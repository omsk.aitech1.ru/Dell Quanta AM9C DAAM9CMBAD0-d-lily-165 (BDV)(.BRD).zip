# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAB0_1: length 34.1
  TOP w0.11: 152.24,107.81 151.79,107.81 150.36,106.37 149.8,106.37 149.5,106.67 148.33,106.67 148.13,106.47 147.28,106.47 v2(146.8,106)
  TOP w0.14: 152.24,107.81 152.56,107.81 152.86,108.12 156.57,108.12 159.04,110.58 159.04,113.38 159.97,114.32 v1(161.53,114.32) 161.53,113.76 162.71,112.59 167.52,112.59 167.72,112.39 168.16,111.95 170.9,111.95 172.21,110.65 v1(172.34,110.65)
  BOTTOM w0.14: U22.R8 147.15,105.65 v2(146.8,106) ; VRAM3.H5 171.92,110.23 v1(172.34,110.65)
MAB0_2: length 33.9
  TOP w0.102: 150.49,107.52 151.92,108.95 ; v2(147.6,107.1) 148.03,107.52 150.37,107.52
  TOP w0.11: 150.37,107.52 150.49,107.52
  TOP w0.14: 151.92,108.95 152.18,109.21 153.03,109.21 153.24,109.01 154.78,109.01 155.09,109.31 155.9,109.31 157.99,111.41 157.99,114.73 159.44,116.17 v1(161.49,116.17) 161.85,116.17 162.85,115.18 162.85,114.31 163.25,113.91 168.24,113.91 168.95,113.2 170.34,113.2 170.72,113.58 v1(170.72,114.59)
  BOTTOM w0.14: U22.N7 147.6,106.9 v2(147.6,107.1) ; v1(170.72,114.59) 171.57,114.59 VRAM3.H11
MAB0_3: length 31.2
  TOP w0.11: 152.24,108.19 151.71,108.19 150.16,106.64 149.88,106.64 149.42,107.1 v2(149.2,107.1)
  TOP w0.14: 152.24,108.19 152.43,108.19 152.81,108.57 154.92,108.57 154.99,108.65 156.17,108.65 158.52,110.99 158.52,114.21 159.37,115.07 161.74,115.07 162.19,114.61 162.19,114.04 162.98,113.25 167.88,113.25 168.23,112.9 v1(168.51,112.61) 170.87,112.61 171.13,112.87 v1(171.13,113.3)
  BOTTOM w0.14: VRAM3.H10 171.92,114.09 v1(171.13,113.3) ; v2(149.2,107.1) 149.2,106.9 U22.N4
MAB0_4: length 34.5
  TOP w0.102: v1(169.92,114.59) 170.32,114.99 170.32,115.54 170.37,115.58
  TOP w0.14: v2(147.52,108.15) 148.2,108.83 150.22,108.83 151.76,110.36 151.76,111.15 152.23,111.62 152.56,111.62 153.06,112.13 154.21,112.13 154.72,112.64 155.57,112.64 156.43,113.5 156.43,115.58 160.58,119.73 v1(165.96,119.73) 168.1,119.73 169.35,118.48 169.35,117.49 170.37,116.47 170.37,115.58
  BOTTOM w0.14: U22.L8 147.15,107.79 147.51,108.15 v2(147.52,108.15) ; v1(169.92,114.59) 170.27,114.94 VRAM3.K11
MAB0_5: length 34.6
  TOP w0.102: 150.53,108.07 150.21,107.75 147.6,107.75 v2(146.95,107.1) ; 167.7,117.49 167.93,117.26 167.93,116.75 168.13,116.55 168.64,116.55 168.69,116.5 168.69,115.87 168.72,115.84 168.72,114.82 168.72,114.37 168.98,114.11 169.48,114.11 v1(169.93,113.66)
  TOP w0.14: 150.53,108.07 152.18,109.72 153.19,109.72 153.45,109.97 155.62,109.97 157.47,111.82 157.47,115.1 159.22,116.85 162.46,116.85 v1(163.07,117.46) 163.98,118.36 167.33,118.36 167.57,118.13 167.57,117.62 167.7,117.49
  BOTTOM w0.14: v2(146.95,107.1) 146.95,106.75 U22.N8 ; VRAM3.K10 170.32,114.05 v1(169.93,113.66)
MAB0_6: length 31.4
  TOP w0.11: 152.01,105.57 147.58,105.57 v2(146.9,104.9)
  TOP w0.14: v1(167.52,109.74) 167.04,110.23 162.48,110.23 161.63,109.38 161.63,108.91 161.49,108.77 161.13,108.77 161,108.64 161,108.16 161.13,108.03 161.41,108.03 161.53,107.9 161.53,107.47 161.41,107.35 161.13,107.35 161,107.22 161,106.81 161.13,106.69 161.43,106.69 161.58,106.53 161.58,106.09 161.35,105.86 156.42,105.86 156.14,105.58 156.14,105.37 155.76,104.99 153.72,104.99 153.14,105.57 152.01,105.57
  BOTTOM w0.14: U22.U8 147.15,104.65 v2(146.9,104.9) ; v1(167.52,109.74) 167.52,110.28 167.77,110.53 169.93,110.53 VRAM3.K5
MAB0_7: length 31.3
  TOP w0.102: 167.88,108.55 168.54,108.55 169.37,109.38 170.41,109.38 v1(170.72,109.7)
  TOP w0.11: 152.43,105.14 150.78,105.14 150.57,105.36 148.11,105.36 v2(147.65,104.9)
  TOP w0.14: 152.43,105.14 152.81,105.14 153.24,104.71 155.27,104.71 155.35,104.64 163.14,104.64 v1(163.36,104.86) 163.36,105.64 162.85,106.16 162.85,107.88 162.97,108.01 163.38,108.01 163.51,108.14 163.51,108.85 163.76,109.11 165,109.11 165.16,108.95 165.16,108.72 165.29,108.6 165.79,108.6 165.92,108.72 165.92,109.11 166.05,109.24 166.17,109.24 166.34,109.4 166.93,109.4 167.78,108.55 167.88,108.55
  BOTTOM w0.14: v1(170.72,109.7) 170.37,109.34 VRAM3.K4 ; v2(147.65,104.9) 147.65,104.65 U22.U7
MAB0_8: length 30.2
  TOP w0.11: v2(149.2,106) 149.39,105.8 150.96,105.8 151.24,106.08 151.93,106.08
  TOP w0.14: v1(170.75,110.58) 170.57,110.58 170.24,110.25 170.06,110.25 169.68,110.63 167.61,110.63 166.98,111.26 162.22,111.26 160.16,109.21 160.16,106.68 159.86,106.38 159.15,106.38 159.01,106.52 159.01,107.04 158.88,107.17 158.58,107.17 158.45,107.04 158.45,106.52 158.31,106.38 158.03,106.38 157.89,106.52 157.89,107.07 157.77,107.19 157.46,107.19 157.33,107.07 157.33,106.52 157.2,106.38 156.05,106.38 155.76,106.08 153.65,106.08 153.32,106.41 152.89,106.41 152.56,106.08 151.93,106.08
  BOTTOM w0.14: VRAM3.J5 171.12,110.33 170.87,110.58 v1(170.75,110.58) ; U22.R4 149.55,105.65 v2(149.2,106)
MAB1_0: length 30.5
  TOP w0.102: 150.7,99.08 150.5,99.27 149.64,99.27 149.44,99.08 147.83,99.08 147.6,99.31 v2(147.6,99.48)
  TOP w0.14: 150.7,99.08 151.56,98.21 153.04,98.21 153.29,97.96 153.47,97.78 154.52,97.78 155.55,96.75 159.82,96.75 v1(160.4,96.16) 161.06,95.5 161.06,94.52 162.19,93.39 166.82,93.39 167.42,92.79 171.08,92.79 171.61,93.32 171.61,93.8 v1(172.31,94.5)
  BOTTOM w0.14: v2(147.6,99.48) 147.6,99.6 U22.AE7 ; VRAM4.K4 171.91,94.9 v1(172.31,94.5)
MAB1_1: length 32.2
  TOP w0.102: v2(146.8,99.4) 146.8,99.34 147.32,98.82 149.53,98.82 149.75,99.05 150.36,99.05 150.91,98.5 150.91,98.29 151.16,98.03
  TOP w0.14: v1(172.31,93.55) 172.31,93.18 171.37,92.25 167.03,92.25 166.55,92.73 161.92,92.73 161.68,92.96 161.47,92.96 161.34,92.84 161.13,92.84 160.87,93.09 160.87,93.3 161,93.43 161,93.64 160.4,94.24 160.4,95.23 159.49,96.13 v1(158.44,96.13) 155.23,96.13 154.25,97.12 153.65,97.12 153.47,97.3 151.9,97.3 151.16,98.03
  BOTTOM w0.14: v1(172.31,93.55) 172.31,93.75 VRAM4.K5 ; v2(146.8,99.4) 146.8,99.6 U22.AE8
MAB1_2: length 29.9
  TOP w0.102: 150.56,97.62 150.27,97.91 148.62,97.91 148.4,98.13 v2(148.4,98.37)
  TOP w0.14: 150.56,97.62 151.67,96.51 152.99,96.51 155.21,94.29 155.77,94.29 155.98,94.5 158.99,94.5 159.17,94.32 159.17,92.92 v1(161.09,91) 170.31,91 171.03,90.28 171.03,89.87 170.92,89.75 v1(170.71,89.75)
  BOTTOM w0.14: U22.AG5 148.75,98.72 v2(148.4,98.37) ; VRAM4.K11 171.83,89.43 171.55,89.43 171.22,89.75 v1(170.71,89.75)
MAB1_3: length 29.4
  TOP w0.102: v2(149.2,98.37) 149.34,98.52 149.53,98.52 149.84,98.82 150.17,98.82 150.52,98.48 150.52,98.16 151.16,97.52
  TOP w0.14: v1(171.06,90.87) 170.23,91.71 165.36,91.71 165.22,91.85 165.22,91.91 165.07,92.07 164.71,92.07 164.56,91.91 164.56,91.85 164.41,91.7 164.05,91.7 163.9,91.85 163.9,91.91 163.75,92.07 163.39,92.07 163.24,91.91 163.24,91.85 163.09,91.7 162.73,91.7 162.58,91.85 162.58,91.91 162.42,92.07 162.07,92.07 161.92,91.91 161.92,91.85 161.76,91.7 161.32,91.7 159.94,93.08 159.94,93.4 160.02,93.47 160.02,93.69 159.74,93.97 v1(159.74,94.47) 159.74,94.91 159.21,95.43 155,95.43 153.97,96.46 153.67,96.46 153.24,96.89 151.79,96.89 151.16,97.52
  BOTTOM w0.14: VRAM4.K10 171.19,90.87 v1(171.06,90.87) ; v2(149.2,98.37) 149.55,98.72 U22.AG4
MAB1_4: length 29.2
  TOP w0.102: 164.38,87.8 164.67,87.8 164.73,87.74 168.62,87.74 169.51,88.63 169.51,89.11 169.91,89.52 v1(169.91,89.75) ; 150.52,96.72 150.44,96.79 149.61,96.79 v2(149.2,97.2)
  TOP w0.14: 150.52,96.72 152.15,95.09 152.3,95.09 155.23,92.16 155.89,92.16 155.99,92.26 155.99,92.56 156.1,92.66 156.45,92.66 156.58,92.54 156.58,92.31 156.73,92.16 157.07,92.16 157.21,92.3 157.21,92.85 157.35,92.99 157.63,92.99 157.76,92.85 157.76,92.32 157.93,92.16 158.26,92.16 v1(162.62,87.8) 164.38,87.8
  BOTTOM w0.14: U22.AJ4 149.38,97.58 149.38,97.38 v2(149.2,97.2) ; VRAM4.H11 v1(169.91,89.75)
MAB1_5: length 30.7
  TOP w0.102: 163.62,88.31 164.51,88.31 164.77,88.56 167.65,88.56 167.89,88.8 167.89,89.1 168.15,89.36 168.52,89.36 168.71,89.54 168.71,89.92 168.95,90.16 169.27,90.16 169.66,90.55 v1(169.91,90.55)
  TOP w0.11: v2(146.8,98.37) 146.8,98.04 147.02,97.82 148.12,97.82 148.29,97.65 150.15,97.65 150.4,97.4
  TOP w0.14: 163.62,88.31 163.29,88.31 162.86,88.74 162.41,88.74 158.48,92.67 158.48,93.43 158.1,93.81 156.28,93.81 155.99,93.52 155.03,93.52 152.43,96.13 151.67,96.13 150.4,97.4
  BOTTOM w0.14: VRAM4.H10 v1(169.91,90.55) ; U22.AG8 146.8,98.5 v2(146.8,98.37)
MAB1_6: length 31.6
  TOP w0.102: v1(169.91,93.57) 170.1,93.76 170.1,94.28 169.97,94.4 169.59,94.4 169.34,94.15 168.7,94.15 168.63,94.22 168.32,94.22 ; v2(147.6,100.45) 147.35,100.45 147.1,100.19 146.97,100.19 146.85,100.07 146.85,99.93 146.99,99.79 147.25,99.79 147.41,99.95 147.74,99.95 147.98,100.19 148.16,100.19 148.41,99.95 149.29,99.95 149.52,99.71 150.8,99.71 151.16,99.35
  TOP w0.14: 168.32,94.22 167.74,94.22 167.21,94.76 167.21,96.31 166.82,96.69 165.02,96.69 164.41,96.08 162.76,96.08 162.63,96.21 162.63,96.64 162.51,96.76 161.66,96.76 161.27,97.16 161.27,97.9 161.13,98.03 v1(160.18,98.03) 156.13,98.03 155.37,98.79 151.72,98.79 151.16,99.35
  BOTTOM w0.14: U22.AC8 147.48,100.72 147.48,100.62 147.6,100.5 v2(147.6,100.45) ; v1(169.91,93.57) 170.31,93.97 VRAM4.H5
MAB1_7: length 30.9
  TOP w0.102: v2(148.4,100.57) 148.4,100.27 148.5,100.17 149.36,100.17 149.56,99.96 151.01,99.96 151.16,99.81 ; v1(170.71,94.54) 171.51,94.54 171.63,94.66 171.63,94.82 171.51,94.94 170.26,94.94 170.23,94.91
  TOP w0.14: 170.23,94.91 170.17,94.85 169.8,94.85 169.61,95.04 168.83,95.04 168.45,94.66 168.07,94.66 167.84,94.88 167.84,96.79 167.21,97.42 164.97,97.42 164.37,96.82 163.35,96.82 163.22,96.94 163.22,97.3 163.09,97.42 162.1,97.42 161.95,97.58 161.95,98.47 161.58,98.83 v1(158.57,98.83) 156.27,98.83 155.98,99.12 151.85,99.12 151.16,99.81
  BOTTOM w0.14: VRAM4.H4 170.71,94.55 v1(170.71,94.54) ; U22.AC5 148.75,100.92 v2(148.4,100.57)
MAB1_8: length 30.3
  TOP w0.102: v2(149.15,99.51) 150.64,99.51 151.16,98.99
  TOP w0.14: v1(171.11,93.53) 171.11,93.97 170.98,94.09 170.61,94.09 170.48,93.97 170.48,93.36 170.25,93.13 168.02,93.13 167.1,94.05 164.77,94.05 164.64,94.17 164.64,94.61 164.51,94.74 164.11,94.74 163.98,94.61 163.98,94.17 163.85,94.05 163.37,94.05 163.24,94.17 163.24,95.29 163.12,95.42 162.61,95.42 162.48,95.29 162.48,94.79 162.35,94.66 161.85,94.66 161.72,94.79 161.72,95.78 159.99,97.5 v1(158.57,97.5) 155.73,97.5 154.79,98.44 153.29,98.44 153.24,98.49 151.66,98.49 151.16,98.99
  BOTTOM w0.14: U22.AE4 149.55,99.9 v2(149.15,99.51) ; VRAM4.J5 v1(171.11,93.53)
MB_ZVDDIO: length 9.5
  BOTTOM w0.102: R464.2 75.85,85.1 74.61,85.1 v1(74.13,85.58) 74.13,85.96 75.14,86.97 75.14,90.08 75.36,90.29 75.36,90.77 75.35,90.77 75.35,91.4 U18.AF32
MDI0+: length 28.6
  TOP w0.102: v1(269.48,106.96) 269.38,107.07 268.8,107.07 C215.1 268.09,107 267.72,107 EC12.2 ; v1(272.66,92.36) 272.48,92.18 U2.1
  IN1 w0.081: v1(269.48,106.96) 269.25,106.96 269.2,107.01 269.2,107.29 269.14,107.34 268.87,107.34 267.39,105.87 267.39,94.34 269.29,92.45 270.28,92.45 271.09,93.25 271.94,93.25 272.43,92.77 272.43,92.51 272.58,92.36 v1(272.66,92.36)
  BOTTOM w0.102: U12.11 268.22,106.66 268.74,107.18 269.27,107.18 v1(269.48,106.96)
MDI0-: length 28.6
  TOP w0.102: EC11.2 267.71,107.31 268.1,107.31 C199.1 268.66,107.38 269.25,107.38 v1(269.48,107.61) ; v1(272.01,92.36) 272.17,92.2 272.17,91.12 272.08,91.03 U2.2
  IN1 w0.081: v1(269.48,107.61) 268.75,107.61 267.12,105.98 267.12,94.23 269.18,92.17 270.39,92.17 271.2,92.98 271.83,92.98 272.16,92.65 272.16,92.51 v1(272.01,92.36)
  BOTTOM w0.102: v1(269.48,107.61) 269.36,107.49 268.66,107.49 268.21,107.93 U12.12
MDI1+: length 28.7
  TOP w0.102: EC14.2 267.4,102.27 267.58,102.45 267.93,102.45 C287.1 268.42,102.31 268.55,102.44 269.28,102.44 v1(269.45,102.27) ; U2.4 271.28,91.05 271.23,91.1 271.23,92.01 270.94,92.3 270.94,93.41 270.68,93.68 270.33,93.68 v1(270.16,93.84)
  IN1 w0.081: v1(269.45,102.27) 269.4,102.22 269.18,102.22 269.02,102.37 269.02,102.59 268.97,102.64 268.83,102.64 268.61,102.87 268.61,104.21 268.54,104.27 268.23,104.27 268.13,104.18 268.13,100.72 268.21,100.64 268.71,100.64 268.95,100.4 268.95,99.75 268.71,99.51 268.21,99.51 268.13,99.43 268.13,99 268.21,98.92 268.71,98.92 268.95,98.68 268.95,98.03 268.71,97.78 268.21,97.78 268.13,97.7 268.13,97.28 268.21,97.2 268.71,97.2 268.95,96.96 268.95,96.3 268.71,96.06 268.21,96.06 268.13,95.98 268.13,95 269.51,93.63 269.94,93.63 v1(270.16,93.84)
  BOTTOM w0.102: v1(269.45,102.27) 269.25,102.47 269,102.47 268.63,102.1 268.27,102.1 267.75,101.58 U12.7
MDI1-: length 28.7
  TOP w0.102: v1(269.45,102.91) 269.29,102.75 268.53,102.75 268.42,102.86 C254.1 267.95,102.75 267.54,102.75 267.4,102.9 EC13.2 ; U2.5 270.88,91.04 270.92,91.08 270.92,91.88 270.64,92.17 270.64,93.29 270.55,93.37 270.34,93.37 v1(270.16,93.2)
  IN1 w0.081: v1(270.16,93.2) 270,93.36 269.4,93.36 267.86,94.89 267.86,96.09 268.1,96.33 268.6,96.33 268.68,96.42 268.68,96.84 268.6,96.92 268.1,96.92 267.86,97.16 267.86,97.82 268.1,98.06 268.6,98.06 268.68,98.14 268.68,98.56 268.6,98.65 268.1,98.65 267.86,98.89 267.86,99.54 268.1,99.78 268.6,99.78 268.68,99.86 268.68,100.29 268.6,100.37 268.1,100.37 267.86,100.61 267.86,104.29 268.12,104.55 268.65,104.55 268.88,104.32 268.88,102.98 268.94,102.91 v1(269.45,102.91)
  BOTTOM w0.102: U12.8 267.83,102.85 268.27,102.41 268.5,102.41 268.87,102.78 269.31,102.78 v1(269.45,102.91)
MDI2+: length 28.7
  TOP w0.102: C310.1 267.4,98.22 267.55,98.37 267.95,98.37 EC16.2 268.42,98.19 268.69,98.46 268.9,98.46 269.28,98.84 269.61,98.84 v1(269.66,98.79) ; v1(267.67,91.86) 267.76,91.76 268.48,91.76 268.92,92.21 269.71,92.21 270.48,91.44 U2.6
  IN3 w0.102: v1(269.66,98.79) 269.42,98.79 269.33,98.88 269.33,99.09 269.26,99.16 269,99.16 268.44,99.72 268.44,102.82 268.25,103.01 267.54,103.01 267.22,102.69 267.22,91.76 267.33,91.64 267.45,91.64 v1(267.67,91.86)
  BOTTOM w0.102: v1(269.66,98.79) 269.66,98.9 269.54,99.02 269.02,99.02 268.46,99.58 268.29,99.58 267.75,99.04 U12.5
MDI2-: length 28.7
  TOP w0.102: v1(269.66,99.43) 269.37,99.15 269.16,99.15 268.78,98.76 268.57,98.76 268.42,98.92 EC15.2 267.93,98.68 267.57,98.68 267.4,98.84 C302.1 ; U2.7 270.08,91.41 269.58,91.91 269.05,91.91 268.6,91.46 267.92,91.46 v1(267.67,91.21)
  IN3 w0.102: v1(267.67,91.21) 267.51,91.36 267.22,91.36 266.94,91.64 266.94,102.81 267.43,103.29 268.36,103.29 268.72,102.94 268.72,99.83 269.12,99.43 v1(269.66,99.43)
  BOTTOM w0.102: U12.6 267.83,100.31 268.25,99.89 268.58,99.89 269.14,99.33 269.55,99.33 v1(269.66,99.43)
MDI3+: length 28.6
  TOP w0.102: C336.1 267.4,94.14 267.58,94.32 267.94,94.32 EC18.2 268.91,94.34 269.41,94.34 v1(269.59,94.16) ; U2.9 268.44,89.8 268.39,89.75 268.01,89.75 267.89,89.88 267.89,89.95 268.02,90.08 268.2,90.08 268.71,90.59 268.71,90.88 268.78,90.95 v1(268.92,90.95)
  IN3 w0.102: v1(269.59,94.16) 269.59,94.04 269.47,93.92 269.27,93.92 269.1,94.09 269.1,94.48 269.05,94.53 268.95,94.53 268.64,94.84 268.64,95.42 268.98,95.76 268.98,96.09 268.64,96.42 268.64,97.07 268.9,97.33 270.14,97.33 270.27,97.46 270.27,97.88 270.13,98.02 268.77,98.02 268.52,98.28 268.52,98.56 268.23,98.85 268.1,98.85 267.99,98.74 267.99,93.3 268.08,93.21 269.48,93.21 269.99,92.7 269.99,92.26 269.74,92.01 269.06,92.01 268.55,91.5 268.55,91.3 268.72,91.13 268.72,91.01 268.78,90.95 v1(268.92,90.95)
  BOTTOM w0.102: U12.1 268.23,93.96 268.64,94.37 269.38,94.37 v1(269.59,94.16)
MDI3-: length 28.6
  TOP w0.102: v1(269.59,94.81) 269.41,94.64 268.87,94.64 C323.1 267.94,94.62 267.55,94.62 267.4,94.77 EC17.2 ; U2.10 268.43,89.4 268.38,89.45 267.89,89.45 267.58,89.75 267.58,90.08 267.89,90.39 268.07,90.39 268.4,90.72 268.4,90.82 v1(268.27,90.95)
  IN3 w0.102: v1(268.27,90.95) 268.27,91.62 268.94,92.29 269.63,92.29 269.71,92.37 269.71,92.58 269.37,92.93 267.96,92.93 267.71,93.19 267.71,98.85 267.98,99.13 268.34,99.13 268.8,98.68 268.8,98.4 268.89,98.3 270.25,98.3 270.55,98 270.55,97.34 270.26,97.05 269.01,97.05 268.92,96.96 268.92,96.54 269.25,96.2 269.25,95.65 268.92,95.31 268.92,94.96 269.07,94.81 v1(269.59,94.81)
  BOTTOM w0.102: U12.2 268.29,95.23 268.84,94.68 269.45,94.68 v1(269.59,94.81)
MEM_CALRA: length 24.9
  TOP w0.381: v1(141.55,129.82) 141.29,129.56 R666.2
  IN1 w0.381: v1(141.55,129.82) 141.2,129.47 141.2,120.59 141.69,120.1 141.94,119.85 141.94,113.91 143.69,112.16 143.69,108.09 v1(144.08,107.69)
  BOTTOM w0.381: U22.K15 143.65,108.12 v1(144.08,107.69)
MEM_CALRB: length 28.3
  IN1 w0.305: v1(145.85,104.69) 146.61,105.45 149.71,105.45 149.9,105.64
  IN1 w0.381: 149.9,105.64 150.78,106.52 150.78,111.25 151.96,112.43 152.61,112.43 153.58,113.4 155.37,113.4 155.86,113.89 155.86,117.12 v1(160.69,121.95)
  BOTTOM w0.381: v1(145.85,104.69) 146.35,105.19 U22.R10 ; R667.2 v1(160.69,121.95)
MEM_MA1_CS#0: length 1.6
  TOP w0.114: v1(77.61,93.26) 78.04,92.83 TP108.1
  BOTTOM w0.178: U18.AH29 77.25,93.62 v1(77.61,93.26)
MEM_MA1_CS#1: length 1.5
  TOP w0.114: v1(79.15,94.09) 78.76,94.48 TP109.1
  BOTTOM w0.178: v1(79.15,94.09) 79.56,94.5 U18.AL28
MEM_MA1_ODT0: length 2.7
  TOP w0.114: TP106.1 76.33,96.26 76.25,96.34 76.25,97.08 v1(76.61,97.45)
  BOTTOM w0.114: U18.AH25 77.16,96.9 v1(76.61,97.45)
MEM_MA1_ODT1: length 1.5
  TOP w0.114: TP107.1 78.74,96.57 v1(79.06,96.57)
  BOTTOM w0.114: U18.AL25 79.39,96.9 v1(79.06,96.57)
MEM_MA_ACT#: length 59.4
  IN4 w0.127: v1(67.02,96.7) 66.97,96.75 65.74,96.75 65.2,96.21 65.2,90.1 64.57,89.47 64.57,88.84 63.99,88.26 63.99,86.36 64.77,85.58 64.77,68.8 62.42,66.45 62.42,57.07 63.11,56.38 63.11,55.73 62.98,55.61 62.75,55.61 62.62,55.48 62.62,55.22 62.75,55.1 62.98,55.1 63.11,54.97 63.11,52.58 63.64,52.05 63.64,49.11 65.17,47.58 v1(66.43,47.58)
  BOTTOM w0.178: v1(66.43,47.58) 67.3,46.72 67.3,45.97 67.48,45.78 CN16.114 ; U18.T25 67.45,96.7 v1(67.02,96.7)
MEM_MB_ACT#: length 38.3
  IN1 w0.127: v1(67.3,58.81) 66.76,59.34 66.76,61.04 65.56,62.24 65.56,67.15 65.87,67.46 65.87,83.45 65.08,84.24 65.08,87.56 66.91,89.39 v1(68.71,89.39)
  BOTTOM w0.102: v1(68.71,89.39) 68.71,90.03 68.97,90.29 68.97,90.29 68.99,90.31 68.99,90.69 68.97,90.71 68.97,90.71 68.94,90.75 68.94,91.1 69.25,91.42 U18.V32
  BOTTOM w0.178: CN17.114 67.48,58.63 v1(67.3,58.81)
MF_A0: length 3.4
  BOTTOM w0.152: VRAM1.J1 139.42,133.42 139.64,133.19 R784.1
MF_A1: length 3.4
  BOTTOM w0.152: VRAM2.J1 142.77,133.44 142.57,133.24 R785.1
MF_B0: length 2.4
  TOP w0.152: v1(170.96,105.37) 170.89,105.3 R786.1
  BOTTOM w0.152: VRAM3.J1 170.96,106.78 v1(170.96,105.37)
MF_B1: length 1.7
  TOP w0.152: R787.1 170.62,98.59 171.12,98.08 v1(171.12,97.91)
  BOTTOM w0.152: v1(171.12,97.91) 171.12,97.36 VRAM4.J1
MVREFDA: length 27.4
  TOP w0.381: v1(141.55,131.29) 141.43,131.42 C1231.1 R664.2 139.81,130.79 139.84,130.76 R670.1
  IN1 w0.381: v1(142,108.67) 141.42,109.26 141.42,119.64 140.68,120.38 140.68,130.76 141.21,131.29 v1(141.55,131.29)
  BOTTOM w0.381: U22.K17 142.52,108.15 v1(142,108.67)
MVREFDB: length 31.3
  IN1 w0.305: v1(146.89,103.82) 146.89,103.95 147.29,104.35 150.37,104.35 150.59,104.57
  IN1 w0.381: 150.59,104.57 151.3,105.28 151.3,111.03 152.12,111.85 153.9,111.85 154.76,112.7 155.64,112.7 156.55,113.62 156.55,116.64 v1(161.84,121.93)
  BOTTOM w0.3: U22.U10 146.88,103.82 v1(146.89,103.82)
  BOTTOM w0.381: R665.2 R673.1 C1232.1 v1(161.84,121.93)
MX0: length 225.8
  TOP w0.114: v1(231.67,7.87) 232.37,8.56 U34.58 ; CN2.22 32.74,44.93 32.91,44.76 32.91,44.32 33.56,43.67 33.71,43.67 EC74.1 v1(33.59,42.79)
  IN1 w0.089: v1(231.67,7.87) 230.46,6.65 213.08,6.65 203.6,16.13 200.39,16.13 199.74,16.79 197.86,16.79 197.2,16.13 184.42,16.13 181.25,19.3 155.85,19.3 155.62,19.07 146.15,19.07 145.86,19.36 140.64,19.36 139.68,18.39 128.34,18.39 127.5,17.56 121.71,17.56 120.13,15.97 116.42,15.97 115.66,16.73 114.38,16.73 114.23,16.88 111.42,16.88 110.27,18.03 109.19,18.03 107.28,19.94 104.36,19.94 103.68,20.63 102.54,20.63 98.14,25.02 60.26,25.02 54.49,30.8 43.71,30.8 36.84,37.66 36.84,41.78 35.83,42.79 v1(33.59,42.79)
MX1: length 224
  TOP w0.114: v1(34.47,40.48) 34.09,40.87 EC76.1 34.09,41.33 32.89,42.53 32.89,43.15 32.71,43.33 CN2.24 ; U34.59 232.77,8.02 v1(232.55,7.8)
  IN1 w0.089: v1(34.47,40.48) 35.55,40.48 36.39,39.64 36.39,37.47 43.52,30.34 54.3,30.34 60.07,24.57 97.95,24.57 102.35,20.17 103.49,20.17 104.17,19.49 107.09,19.49 109,17.58 110.08,17.58 111.23,16.42 114.04,16.42 114.19,16.28 115.47,16.28 116.3,15.44 123.05,15.44 124.37,16.77 127.36,16.77 128.53,17.94 139.87,17.94 140.84,18.91 145.67,18.91 145.96,18.62 155.81,18.62 156.04,18.84 181.06,18.84 184.23,15.67 203.41,15.67 212.89,6.2 230.94,6.2 v1(232.55,7.8)
MX2: length 224.2
  TOP w0.114: CN2.26 32.76,41.73 33.31,41.18 33.31,40.75 33.67,40.39 33.67,39.39 34.09,38.97 EC78.1 34.09,38.6 v1(34.48,38.21) ; v1(233.46,7.78) 233.17,8.08 U34.60
  IN1 w0.089: v1(233.46,7.78) 233.46,7.52 231.68,5.74 212.7,5.74 203.22,15.21 184.04,15.21 180.87,18.38 156.23,18.38 156,18.16 145.77,18.16 145.48,18.45 141.04,18.45 140.07,17.48 128.72,17.48 127.55,16.31 124.56,16.31 123.24,14.99 116.11,14.99 115.28,15.82 114,15.82 113.85,15.96 111.04,15.96 109.89,17.12 108.7,17.12 106.79,19.03 103.99,19.03 103.3,19.71 102.16,19.71 97.76,24.11 59.88,24.11 54.11,29.88 43.33,29.88 35.93,37.28 35.93,37.82 35.54,38.21 v1(34.48,38.21)
MX3: length 226.1
  TOP w0.114: v1(233.72,8.69) 233.57,8.84 U34.61 ; v1(34.47,41.62) 34.09,42 EC75.1 33.57,42.19 33.15,42.61 33.15,43.73 32.76,44.13 CN2.23
  IN1 w0.089: v1(233.72,8.69) 232.78,8.69 232.11,8.03 232.11,7.69 230.85,6.42 212.98,6.42 203.51,15.9 200.3,15.9 199.64,16.56 197.96,16.56 197.3,15.9 184.32,15.9 181.15,19.07 155.94,19.07 155.72,18.84 146.05,18.84 145.76,19.13 140.74,19.13 139.77,18.17 128.44,18.17 127.6,17.33 121.81,17.33 120.15,15.67 116.39,15.67 115.56,16.5 114.28,16.5 114.14,16.65 111.33,16.65 110.17,17.81 109.1,17.81 107.19,19.72 104.27,19.72 103.59,20.4 102.44,20.4 98.04,24.8 60.17,24.8 54.39,30.57 43.62,30.57 36.62,37.57 36.62,40.56 35.55,41.62 v1(34.47,41.62)
MX4: length 224.4
  TOP w0.114: U34.62 233.97,9.13 234.16,8.94 234.16,7.78 v1(234.15,7.78) ; v1(34.48,37.09) 34.09,37.47 EC80.1 33.65,38.09 33.65,39.07 33.41,39.3 33.41,40.24 32.72,40.93 CN2.27
  IN1 w0.089: v1(34.48,37.09) 35.8,37.09 44.56,28.33 48.9,28.33 49.77,27.46 50.5,27.46 51.62,26.33 56.46,26.33 58.91,23.88 97.67,23.88 102.06,19.48 103.21,19.48 103.9,18.79 106.71,18.79 108.61,16.89 109.79,16.89 110.95,15.74 113.76,15.74 113.91,15.59 115.18,15.59 116.02,14.76 123.33,14.76 124.65,16.08 127.64,16.08 128.81,17.25 140.16,17.25 141.13,18.22 145.39,18.22 145.68,17.93 156.1,17.93 156.32,18.16 180.77,18.16 183.94,14.98 203.13,14.98 212.6,5.51 231.88,5.51 v1(234.15,7.78)
MX5: length 225.3
  TOP w0.114: CN2.25 32.55,42.53 33.62,41.46 33.62,40.82 33.93,40.51 33.93,40.12 34.09,39.96 EC77.1 34.09,39.61 34.36,39.35 v1(34.48,39.35) ; v1(234.59,8.67) 234.59,8.89 234.37,9.11 U34.63
  IN1 w0.089: v1(234.59,8.67) 234.16,8.23 233.3,8.23 233.01,7.94 233.01,7.57 231.4,5.97 212.79,5.97 203.32,15.44 184.13,15.44 180.96,18.61 156.13,18.61 155.91,18.39 145.86,18.39 145.58,18.68 140.94,18.68 139.97,17.71 128.62,17.71 127.45,16.54 124.46,16.54 123.14,15.22 116.21,15.22 115.37,16.05 114.09,16.05 113.95,16.19 111.14,16.19 109.98,17.35 108.8,17.35 106.89,19.26 104.08,19.26 103.4,19.94 102.25,19.94 97.85,24.34 59.98,24.34 54.2,30.11 43.43,30.11 36.16,37.38 36.16,38.74 35.56,39.35 v1(34.48,39.35)
MX6: length 225.4
  TOP w0.114: U34.64 234.77,9.12 235.03,8.85 235.03,7.97 v1(234.84,7.78) ; CN2.28 32.86,40.13 33.16,39.83 33.16,39.22 33.4,38.97 33.4,37.21 EC81.1 34.09,36.34 v1(34.48,35.95)
  IN1 w0.089: v1(234.84,7.78) 232.34,5.28 212.51,5.28 203.03,14.76 183.85,14.76 180.68,17.92 156.41,17.92 156.19,17.7 145.58,17.7 145.29,17.99 141.23,17.99 140.26,17.02 128.91,17.02 127.74,15.85 124.75,15.85 123.43,14.53 115.92,14.53 115.09,15.36 113.81,15.36 113.66,15.51 109.67,15.51 106.62,18.56 103.81,18.56 103.11,19.25 101.97,19.25 97.57,23.65 58.82,23.65 56.36,26.11 51.53,26.11 50.4,27.23 49.68,27.23 48.81,28.1 44.46,28.1 36.61,35.95 v1(34.48,35.95)
MX7: length 229.9
  TOP w0.114: v1(36.14,34.85) 34.43,34.85 34.09,35.2 EC79.1 34.09,35.69 33.16,36.62 33.16,38.87 32.71,39.33 CN2.29 ; U34.65 237.81,11.81 v1(237.91,11.71)
  IN1 w0.089: v1(36.14,34.85) 37.39,34.85 44.37,27.88 48.71,27.88 49.58,27 50.31,27 51.43,25.88 56.27,25.88 58.72,23.42 97.48,23.42 102.57,18.33 106.52,18.33 109.57,15.28 113.57,15.28 113.72,15.13 114.99,15.13 115.83,14.3 123.52,14.3 124.84,15.62 127.83,15.62 129,16.79 140.35,16.79 141.32,17.76 145.2,17.76 145.49,17.47 156.29,17.47 156.51,17.7 180.58,17.7 183.75,14.53 202.94,14.53 212.41,5.05 232.85,5.05 237.91,10.11 v1(237.91,11.71)
MY0: length 219.8
  TOP w0.114: CN2.13 32.71,52.13 33.16,52.58 EC65.1 34.09,52.32 33.88,52.11 v1(33.57,52.11) ; v1(223.38,8.95) 223.57,9.13 U34.36
  IN1 w0.089: v1(223.38,8.95) 222.95,9.38 213.89,9.38 203.75,19.52 183.93,19.52 182.1,21.36 166.96,21.36 166.05,22.26 155.9,22.26 154.77,21.13 147.04,21.13 146.75,21.42 139.78,21.42 138.81,20.45 131.57,20.45 130.91,21.12 128.15,21.12 126.7,19.66 115.96,19.66 114.77,20.85 113,20.85 111.85,22 105.39,22 104.71,22.68 104.54,22.68 104.53,22.68 103.39,22.68 97.55,28.53 64.8,28.53 60.48,32.85 44.65,32.85 38.9,38.61 38.9,43.69 34.79,47.8 34.79,50.08 33.88,51 33.88,51.8 v1(33.57,52.11)
MY1: length 219.5
  TOP w0.114: v1(33.44,50.07) 33.9,50.07 34.09,50.26 EC67.1 32.91,50.55 32.88,50.53 CN2.15 ; v1(222.44,8.54) 222.52,8.46 223.76,8.46 223.97,8.67 U34.37
  IN1 w0.089: v1(222.44,8.54) 222.16,8.25 213.74,8.25 202.93,19.06 183.75,19.06 181.91,20.9 166.77,20.9 165.92,21.75 159.6,21.75 158.75,20.9 155.18,20.9 154.96,20.67 146.81,20.67 146.52,20.96 139.97,20.96 139,19.99 131.38,19.99 130.72,20.66 128.34,20.66 126.86,19.18 115.79,19.18 114.58,20.39 112.81,20.39 111.66,21.54 105.03,21.54 104.34,22.23 103.2,22.23 97.36,28.07 59.48,28.07 55.15,32.4 44.46,32.4 38.44,38.42 38.44,43.5 34.33,47.61 34.33,49.17 v1(33.44,50.07)
MY2: length 220.5
  TOP w0.114: v1(33.44,51.11) 33.85,51.11 34.09,51.35 EC66.1 32.98,51.57 32.74,51.33 CN2.14 ; v1(224.47,8.97) 224.37,9.08 U34.38
  IN1 w0.089: v1(224.47,8.97) 223.94,8.44 223.2,8.44 222.49,9.15 213.17,9.15 203.03,19.29 183.84,19.29 182,21.13 166.86,21.13 166.01,21.98 159.5,21.98 158.65,21.13 155.09,21.13 154.86,20.9 146.91,20.9 146.62,21.19 139.87,21.19 138.91,20.22 131.48,20.22 130.81,20.89 128.25,20.89 126.79,19.43 115.86,19.43 114.67,20.62 112.91,20.62 111.76,21.77 105.12,21.77 104.44,22.46 103.29,22.46 97.45,28.3 59.57,28.3 55.25,32.63 44.56,32.63 38.67,38.51 38.67,43.6 34.56,47.71 34.56,49.99 v1(33.44,51.11)
MY3: length 219.8
  TOP w0.114: v1(33.42,49.1) 33.87,49.1 34.09,49.32 EC68.1 33.19,49.54 32.99,49.73 CN2.16 ; v1(224.47,8.28) 224.92,8.73 224.92,9.23 224.77,9.39 U34.39
  IN1 w0.089: v1(224.47,8.28) 224.22,8.02 213.65,8.02 202.84,18.84 183.65,18.84 181.82,20.67 166.67,20.67 165.82,21.52 159.69,21.52 158.84,20.67 155.28,20.67 155.05,20.44 146.72,20.44 146.43,20.73 140.06,20.73 139.09,19.77 131.29,19.77 130.62,20.43 128.44,20.43 126.96,18.95 115.7,18.95 114.48,20.17 112.72,20.17 112.23,20.66 110.41,20.66 109.75,21.32 104.93,21.32 104.25,22 103.11,22 97.26,27.84 59.38,27.84 55.06,32.17 44.37,32.17 38.22,38.32 38.22,43.41 34.11,47.52 34.11,48.41 v1(33.42,49.1)
MY4: length 220.2
  TOP w0.114: v1(225.85,7.83) 225.64,7.83 225.17,8.3 U34.40 ; CN2.20 32.63,46.53 33.26,45.9 33.67,45.9 EC72.1 33.99,45.37 v1(33.44,45.37)
  IN1 w0.089: v1(225.85,7.83) 225.13,7.11 213.27,7.11 202.46,17.92 183.27,17.92 181.44,19.76 155.66,19.76 155.43,19.53 146.34,19.53 146.05,19.82 140.45,19.82 139.48,18.85 130.91,18.85 130.24,19.52 128.82,19.52 127.31,18.01 115.73,18.01 115.06,17.34 111.61,17.34 110.46,18.49 109.38,18.49 107.96,19.92 107.47,20.4 104.55,20.4 103.87,21.08 102.73,21.08 98.33,25.48 60.45,25.48 54.68,31.25 43.99,31.25 37.3,37.94 37.3,42.92 34.86,45.37 v1(33.44,45.37)
MY5: length 220.4
  TOP w0.114: CN2.21 32.74,45.73 32.96,45.51 32.96,45.23 33.26,44.93 33.88,44.93 34.09,44.72 EC73.1 v1(33.47,44.38) ; U34.41 225.57,9.38 225.46,9.28 225.46,8.51 225.69,8.29 226.04,8.29 v1(226.49,7.83)
  IN1 w0.089: v1(226.49,7.83) 225.55,6.88 213.17,6.88 202.36,17.69 183.18,17.69 181.34,19.53 155.75,19.53 155.53,19.3 146.24,19.3 145.95,19.59 140.54,19.59 139.58,18.62 128.25,18.62 127.41,17.79 119.74,17.79 119.62,17.66 115.77,17.66 115.21,17.11 111.52,17.11 110.36,18.26 109.29,18.26 107.73,19.82 107.38,20.17 104.46,20.17 103.78,20.85 102.63,20.85 98.23,25.25 60.36,25.25 54.58,31.02 43.8,31.02 37.07,37.76 37.07,42.27 35.67,43.67 34.18,43.67 v1(33.47,44.38)
MY6: length 219.8
  TOP w0.114: U34.42 225.97,8.81 v1(225.91,8.76) ; v1(33.47,47.27) 33.86,47.27 EC70.1 33.86,47.73 33.29,47.73 32.89,48.13 CN2.18
  IN1 w0.089: v1(225.91,8.76) 225.78,8.76 225.13,8.11 225.13,7.96 224.74,7.57 213.46,7.57 202.65,18.38 183.46,18.38 181.63,20.21 166.46,20.21 165.62,21.06 159.9,21.06 159.05,20.21 155.47,20.21 155.24,19.99 146.53,19.99 146.24,20.28 140.25,20.28 139.28,19.31 131.1,19.31 130.43,19.98 128.63,19.98 127.15,18.49 115.51,18.49 115.21,18.78 110.81,18.78 110.64,18.95 109.57,18.95 107.66,20.86 104.74,20.86 104.06,21.54 102.92,21.54 98.52,25.94 60.64,25.94 54.87,31.71 44.18,31.71 37.76,38.13 37.76,43.22 33.7,47.27 v1(33.47,47.27)
MY7: length 221.5
  TOP w0.114: v1(33.45,46.33) 33.94,46.33 EC71.1 33.76,46.82 33.29,46.82 32.77,47.33 CN2.19 ; U34.43 226.37,8.61 v1(227.15,7.83)
  IN1 w0.089: v1(33.45,46.33) 34.32,46.33 37.53,43.12 37.53,38.04 44.08,31.48 54.77,31.48 60.54,25.71 98.42,25.71 102.82,21.31 103.96,21.31 104.65,20.63 107.57,20.63 109.48,18.72 110.55,18.72 110.71,18.56 115.12,18.56 115.43,18.24 127.22,18.24 128.72,19.75 130.34,19.75 131,19.08 139.38,19.08 140.35,20.05 146.14,20.05 146.43,19.76 155.34,19.76 155.56,19.98 181.53,19.98 183.37,18.15 202.55,18.15 213.36,7.34 224.83,7.34 225.36,7.87 225.36,7.96 225.72,8.32 226.66,8.32 v1(227.15,7.83)
MY8: length 221.7
  TOP w0.114: CN2.17 32.93,48.93 33.2,48.66 33.95,48.66 EC69.1 33.79,48.21 v1(33.44,48.21) ; U34.44 226.77,8.86 v1(226.89,8.74)
  IN1 w0.089: v1(226.89,8.74) 226.43,9.2 225.73,9.2 224.9,8.37 224.9,8.06 224.64,7.8 213.55,7.8 202.74,18.61 183.56,18.61 181.72,20.44 166.58,20.44 165.73,21.29 159.8,21.29 158.95,20.44 155.37,20.44 155.15,20.22 146.62,20.22 146.33,20.51 140.16,20.51 139.19,19.54 131.19,19.54 130.53,20.2 128.53,20.2 127.05,18.72 115.6,18.72 114.39,19.94 112.62,19.94 112.13,20.43 110.32,20.43 109.66,21.09 104.84,21.09 104.15,21.77 103.01,21.77 97.17,27.61 59.29,27.61 54.96,31.94 44.27,31.94 37.99,38.23 37.99,43.31 33.88,47.42 33.88,47.78 v1(33.44,48.21)
MY9: length 229.5
  TOP w0.114: v1(226.62,11.36) 226.76,11.36 227.17,10.95 U34.45 ; CN2.7 32.71,56.93 32.88,57.11 32.88,57.55 33.13,57.8 33.13,58.29 33.62,58.78 EC56.1 34.09,58.44 33.74,58.09 v1(33.57,58.09)
  IN1 w0.089: v1(33.57,58.09) 35.25,56.41 35.25,51.56 36.16,50.65 36.16,48.37 40.32,44.21 40.32,39.12 45.22,34.23 61.08,34.23 65.41,29.9 97.55,29.9 98.11,29.9 102.81,25.2 105.65,25.2 106.18,24.67 106.18,24.31 106.44,24.05 108.38,24.05 108.88,23.56 113.19,23.56 114.53,22.22 115.39,22.22 116.58,21.03 126.08,21.03 127.54,22.49 131.47,22.49 132.14,21.82 138.24,21.82 139.21,22.79 147.7,22.79 148.37,23.46 155.07,23.46 155.89,24.28 163.25,24.28 163.8,23.74 166.51,23.74 167.31,22.95 169.91,22.95 170.71,23.74 172.27,23.74 173.28,22.73 184.15,22.73 185.28,21.6 203.61,21.6 213.15,12.05 225.92,12.05 v1(226.62,11.36)
MY10: length 232.5
  TOP w0.114: v1(33.35,60.39) 33.83,60.39 34.09,60.65 EC54.1 33.13,60.89 32.89,60.64 32.89,58.73 32.68,58.53 CN2.5 ; U34.46 227.57,11.36 v1(227.5,11.43)
  IN1 w0.089: v1(33.35,60.39) 33.87,60.39 36.62,57.64 36.62,48.56 40.78,44.4 40.78,39.31 45.41,34.68 61.28,34.68 65.6,30.36 97.36,30.36 97.36,30.36 98.3,30.36 102.95,25.71 107.37,25.71 109.07,24.01 113.38,24.01 114.72,22.68 118.89,22.68 120.08,21.49 125.89,21.49 127.35,22.95 131.66,22.95 132.33,22.28 138.05,22.28 139.02,23.25 147.51,23.25 148.18,23.92 152.14,23.92 152.96,24.74 163.44,24.74 163.99,24.2 172.46,24.2 173.47,23.19 184.34,23.19 185.47,22.06 203.8,22.06 213.34,12.51 226.48,12.51 227.5,11.5 v1(227.5,11.43)
MY11: length 233.8
  TOP w0.114: CN2.6 32.72,57.73 32.89,57.9 32.89,58.39 34.09,59.6 EC55.1 33.68,59.87 v1(33.35,59.54) ; v1(229.57,11.42) 229.57,11.03 229.57,11.03 U34.51
  IN1 w0.089: v1(33.35,59.54) 36.39,56.5 36.39,48.46 40.55,44.3 40.55,39.22 45.32,34.45 61.18,34.45 65.5,30.13 97.45,30.13 98.21,30.13 102.91,25.43 107.33,25.43 108.97,23.79 113.29,23.79 114.62,22.45 118.8,22.45 119.99,21.26 125.98,21.26 127.44,22.72 131.57,22.72 132.24,22.05 138.15,22.05 139.12,23.02 147.61,23.02 148.28,23.69 154.97,23.69 155.79,24.51 163.35,24.51 163.89,23.97 166.61,23.97 167.4,23.18 169.82,23.18 170.61,23.97 172.36,23.97 173.37,22.96 184.25,22.96 185.37,21.83 203.7,21.83 213.25,12.28 226.32,12.28 227.06,11.55 227.06,11.21 227.28,10.99 229.13,10.99 229.57,11.43 v1(229.57,11.42)
MY12: length 227.6
  TOP w0.114: CN2.12 32.8,52.93 33.47,53.6 EC62.1 34.09,53.31 33.85,53.07 v1(33.56,53.07) ; v1(230.02,8.72) 229.97,8.77 U34.52
  IN1 w0.089: v1(33.56,53.07) 34.11,52.52 34.11,51.09 35.02,50.18 35.02,47.9 39.13,43.79 39.13,38.7 44.75,33.08 60.57,33.08 64.9,28.76 97.64,28.76 103.48,22.91 104.63,22.91 104.63,22.91 107.91,22.91 108.4,22.41 111.76,22.41 113.1,21.08 114.86,21.08 116.05,19.89 126.6,19.89 128.06,21.35 131,21.35 131.67,20.68 138.72,20.68 139.68,21.65 146.85,21.65 147.14,21.36 154.58,21.36 155.71,22.49 166.15,22.49 167.05,21.58 182.19,21.58 184.03,19.75 203.84,19.75 212.68,10.91 224.41,10.91 225.53,9.8 228.94,9.8 v1(230.02,8.72)
MY13: length 231.3
  TOP w0.114: v1(230.47,11.45) 230.37,11.34 U34.53 ; CN2.9 32.75,55.33 33.04,55.62 33.04,56.3 33.34,56.59 EC59.1 34.09,56.43 33.77,56.11 v1(33.48,56.11)
  IN1 w0.089: v1(33.48,56.11) 34.79,54.8 34.79,51.37 35.71,50.46 35.71,48.18 39.82,44.07 39.82,38.98 45.03,33.77 60.89,33.77 65.09,29.58 65.22,29.44 97.92,29.44 103.77,23.6 104.91,23.6 104.91,23.6 108.19,23.6 108.69,23.1 113.01,23.1 114.34,21.77 115.16,21.77 116.35,20.58 126.32,20.58 127.78,22.03 131.28,22.03 131.95,21.37 138.43,21.37 139.4,22.33 147.89,22.33 148.56,23 155.26,23 155.43,23.17 166.43,23.17 167.12,22.49 170.1,22.49 170.9,23.28 172.03,23.28 173.04,22.27 183.96,22.27 185.09,21.14 203.42,21.14 212.96,11.6 224.7,11.6 225.81,10.48 229.71,10.48 230.47,11.24 v1(230.47,11.45)
MY14: length 234
  TOP w0.114: v1(231.18,11.44) 230.77,11.02 U34.54 ; v1(33.57,57.03) 33.7,57.03 34.09,57.43 EC57.1 33.22,57.55 33.13,57.46 33.13,56.72 32.53,56.13 CN2.8
  IN1 w0.089: v1(33.57,57.03) 35.02,55.57 35.02,51.47 35.93,50.56 35.93,48.27 40.04,44.17 40.04,39.08 45.13,34 60.99,34 65.31,29.67 97.64,29.67 98.02,29.67 102.72,24.97 104.87,24.97 105.16,24.67 105.16,24.04 105.38,23.82 108.29,23.82 108.78,23.33 113.1,23.33 114.43,21.99 115.28,21.99 116.47,20.8 126.22,20.8 127.68,22.26 131.38,22.26 132.05,21.6 138.34,21.6 139.3,22.56 147.8,22.56 148.47,23.23 155.16,23.23 155.98,24.05 163.16,24.05 163.7,23.51 166.42,23.51 167.21,22.72 170.01,22.72 170.8,23.51 172.17,23.51 173.18,22.5 184.06,22.5 185.18,21.37 203.51,21.37 213.06,11.83 224.79,11.83 225.86,10.76 229.57,10.76 230.01,11.21 230.01,11.61 230.29,11.88 230.73,11.88 v1(231.18,11.44)
MY15: length 230.4
  TOP w0.114: CN2.10 32.72,54.53 32.91,54.72 32.91,55.15 33.29,55.54 33.75,55.54 33.85,55.63 EC60.1 34.09,55.39 33.8,55.1 v1(33.56,55.1) ; U34.55 231.17,8.96 v1(231,8.79)
  IN1 w0.089: v1(33.56,55.1) 34.56,54.09 34.56,51.28 35.48,50.37 35.48,48.09 39.59,43.98 39.59,38.89 44.94,33.54 60.77,33.54 65.09,29.21 97.83,29.21 103.67,23.37 104.82,23.37 104.82,23.37 108.1,23.37 108.59,22.87 112.91,22.87 114.25,21.54 115.06,21.54 116.25,20.35 126.41,20.35 127.87,21.8 131.19,21.8 131.86,21.14 138.53,21.14 139.49,22.11 147.98,22.11 148.65,22.78 155.35,22.78 155.52,22.95 166.34,22.95 167.24,22.04 183.87,22.04 184.99,20.92 203.32,20.92 212.87,11.37 224.6,11.37 225.72,10.25 229.66,10.25 231,8.91 v1(231,8.79)
MY16: length 231.4
  TOP w0.114: v1(230.65,7.82) 231.57,8.74 U34.56 ; CN2.11 32.77,53.73 32.93,53.89 32.93,54.4 33.15,54.62 EC61.1 34.09,54.38 33.8,54.09 v1(33.57,54.09)
  IN1 w0.089: v1(230.65,7.82) 230.49,7.97 230.49,9 229.46,10.03 225.62,10.03 224.51,11.14 212.77,11.14 203.23,20.69 184.9,20.69 183.77,21.81 167.14,21.81 166.24,22.72 155.62,22.72 155.45,22.55 148.75,22.55 148.08,21.88 139.59,21.88 138.62,20.91 131.76,20.91 131.1,21.58 127.97,21.58 126.51,20.12 116.15,20.12 114.96,21.31 114.15,21.31 112.82,22.64 108.5,22.64 108,23.14 104.73,23.14 104.72,23.14 103.58,23.14 97.73,28.98 65,28.98 60.67,33.31 44.84,33.31 39.36,38.79 39.36,43.88 35.25,47.99 35.25,50.27 34.33,51.19 34.33,53.32 v1(33.57,54.09)
NB_MUTE#: length 232.4
  TOP w0.114: v1(23.12,11) 22.82,11.3 CN5.27 ; v1(233.68,18.92) 234.09,19.33 235.43,19.33 235.51,19.41 U34.84
  IN4 w0.089: v1(233.68,18.92) 233.91,18.7 233.91,16.09 231.92,14.1 224.84,14.1 223.62,12.88 223.62,11.24 222.3,9.92 220.65,9.92 217.52,6.78 189.55,6.78 185.05,11.28 180.27,11.28 173.26,18.29 155.82,18.29 155.33,17.8 141.38,17.8 140.78,17.21 123.79,17.21 123.41,17.59 121.74,17.59 120.35,16.2 118.42,16.2 118.24,16.02 112.06,16.02 110.68,17.39 110.41,17.39 110.22,17.58 108.76,17.58 108.21,18.13 98.79,18.13 98.41,17.75 76.8,17.75 75.88,16.83 52.08,16.83 49.92,14.67 32.31,14.67 31.02,13.39 27.71,13.39 27.38,13.06 26.07,13.06 24.25,11.23 23.35,11.23 v1(23.12,11)
NTC: length 41.3
  TOP w0.254: PC9372.2 115.37,140.66 v1(115.41,140.61)
  IN3 w0.254: v1(95.11,136.31) 95.5,135.92 100.18,135.92 102.52,138.26 112.46,138.26 112.92,138.72 117.08,138.72 117.62,139.25 117.62,141.58 v1(118.67,142.63)
  BOTTOM w0.203: v1(118.67,142.63) 118.09,142.63 PR278.2 117.55,142.09 117.54,142.09 116.88,141.43 116.43,141.43 115.61,140.61 v1(115.41,140.61) 115.06,140.61 114.9,140.77 PU16.11
  BOTTOM w0.254: v1(95.11,136.31) 95.11,136.31 94.88,136.53 92.47,136.53 91.9,135.97 90.08,135.97 v1(90.01,135.9) 88.96,134.84 PR277.1
NTC_GFX: length 38.8
  TOP w0.254: v1(34.81,117.22) 34.8,117.21 34.22,117.21 PC9373.2 34.17,117.57 34.75,118.16 35.47,118.16 36.83,119.51 42.65,119.51 v1(43.23,120.1)
  BOTTOM w0.203: PU17.11 36.56,120.09 36.46,119.99
  BOTTOM w0.254: PR323.1 55.67,132.57 54.17,132.57 53.66,133.08 50.32,133.08 48.4,131.16 48.4,125.94 46.25,123.79 46.25,120.65 45.25,119.65 43.68,119.65 v1(43.23,120.1) ; v1(34.81,117.22) 34.98,117.39 PR324.2 35.47,118.15 36.46,119.14 36.46,119.99
NTC_GPU: length 30.6
  TOP w0.254: v1(131.97,48.67) 132.43,48.21 134.68,48.21 135.4,47.49 PR423.2 135.42,47.46 v1(136.51,47.46) 136.51,47.46 136.61,47.57 137.34,47.57 PC9375.2 137.34,47.57 137.88,47.57 137.99,47.46 v1(137.99,47.46)
  BOTTOM w0.152: PR422.1 125.42,67.66 124.92,67.16 124.92,57.88 127.86,54.94 129.15,54.94 129.15,54.95 129.38,54.95 129.38,54.94 131.04,53.28 131.04,53.28 131.1,53.22 131.1,49.54 v1(131.97,48.67)
  BOTTOM w0.203: PU24.11 137.96,47.96 137.83,47.83 137.83,47.61 137.98,47.46 v1(137.99,47.46)
NTC_NB: length 27.2
  TOP w0.254: PC9371.2 113.98,146.24 115.41,146.24 115.62,146.03 ; 115.62,146.03 115.62,146.19 115.94,146.51 v1(116.6,146.51) 116.92,146.51 PR276.2 ; 115.62,146.03 v1(115.62,146.03)
  IN2 w0.254: v1(115.62,146.03) 115.62,146.32 115.81,146.51 117.21,146.51 117.54,146.18 117.54,142.04 116.94,141.43 116.48,141.43 115.94,140.9 115.94,140.19 115.52,139.76 109.17,139.76 107.13,137.72 107.13,137.28 v1(106.1,136.25)
  BOTTOM w0.203: PU16.1 115.62,146.03 v1(115.62,146.03)
  BOTTOM w0.254: PR275.1 v1(106.1,136.25)
NTC_NB_GFX: length 2.9
  TOP w0.254: PR325.1 42.35,117.92 v1(42.25,118.01) 41.92,118.34 v1(41.92,118.6)
  BOTTOM w0.203: PU17.1 41.2,118.97 41.57,118.6 v1(41.92,118.6)
NTC_NB_GPU: length 50.5
  TOP w0.254: v1(143.27,46.76) 143.27,46.77 PC9374.2
  BOTTOM w0.152: PR421.2 146.05,43.66 146.86,42.85 v1(147,42.85) 150.06,42.85 150.72,43.52 152.93,43.52 161.3,51.89 161.3,68.87 PR420.1
  BOTTOM w0.203: PU24.1 142.58,46.9 142.74,46.74 143.25,46.74 v1(143.27,46.76)
  BOTTOM w0.254: v1(143.27,46.76) 143.27,46.57 143.71,46.13 144.51,46.13 145.19,45.45 145.19,44.53 PR421.2
P_ZVDDP_P_TX_095: length 1.8
  TOP w0.254: R461.1 68.83,112.14 v1(69.4,112.14)
  BOTTOM w0.254: v1(69.4,112.14) 69.3,112.14 68.85,111.69 U18.U7
P_ZVSS_P_RX_095: length 1.4
  TOP w0.254: R462.2 v1(69.42,112.79)
  BOTTOM w0.254: v1(69.42,112.79) 69.34,112.79 U18.U6
PBAT_PRES#: length 188.1
  TOP w0.114: v1(113.63,17.96) 113.63,18.29 114.14,18.8 126.23,18.8 128.49,21.06 130.87,21.06 132.29,19.64 157.74,19.64 159.07,18.32 179.84,18.32 184.7,13.47 188.84,13.47 195.31,6.99 203.07,6.99 205.3,9.22 v1(205.3,9.58) ; U34.18 219.83,17.41 219.53,17.7 218.38,17.7 v1(218.17,17.91)
  IN4 w0.089: v1(113.63,17.96) 112.94,17.28 111.82,17.28 111.03,18.08 110.69,18.08 110.48,18.29 109.03,18.29 107.83,19.48 99.5,19.48 98.22,18.21 77.97,18.21 77.43,18.75 66.66,18.75 v1(65.44,17.53)
  BOTTOM w0.114: v1(205.3,9.58) 205.81,10.09 210.75,10.09 213.12,12.46 213.12,16.85 214.19,17.91 v1(218.17,17.91) ; v1(113.63,17.96) 113.63,17.07 v1(114.01,16.69) 115.49,15.21 ESD1.3 115.75,14.59 115.75,13.55 117.18,12.12 PR222.2 PR221.2 ; v1(65.44,17.53) 65.79,17.18 65.79,15.66 66.61,14.84 66.77,14.84 67.35,14.26 68.68,14.26 68.74,14.21 PU15.15
PCI_SERR#_R: length 2.2
  TOP w0.114: TP128.1 80.92,111.62 80.42,111.12 v2(80.21,111.12)
  BOTTOM w0.102: v2(80.21,111.12) 80.07,111.12 U18.AL8
PCIE_CLKREQ_LAN#: length 348.9
  TOP w0.114: v1(117.21,26.91) 118.2,25.92 121.77,25.92 122.23,26.39 122.23,27.34 123.27,28.38 127.06,28.38 127.67,27.77 137.06,27.77 138.21,26.62 138.21,26.07 139.82,24.46 152.69,24.46 153.44,25.21 154.65,25.21 154.87,24.99 177.79,24.99 179.18,26.39 179.18,27.79 v1(179.61,28.21) ; U2.12 268.31,88.6 268.27,88.55 267.81,88.55 v1(267.37,88.98)
  IN1 w0.089: v1(117.21,26.91) 117.21,26.9 116.36,26.9 115.67,27.59 114.13,27.59 113.54,28.18 111.91,28.18 110.16,26.42 106.53,26.42 99.02,33.93 94.87,33.93 v1(94.51,33.58)
  IN4 w0.089: v1(269.79,81.86) 269.44,81.51 267.56,81.51 267.15,81.11 267.15,76.22 272.72,70.66 272.72,63.16 271.59,62.04 269.26,62.04 266.23,59.01 266.23,53.67 268.67,51.23 268.67,41.97 267.22,40.52 252.23,40.52 245.42,33.71 219.26,33.71 218.03,32.48 194.4,32.48 191.06,29.14 180.53,29.14 v1(179.61,28.21)
  BOTTOM w0.102: U18.BB17 88.92,103.4 89.22,103.1 90.21,103.1 90.45,103.33 93.53,103.33 93.94,102.93 98.23,102.93 98.91,102.25 98.91,101.38 99.19,101.1 99.3,101.1
  BOTTOM w0.114: v1(269.79,81.86) 269.85,81.92 v1(269.85,82.86) R321.1 269.85,86.08 269.04,86.88 268.25,86.88 267.37,87.76 v1(267.37,88.98) ; v1(94.51,33.58) 94.96,34.02 95.91,34.02 103.88,41.99 105.99,41.99 107.06,43.06 107.06,46.9 108.99,48.83 108.99,50.75 107.22,52.52 107.22,57.71 108.23,58.72 108.23,72.99 105.52,75.7 105.52,92.18 107.08,93.74 107.36,93.74 107.71,94.09 107.71,98.81 105.42,101.1 99.3,101.1
PCIE_CLKREQ_VGA#: length 43.4
  IN1 w0.089: v1(103.94,102.02) 104.26,101.7 104.26,98.78 108.04,95 108.04,90.61 111.05,87.61 v1(111.37,87.61)
  BOTTOM w0.102: R1006.1 98.34,103.91 98.54,103.71 99.3,103.71 ; U18.BB16 88.67,103.68 89.15,103.68 89.17,103.7 89.48,103.7 89.61,103.57
  BOTTOM w0.114: R1006.1 97.13,103.41 94.04,103.41 93.68,103.77 90.3,103.77 90.1,103.57 89.61,103.57 ; v1(111.37,87.61) 111.75,87.61 112.87,86.49 116.68,86.49 R1007.1 118.28,84.89 Q50.3 ; 99.3,103.71 99.95,103.71 100.58,103.07 101.77,103.07 v1(102.48,102.37) 103.6,102.37 v1(103.94,102.02)
PCIE_CLKREQ_WLAN#: length 202.4
  TOP w0.114: v1(10.5,15.85) 9.75,15.85 R241.1
  IN4 w0.089: v1(96.46,22.56) 95.99,23.02 62.68,23.02 60.48,20.82 55.77,20.82 55.03,20.08 40.07,20.08 38.36,18.38 29.46,18.38 28.21,17.12 26.66,17.12 25.95,17.83 16.98,17.83 16.24,17.09 11.94,17.09 10.7,15.85 v1(10.5,15.85)
  BOTTOM w0.114: CN10.53 10.33,15.68 v1(10.5,15.85) ; v1(96.46,22.56) 96.46,33.85 104.12,41.51 106.19,41.51 108.72,44.04 108.72,47.61 109.47,48.36 109.47,50.95 107.7,52.72 107.7,57.51 108.96,58.77 108.96,72.99 106,75.95 106,91.08 108.62,93.7 108.62,98.96 103.58,104.01 102.19,104.01 v1(102.03,103.85) 101.82,103.64 100.69,103.64 100.03,104.31 98.98,104.31 97.76,105.53 94.24,105.53 93.81,105.11 89.46,105.11 U18.BC15
PCIE_EC_WAKE#: length 101.9
  TOP w0.114: v1(237.94,13.29) 237.67,13.29 237.14,13.81 U34.70 ; Q49.3 268.47,80.85 267.89,80.28 267.89,77.77 v1(268.09,77.58) R1004.1 v1(268.91,76.81)
  IN4 w0.089: v1(237.94,13.29) 238.32,12.91 246.8,12.91 249.19,15.3 249.19,19.99 253.43,24.23 253.43,34.74 258.74,40.06 267.42,40.06 269.13,41.76 269.13,51.42 266.69,53.86 266.69,58.82 269.45,61.58 271.86,61.58 273.18,62.9 273.18,70.85 268.91,75.11 v1(268.91,76.81)
PCIE_EC_WAKE#_R: length 13
  TOP w0.114: R1004.2 269.96,77.85 Q49.1 v1(270.75,78.87) ; v1(271.55,84.69) 271.11,85.13 271.11,85.55 271.28,85.72 U2.21
  IN4 w0.089: v1(270.75,78.87) 270.8,78.87 272.66,80.73 272.66,83.58 v1(271.55,84.69)
  BOTTOM w0.114: v1(271.55,84.69) 271.46,84.6 v1(271.46,83.75) 271.64,83.57 R303.2
PCIE_RST#: length 28.4
  TOP w0.114: R522.1 101.15,105.15 v1(101.41,105.42)
  IN1 w0.089: v2(81.52,111.46) 82.31,110.67 85.18,110.67 85.37,110.87 86.76,110.87 86.96,110.67 87.97,110.67 89.27,111.97 93.23,111.97 93.65,111.56 96.41,111.56 97.64,110.32 99.36,110.32 102.4,107.28 102.4,105.65 102.1,105.34 101.49,105.34 v1(101.41,105.42)
  BOTTOM w0.102: U18.AN7 80.89,111.46 v2(81.52,111.46)
PCIE_RXN0_WLAN: length 134.7
  IN3 w0.114: v1(12.28,13.31) 12.45,13.14 12.99,13.14 13.62,13.77 13.62,15.16 16.85,18.39 18.64,18.39 24.57,24.33 25.12,24.33 31.01,30.21 31.01,58.37 30.34,59.04 30.34,62.83 35.62,68.11 35.62,74.15 40.06,78.59 40.06,86.3 43.8,90.04 43.8,95.73 45.71,97.65 48.93,100.86 48.93,103.7 49.48,104.25 51.96,104.25 54.34,106.63 55.8,106.63 57.48,108.32 62.62,108.32 63.05,107.89 66.47,107.89 68.24,109.65 v1(68.24,109.7)
  BOTTOM w0.114: v1(68.24,109.7) 68.43,109.9 U18.U9 ; v1(12.28,13.31) 12.01,13.04 9.73,13.04 9.59,13.18 CN10.43
PCIE_RXN1_LAN: length 291.9
  TOP w0.114: C643.1 267.78,73.76 267.78,72.98 267.94,72.82 268.03,72.82 268.38,72.82 v1(268.75,73.19)
  IN3 w0.114: v1(67.17,112.58) 67.43,112.32 67.6,112.32 67.7,112.43 67.7,114.17 70.79,118.44 72.65,120.3 75.13,120.3 76.43,121.59 79.36,121.59 79.59,121.83 79.59,122.18 80.27,122.86 88.18,122.86 88.71,122.32 91.39,122.32 94.03,119.68 97.62,119.68 98.25,120.31 105.13,120.31 107.91,117.54 107.91,114.35 111.46,110.8 111.46,89.8 114.76,86.5 115.75,86.5 116.91,85.34 116.91,83.45 119.51,80.85 121.27,80.85 121.74,80.38 122.4,80.38 123.63,81.61 130.86,81.61 132.6,83.34 143.38,83.34 144.3,82.43 144.94,82.43 148.19,79.18 156.06,79.18 156.4,78.84 162.67,78.84 164.44,77.08 171.42,77.08 173.85,74.65 173.85,67.75 175.19,64.11 178.04,61.26 189.06,50.24 191.04,45.64 193.09,43.59 195.1,41.58 204.13,41.58 217.49,36.7 232.83,36.7 251.16,42.49 258.18,46.32 262.35,50.49 262.89,51.03 262.89,52.6 264.19,57.73 264.97,58.5 264.97,58.79 266.2,62.84 267.11,63.79 268.03,64.74 268.03,72.62 268.23,72.83 268.39,72.83 v1(268.75,73.19)
  BOTTOM w0.114: U18.T5 67.65,112.96 67.28,112.58 v1(67.17,112.58)
PCIE_RXN1_LAN_C: length 12.8
  TOP w0.114: C643.2 267.77,75.35 267.77,75.89 267.4,76.26 267.4,82.56 269.99,85.15 269.99,85.7 270.08,85.79 U2.18
PCIE_RXP0_WLAN: length 134.7
  IN3 w0.114: v1(68.27,108.98) 68.12,109.12 68.02,109.12 66.56,107.67 62.96,107.67 62.53,108.1 57.57,108.1 55.88,106.42 54.43,106.42 52.05,104.03 49.57,104.03 49.14,103.61 49.14,100.77 45.5,97.13 45.5,97.13 44.01,95.64 44.01,89.95 40.28,86.21 40.28,78.5 35.84,74.06 35.84,68.02 30.55,62.74 30.55,59.13 31.22,58.46 31.22,30.12 25.21,24.11 24.66,24.11 18.73,18.18 16.94,18.18 13.84,15.07 13.84,13.68 13.08,12.92 12.66,12.92 v1(12.28,12.55)
  BOTTOM w0.102: v1(68.27,108.98) 68.32,109.02 68.63,109.02 U18.U10
  BOTTOM w0.114: CN10.41 9.59,12.68 9.73,12.82 12.01,12.82 v1(12.28,12.55)
PCIE_RXP1_LAN: length 291.9
  TOP w0.114: v1(268.75,72.4) 268.54,72.6 268.12,72.6 267.85,72.6 267.56,72.89 267.56,73.07 267.56,73.07 267.56,73.76 C642.1
  IN3 w0.114: v1(67.2,111.93) 67.37,112.11 67.69,112.11 67.92,112.34 67.92,114.1 70.96,118.3 71.14,118.48 71.15,118.5 72.74,120.08 75.22,120.08 76.52,121.38 79.45,121.38 79.81,121.74 79.81,122.09 80.36,122.64 88.09,122.64 88.62,122.11 91.3,122.11 93.94,119.46 97.71,119.46 98.34,120.1 105.04,120.1 107.69,117.45 107.69,114.26 111.25,110.71 111.25,89.71 114.67,86.29 115.66,86.29 116.69,85.25 116.69,83.36 119.42,80.64 121.18,80.64 121.65,80.17 122.49,80.17 123.72,81.39 130.95,81.39 132.69,83.13 143.29,83.13 144.21,82.22 144.85,82.22 148.1,78.97 155.97,78.97 156.31,78.63 162.58,78.63 164.35,76.87 171.33,76.87 173.64,74.56 173.64,67.71 175.01,63.99 180.73,58.27 186.43,52.57 188.88,50.12 190.85,45.52 195.01,41.36 204.09,41.36 217.45,36.49 232.87,36.49 251.24,42.29 251.29,42.32 258.31,46.14 263.11,50.94 263.11,52.57 264.39,57.61 265.18,58.41 265.18,58.76 266.39,62.73 268.24,64.66 268.24,72.53 268.32,72.61 268.53,72.61 v1(268.75,72.4)
  BOTTOM w0.114: U18.T6 67.31,111.96 67.22,111.96 v1(67.2,111.93)
PCIE_RXP1_LAN_C: length 12.8
  TOP w0.114: C642.2 267.55,75.33 267.55,75.81 267.18,76.17 267.18,82.65 269.77,85.24 269.77,85.67 269.68,85.76 U2.17
PCIE_TXN0_WLAN: length 148.2
  IN3 w0.114: v1(10.53,11.81) 10.53,11.59 10.64,11.49 10.9,11.49 11.06,11.65 11.06,12.22 10.54,12.74 10.54,15.03 14.09,18.58 14.85,18.58 17.09,20.82 18.9,22.62 18.9,23.59 19.33,24.02 20.57,24.02 22.3,25.75 24.45,25.75 29.58,30.88 29.58,57.61 28.91,58.28 28.91,63.42 34.19,68.69 34.19,74.77 38.62,79.2 38.62,86.92 42.37,90.67 42.37,97.33 46.74,101.7 46.74,107.65 47.55,108.46 50.35,108.46 50.76,108.87 50.76,110.84 52.68,112.76 52.68,115.96 53.28,116.56 53.28,118.98 55.9,121.61 64.97,121.61 65.22,121.85 65.22,122.44 v1(64.78,122.88)
  BOTTOM w0.114: v1(10.53,11.81) 10.26,11.54 9.72,11.54 9.57,11.68 CN10.37 ; v1(64.78,122.88) 65.05,122.61 65.05,122.17 64.95,122.07 C1099.2
PCIE_TXN0_WLAN_C: length 12.9
  BOTTOM w0.114: C1099.1 64.95,121.04 64.95,120.32 65.27,120 65.62,120 66.29,120.68 66.48,120.68 66.73,120.43 66.73,119.94 66.6,119.82 66.01,119.82 65.76,119.57 65.76,119.15 66.01,118.89 66.98,118.89 67.2,118.67 67.2,118.45 67.15,118.4 65.95,118.4 65.69,118.14 65.69,117.72 65.95,117.47 66.72,117.47 66.84,117.36 66.84,117.03 66.31,116.5 66.31,116.09 66.85,115.56 U18.R2
PCIE_TXN1_LAN: length 287.4
  TOP w0.114: v1(267.98,85.32) 267.91,85.25 267.81,85.25 267.65,85.4 267.65,85.78 267.28,86.15 267.28,87.34 267.92,87.98 268.29,87.98 268.36,87.9 268.36,87.85 268.42,87.8 U2.14
  IN3 w0.114: v1(64.75,125.84) 64.44,126.14 64.44,126.26 64.5,126.32 68.7,126.32 73.86,126.83 90.84,126.83 91.33,126.35 93.05,126.35 97.29,125.16 101.04,124.29 106.78,124.29 113.96,117.11 119.28,114.68 122.21,111.76 122.21,110.47 122.63,110.05 123.3,110.05 124.61,108.74 129.71,96.18 130.47,95.42 133.17,95.42 133.85,94.73 133.88,94.71 134.4,92.57 134.81,92.06 135.36,91.76 138.97,91.76 144.74,89.09 147.79,86.04 147.79,85.69 148.58,84.9 155.1,82.98 158.1,82.98 161.33,82.24 161.35,82.24 171.56,82.24 175.58,79.67 178.82,76.43 178.85,76.4 187.25,53.86 187.78,53.33 190.36,50.75 192.32,46.07 195.6,42.78 204.68,42.78 218.81,37.91 230.88,37.91 250.57,43.8 257.73,47.58 259.85,49.7 261.1,52.25 261.68,52.84 261.68,54.18 261.79,54.53 262.88,58.15 263.72,59 263.72,63.67 264.62,65.8 264.8,66.23 265.93,69.89 266.03,70.35 266.05,70.45 266.64,73.03 266.64,73.04 267.16,76.39 267.16,82.61 267.91,84.3 267.91,84.77 267.74,84.94 267.74,85.08 v1(267.98,85.32)
  BOTTOM w0.114: C750.2 64.48,125.36 64.48,125.56 v1(64.75,125.84)
