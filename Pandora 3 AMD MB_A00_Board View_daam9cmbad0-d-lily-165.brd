# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQB0_31: length 25.1
  BOTTOM w0.102: U22.AG2 151.2,98.85 151.52,98.53 151.81,98.53 151.92,98.64 152.96,98.64 153.15,98.45
  BOTTOM w0.14: 153.15,98.45 156.15,98.45 156.21,98.52 159.58,98.52 v1(162.59,101.52) 164.6,101.52 169.25,106.18 169.25,106.7 169.17,106.79 169.17,108.89 VRAM3.M4
DQB1_0: length 24.2
  BOTTOM w0.102: 153,98.15 152.75,98.4 151.97,98.4 151.87,98.3 U22.AH1
  BOTTOM w0.14: 153,98.15 159.95,98.15 162.78,100.98 v1(166.87,100.98) 169.32,98.53 169.32,97.65 169.11,97.44 169.11,95.35 VRAM4.F4
DQB1_1: length 22.4
  BOTTOM w0.102: 152.9,97.85 152.55,98.2 152.09,98.2 151.95,98.06 151.51,98.06 151.39,97.97 151.17,97.97 150.85,98.3 U22.AH2
  BOTTOM w0.14: 152.9,97.85 160.51,97.85 v1(161.76,99.09) 163.12,100.46 166.65,100.46 168.47,98.64 168.47,97.6 168.32,97.46 168.32,96.94 VRAM4.F2
DQB1_2: length 20.8
  BOTTOM w0.102: 152.85,97.55 152.62,97.32 152.07,97.32 151.96,97.43 151.52,97.43 151.2,97.75 U22.AJ2
  BOTTOM w0.14: 152.85,97.55 156,97.55 156.03,97.52 160.92,97.52 v1(161.15,97.75) 163.34,99.94 166.44,99.94 167.62,98.75 167.62,97.93 167.62,97.93 167.62,97.54 167.53,97.45 167.53,97.18 167.91,96.8 VRAM4.E2
DQB1_3: length 21.3
  BOTTOM w0.102: 152.9,97.25 152.76,97.11 151.97,97.11 151.88,97.2 U22.AK1
  BOTTOM w0.14: VRAM4.E4 167.51,95.35 167.51,96.7 167.31,96.9 166.96,96.9 166.76,97.1 166.76,98.09 166.79,98.11 166.79,98.85 166.22,99.42 163.55,99.42 161.41,97.27 156.02,97.27 156,97.25 152.9,97.25
DQB1_4: length 16.8
  BOTTOM w0.102: 153.05,96.25 152.86,96.44 151.92,96.44 151.81,96.33 151.52,96.33 151.2,96.65 U22.AL2
  BOTTOM w0.14: 153.05,96.25 156.81,96.25 157.96,95.1 v1(160.85,95.1) 161.31,94.64 162.6,94.64 162.97,95.01 162.97,95.43 164.44,96.9 164.87,96.9 165.07,96.69 165.37,96.69 VRAM4.B2
DQB1_5: length 15.8
  BOTTOM w0.102: U22.AM1 151.87,96.1 151.97,96.2 152.7,96.2 152.95,95.95
  BOTTOM w0.14: 152.95,95.95 156.38,95.95 157.75,94.58 v1(159.58,94.58) 160.04,94.12 163.03,94.12 163.49,94.57 163.49,95.21 164.71,96.43 VRAM4.A2
DQB1_6: length 17.5
  BOTTOM w0.102: U22.AM2 150.85,96.1 151.17,95.77 151.39,95.77 151.51,95.86 151.95,95.86 152.09,96 152.5,96 152.85,95.65
  BOTTOM w0.14: VRAM4.B4 165.11,95.35 164.37,95.35 164.01,94.99 164.01,94.35 163.14,93.49 158.1,93.49 v1(157.53,94.06) 155.94,95.65 152.85,95.65
DQB1_7: length 16.2
  BOTTOM w0.102: U22.AN2 151.2,95.55 151.52,95.23 151.94,95.23 152.05,95.12 152.67,95.12
  BOTTOM w0.14: VRAM4.A4 164.36,94.6 164.36,93.97 163.32,92.93 v1(161.09,92.93) 157.92,92.93 155.5,95.35 152.9,95.35 152.67,95.12
DQB1_8: length 16.9
  IN1 w0.114: v1(157.76,90.92) 158.31,90.92 160.96,88.27 164.38,88.27 v1(165.11,89)
  BOTTOM w0.102: U22.AR1 154.11,94.45
  BOTTOM w0.14: v1(165.11,89) 164.76,89.35 VRAM4.A11 ; 154.11,94.45 154.23,94.45 v1(157.76,90.92)
DQB1_9: length 18.7
  IN1 w0.114: v1(165.91,89) 165.51,89.4 165.51,90.11 164.06,91.55 157.66,91.55 v1(157.08,90.97)
  BOTTOM w0.102: 153.83,94.22 151.9,94.22 151.81,94.13 151.52,94.13 151.2,94.45
  BOTTOM w0.14: 153.83,94.22 v1(157.08,90.97) ; v1(165.91,89) 165.56,89.35 VRAM4.B11 ; U22.AR2 151.2,94.45
DQB1_10: length 16.5
  IN1 w0.114: v1(156.11,91.05) 159.81,87.35 v1(164.31,87.35)
  BOTTOM w0.102: U22.AT1 151.87,93.9 151.93,93.96 152.84,93.96 152.9,93.9
  BOTTOM w0.14: 152.9,93.9 153.51,93.9 156.11,91.3 v1(156.11,91.05) ; VRAM4.A13 v1(164.31,87.35)
DQB1_11: length 19.1
  IN1 w0.114: v1(165.1,87.34) 164.65,86.88 158.61,86.88 155.72,89.77 v1(155.72,90.23)
  BOTTOM w0.102: 152.85,93.55 152.64,93.76 152.04,93.76 151.95,93.66 151.51,93.66 151.42,93.59 151.15,93.59 150.85,93.9 U22.AT2
  BOTTOM w0.14: 152.85,93.55 153.36,93.55 155.4,91.5 155.4,90.55 v1(155.72,90.23) ; v1(165.1,87.34) 165.51,87.75 VRAM4.B13
DQB1_12: length 21.1
  IN1 w0.114: v1(153.5,90.82) 154.87,92.19 165.07,92.19 167.1,90.16 167.1,89.35 v1(167.48,88.97)
  BOTTOM w0.102: 152.51,92.44 151.93,92.44 151.81,92.56 151.51,92.56 151.39,92.47 151.17,92.47 150.85,92.8 U22.AV2
  BOTTOM w0.14: VRAM4.E11 167.88,89.35 167.51,88.98 167.49,88.98 v1(167.48,88.97) ; 152.51,92.44 153.5,91.45 v1(153.5,90.82)
DQB1_13: length 22.6
  IN1 w0.114: v1(154.72,88.13) 158.35,84.5 165.97,84.5 167.61,86.13 167.61,87.23 v1(167.5,87.34)
  BOTTOM w0.14: U22.AW1 152.2,92.2 153.06,91.34 153.06,90.12 154.72,88.47 v1(154.72,88.13) ; VRAM4.E13 167.91,87.75 v1(167.5,87.34)
DQB1_14: length 24.8
  IN1 w0.114: v1(168.31,87.34) 168.31,86.78 168.51,86.58 168.51,86.1 167.81,85.39 167.46,85.39 166.11,84.04 158.09,84.04 154.01,88.11 v1(154.01,88.13)
  BOTTOM w0.14: v1(168.31,87.34) 168.31,87.35 VRAM4.F13 ; U22.AW2 151.37,91.83 152.16,91.83 152.68,91.3 152.68,89.45 v1(154.01,88.13)
DQB1_15: length 27.4
  IN1 w0.114: v1(153.35,88.13) 153.35,88.13 157.9,83.58 166.3,83.58 167.65,84.94 168.24,84.94 169.41,86.11 169.41,86.83 169.1,87.15 v1(169.1,88.95)
  BOTTOM w0.102: U22.AY3 150.67,91.13 150.67,90.74 152.13,89.27
  BOTTOM w0.14: 152.13,89.27 152.36,89.27 153.06,88.56 153.06,88.41 v1(153.35,88.13) ; VRAM4.F11 168.71,89.34 v1(169.1,88.95)
DQB1_16: length 30
  IN4 w0.114: v1(174.72,88.95) 174.99,89.22 174.99,90.78 173.81,91.96 168.21,91.96 167.46,91.21 161.36,91.21 158.9,88.75 v1(152.15,88.75)
  BOTTOM w0.102: U22.BA3 150.3,90.65 150.8,90.15 152.15,88.8 v1(152.15,88.75)
  BOTTOM w0.14: VRAM4.N11 174.32,89.35 v1(174.72,88.95)
DQB1_17: length 29.7
  IN4 w0.114: v1(152.5,88.15) 152.66,88.15 153.19,87.62 158.42,87.62 161.55,90.75 167.65,90.75 168.4,91.5 171.21,91.5 172.96,89.75 v1(173.91,89.75)
  BOTTOM w0.102: U22.AY4 149.85,91.75 149.85,91.5 150.03,91.33 150.03,91.11 149.94,90.99 149.94,90.69 151.72,88.91
  BOTTOM w0.14: 151.72,88.91 151.72,88.58 151.98,88.31 152.33,88.31 v1(152.5,88.15) ; VRAM4.M11 v1(173.91,89.75)
DQB1_18: length 29.7
  IN4 w0.114: v1(152.18,87.44) 152.78,87.44 153.11,87.11 158.56,87.11 161.74,90.29 167.84,90.29 168.59,91.04 170.08,91.04 170.79,90.33 171.27,90.33 172.06,89.55 172.51,89.55 v1(173.11,88.95)
  BOTTOM w0.102: U22.BA4 149.7,90.53 151.45,88.78
  BOTTOM w0.14: v1(173.11,88.95) 173.11,88.09 173.45,87.75 VRAM4.M13 ; v1(152.18,87.44) 152.18,87.78 151.45,88.51 151.45,88.78
DQB1_19: length 29.2
  IN4 w0.114: v1(173.91,88.14) 172.64,86.87 159.36,86.87 159,86.51 153.07,86.51 v1(152.75,86.83)
  BOTTOM w0.102: U22.AY5 149.37,91.33 149.37,91.07 149.47,90.98 149.47,90.43 151.16,88.74
  BOTTOM w0.14: VRAM4.N13 174.28,87.75 173.91,88.12 v1(173.91,88.14) ; 151.16,88.74 151.16,88.06 151.62,87.6 151.62,87.26 152.05,86.83 v1(152.75,86.83)
DQB1_20: length 42.5
  IN4 w0.114: v1(149.35,87.95) 148.9,87.5 148.9,86.16 151.71,83.36 167.98,83.36 168.51,82.83 176.49,82.83 178.88,85.22 178.88,87.98 v1(177.91,88.95)
  BOTTOM w0.102: 148.31,89.21 148.05,89.47 U22.BA7
  BOTTOM w0.14: 148.31,89.21 148.31,88.99 v1(149.35,87.95) ; v1(177.91,88.95) VRAM4.U11
DQB1_21: length 38.5
  IN4 w0.114: v1(176.31,88.95) 176.31,88.31 177,87.62 177,87.1 176.38,86.48 176.38,85.07 175.47,84.17 168.95,84.17 168.5,84.61 152.27,84.61 150.25,86.64 150.25,86.82 149.88,87.18 149.88,88.07 v1(149.35,88.6)
  BOTTOM w0.102: 148.7,89.26 148.29,89.67 148.29,90.61 148.37,90.69 148.37,90.98 148.05,91.3 U22.AY7
  BOTTOM w0.14: VRAM4.T11 v1(176.31,88.95) ; v1(149.35,88.6) 149.1,88.6 148.7,89 148.7,89.26
DQB1_22: length 40.4
  IN4 w0.114: v1(178.06,87.33) 178.42,86.97 178.42,85.41 176.26,83.25 168.68,83.25 168.16,83.78 151.88,83.78 149.35,86.3 v1(149.35,87.15)
  BOTTOM w0.102: 147.82,89.37 147.82,90.61 147.74,90.69 147.74,90.99 147.83,91.11 147.83,91.33 147.5,91.65 U22.AY8
  BOTTOM w0.14: v1(178.06,87.33) 177.64,87.75 VRAM4.U13 ; v1(149.35,87.15) 147.82,88.69 147.82,89.37
DQB1_23: length 39
  IN4 w0.114: v1(177.15,88.15) 177.59,87.71 177.59,86.88 177.39,86.69 177.39,85.45 175.66,83.71 168.81,83.71 168.33,84.2 152.1,84.2 149.82,86.48 v1(149.81,86.48)
  BOTTOM w0.102: U22.BA8 147.5,88.2
  BOTTOM w0.14: VRAM4.T13 176.76,87.75 v1(177.15,88.15) ; v1(149.81,86.48) 149.23,86.48 147.5,88.2
DQB1_24: length 35.3
  IN4 w0.114: v2(150.05,93.85) 150.17,93.97 150.65,93.97 151.15,94.47 151.78,95.1 158.03,95.1 162.9,99.96 176.78,99.96 178.02,98.73 178.02,97.64 177.6,97.22 177.6,96.46 v1(177.91,96.15)
  BOTTOM w0.14: U22.AR4 150.05,93.95 v2(150.05,93.85) ; VRAM4.U2 v1(177.91,96.15)
DQB1_25: length 38.5
  IN4 w0.114: v2(149.35,93.9) 149.94,94.49 150.28,94.49 152.05,96.25 158.6,96.25 162.76,100.42 176.97,100.42 178.51,98.89 178.51,95.15 v1(177.91,94.55)
  BOTTOM w0.14: v2(149.35,93.9) 149.3,93.9 U22.AR5 ; VRAM4.U4 v1(177.91,94.55)
DQB1_26: length 34.7
  IN4 w0.114: v1(149.35,92.77) 149.75,93.18 151.28,93.18 152.36,94.26 158.38,94.26 163.17,99.05 176.1,99.05 176.64,98.51 176.64,95.82 v1(177.11,95.35)
  BOTTOM w0.14: U22.AU4 149.35,93.15 v1(149.35,92.77) ; VRAM4.T4 v1(177.11,95.35)
DQB1_27: length 35.2
  IN4 w0.114: v2(148.75,93.15) 149.04,93.44 150.84,93.44 151.18,93.78 152.08,94.68 158.21,94.68 163.04,99.51 176.59,99.51 177.6,98.5 177.6,97.82 177.15,97.37 v1(177.15,96.95)
  BOTTOM w0.14: v1(177.15,96.95) 176.76,96.55 VRAM4.T2 ; U22.AU7 148.26,93.54 148.65,93.15 v2(148.75,93.15)
DQB1_28: length 34.1
  IN4 w0.114: v2(147.05,94.65) 147.05,93.68 147.09,93.65 147.09,92.23 147.33,92 148.15,91.17 153.14,91.17 154.23,92.27 159.76,92.27 160.53,93.04 166,93.04 167.84,94.88 168.5,94.88 169.05,95.42 169.05,96.24 169.44,96.63 170.31,96.63 170.39,96.55 VRAM4.M2 v1(173.91,96.95)
  BOTTOM w0.14: v2(147.05,94.65) 147.05,95.45 U22.AN8 ; VRAM4.M2 v1(173.91,96.95)
DQB1_29: length 33.5
  IN4 w0.114: v1(173.91,94.55) 173.49,94.97 172.12,94.97 171.84,94.7 171.84,93.52 171.19,92.87 167.83,92.87 167.08,92.12 160.98,92.12 158.58,89.72 148.42,89.72 146.74,91.41 146.46,91.68 v1(146.46,92.5)
  BOTTOM w0.14: VRAM4.N4 v1(173.91,94.55) ; v1(146.46,92.5) 146.3,92.5 U22.AV11
DQB1_30: length 35.4
  IN4 w0.114: v2(146.4,93.3) 146.05,92.95 146.05,90.45 147.19,89.31 158.81,89.31 161.17,91.67 167.27,91.67 168.02,92.41 172.75,92.41 173.58,93.24 173.58,94.03 v1(173.11,94.5)
  BOTTOM w0.14: v1(173.11,94.5) 173.11,94.5 173.51,94.91 VRAM4.M4 ; U22.AU11 145.95,93.75 v2(146.4,93.3)
DQB1_31: length 36
  IN4 w0.114: v1(174.71,96.15) 173.99,95.43 171.93,95.43 171.38,94.89 171.38,94.35 171.08,94.05 167.65,94.05 166.19,92.58 160.79,92.58 160.02,91.81 155.16,91.81 153.5,90.16 151.39,90.16 150.95,90.6 148.18,90.6 147.05,91.72 146.87,91.91 146.87,93.56 146.73,93.7 146.73,94.35 146.44,94.64 v2(146.44,95.06)
  BOTTOM w0.14: v2(146.44,95.06) 146.15,95.35 U22.AP11 ; VRAM4.N2 v1(174.71,96.15)
DRAM_A_RST: length 3.9
  BOTTOM w0.114: C968.1 R668.1 122.5,113.58 v1(122.57,113.64) 123.51,113.64 123.75,113.4 R669.1
DRAM_B_RST: length 3.3
  BOTTOM w0.114: R672.1 C969.1 149.1,83.87 149.42,83.55 v1(149.67,83.55) 149.92,83.55 150.11,83.73 R671.1
DRAM_RST_A: length 62.7
  TOP w0.127: v1(121.72,114.41) 123.55,116.24 123.55,131.46 124.03,131.94 124.03,132.14 124.52,132.63 124.52,139.65 v1(126.2,141.33) 126.63,141.76 v1(128.14,141.76)
  BOTTOM w0.114: 141.17,134.98 139.68,134.98 138.47,133.77 136.7,133.77 VRAM1.J2 ; 141.17,134.98 142.96,134.98 144.18,133.76 144.87,133.76 144.94,133.84 145.57,133.84 VRAM2.J2 ; 141.17,134.98 141.17,140.62 140.42,141.37 128.53,141.37 v1(128.14,141.76) ; R668.2 v1(121.72,114.41)
DRAM_RST_A_R: length 16.6
  TOP w0.114: v1(133.75,108.17) 133.31,107.73 130.14,107.73 129.83,108.03 129.83,108.75 128.77,109.82 127.9,109.82 126.76,110.95 125.68,110.95 124.42,112.21 v1(123.07,112.21)
  BOTTOM w0.114: R669.2 R674.1 124.06,112.21 v1(123.07,112.21)
  BOTTOM w0.127: v1(133.75,108.17) 133.8,108.17 134.32,107.65 U22.L32
DRAM_RST_B: length 58.2
  BOTTOM w0.114: 171.93,102.78 171.55,102.4 171.55,96.99 VRAM4.J2 ; 171.93,102.78 176.41,102.78 178.56,100.62 178.56,94.11 176.95,92.5 171.12,92.5 169.61,90.99 167.96,90.99 167.95,90.98 164.65,90.98 163.84,90.17 159.02,90.17 153.98,85.13 v1(152.05,85.13) R671.2 ; 171.93,102.78 171.55,103.15 171.55,105.77 171.36,105.96 171.36,106.64 171.52,106.8 171.52,107.34 VRAM3.J2
DRAM_RST_B_R: length 14
  TOP w0.114: v1(147.82,86.96) 148.43,87.57 148.43,90.53 146.92,92.03 146.92,94.13 146.5,94.55 146.33,94.55 146,94.88 146,95.35 v2(146.4,95.75)
  BOTTOM w0.114: R675.1 R672.2 148.08,86.7 v1(147.82,86.96)
  BOTTOM w0.127: U22.AM11 146,96.15 v2(146.4,95.75)
EC_AVSS: length 4.7
  TOP w0.114: L15.1 v1(239.92,16.74) 239.65,16.74 239.53,16.63 C1210.1 238.96,16.63 238.15,15.81 U34.75
EC_EXT_SCI#: length 3
  TOP w0.114: D29.1 219.08,14.89 v1(219.34,15.15) 219.6,15.41 U34.23
EC_EXT_SMI#: length 3
  TOP w0.114: U34.15 219.94,18.61 v1(219.4,19.16) D28.1
EC_PWRBTN#: length 291
  TOP w0.114: v2(76.8,122.02) 79.14,119.68 102.67,119.68 110.24,112.11 110.24,93.16 106.86,89.78 106.86,77.28 114.89,69.25 114.89,59.85 115.63,59.11 115.63,38.33 115.31,38.01 115.31,36.69 111.21,32.59 111.21,26.84 112.72,25.34 112.72,23.69 115.87,20.54 125.43,20.54 127.67,22.78 130.26,22.78 131.36,23.88 134.82,23.88 135.29,23.41 135.29,22.61 136.79,21.12 158.4,21.12 159.68,19.84 180.46,19.84 185.31,14.99 189.55,14.99 195.57,8.97 201.11,8.97 v1(201.64,8.44) ; D42.2 v1(241.75,19.54)
  BOTTOM w0.114: U18.AE1 74.97,116.42 74.97,117.33 75.42,117.78 75.42,119.12 76.27,119.97 R536.1 76.75,121.01 76.75,121.97 v2(76.8,122.02) ; v1(201.64,8.44) 203.18,6.9 236.99,6.9 243.35,13.27 v1(243.35,16.77) 243.35,17.93 v1(241.75,19.54)
EC_PWROK: length 459
  TOP w0.114: v1(200.31,9.97) 199.87,10.41 195.2,10.41 189.47,16.13 185.31,16.13 179.95,21.49 166.84,21.49 166.23,22.11 159.61,22.11 159.2,22.52 136.41,22.52 136.02,22.91 136.02,23.71 135.12,24.6 131.06,24.6 129.96,23.5 125.32,23.5 124.67,24.14 120.16,24.14 119.01,22.99 114.45,22.99 113.44,23.99 113.44,25.68 113.08,26.05 113.08,30.08 112.7,30.46 112.7,31.69 v1(112.98,31.97) 112.98,32.99 116.28,36.29 116.28,37.61 116.59,37.93 116.59,47.23 118.57,49.21 118.57,55.45 117.26,56.77 117.26,61.06 116.14,62.18 116.14,69.71 108.17,77.68 108.17,89.23 111.45,92.51 111.45,112.61 103.17,120.89 99.96,120.89 98.96,121.89 90.82,121.89 90.15,122.56 88.28,122.56 88.22,122.63 86.99,122.63 v1(86.55,122.19) ; v1(44.48,110.81) 44.93,110.81 45.04,110.71 45.04,109.66 R263.2 43.23,107.85 Q17.2 ; U34.82 237.46,18.61 v1(237.57,18.72)
  IN1 w0.089: v1(31.02,81.82) 29.9,82.94 29.9,87.84 33.08,91.02 33.08,96.53 32.04,97.57 32.04,109.23 32.75,109.95 34.92,109.95 35.86,110.89 36.93,110.89 37.62,110.2 43.86,110.2 v1(44.48,110.81)
  IN4 w0.089: v1(112.98,31.97) 111.74,33.22 102.41,33.22 101.93,33.7 98.35,33.7 95.21,30.55 64.35,30.55 61.37,33.53 37.6,33.53 36.9,32.83 34.67,32.83 31.21,36.29 31.21,58.5 30.23,59.48 30.23,64.02 31.07,64.86 31.07,71.18 33.63,73.75 33.63,74.96 33.63,74.96 33.63,79.55 31.36,81.82 v1(31.02,81.82)
  BOTTOM w0.114: v1(86.55,122.19) D23.1 86.55,125.2 86.68,125.33 87.14,125.33 87.26,125.2 87.26,124.11 87.69,123.68 Q36.5 ; v1(200.31,9.97) 200.77,9.97 202.74,7.99 210.85,7.99 214.34,11.48 224.89,11.48 225.69,10.68 231.9,10.68 236.8,15.58 v1(236.8,17.28) 236.8,17.95 v1(237.57,18.72)
EC_RCIN#: length 211.9
  TOP w0.114: v1(214.31,22.89) D30.2
  IN1 w0.089: v1(214.31,22.89) 213.68,23.53 210.43,23.53 210.42,23.53 186.08,23.53 184.95,24.66 174.09,24.66 173.07,25.67 169.48,25.67 168.7,26.44 166.11,26.44 165.88,26.21 157.09,26.21 156.28,27.02 151.3,27.02 149.66,25.39 147.57,25.39 146.53,24.36 140.48,24.36 140.03,24.81 138.01,24.81 137.38,24.19 130.16,24.19 129.07,25.28 125.34,25.28 124.89,24.83 123.84,24.83 122.96,25.71 119.07,25.71 118.36,26.42 116.52,26.42 115.8,27.13 112.76,27.13 v1(112.38,27.52)
  BOTTOM w0.102: U18.AY15 87.46,105.51 87.96,105.51 87.97,105.5 88.28,105.5 88.28,105.51 88.78,105.51 88.79,105.5 89.11,105.5 89.25,105.64 92.2,105.64
  BOTTOM w0.114: 92.2,105.64 93.4,106.83 97.04,106.83 97.44,106.43 101.36,106.43 101.55,106.25 102.03,106.25 102.04,106.25 102.4,106.25 109.11,99.55 109.11,93.5 106.49,90.88 106.49,76.16 109.45,73.2 109.45,58.25 112.52,55.18 112.52,53.17 112.84,52.85 112.84,49.8 110.08,47.04 110.08,42.34 111.71,40.71 v1(111.71,28.19) v1(112.38,27.52)
EC_RTC_RST: length 245.4
  TOP w0.114: Q37.2 100.89,107.28 101.28,107.67 102.82,107.67 103.19,108.04 R622.1 v1(105.32,107.12) 105.6,106.83 105.6,96.56 102.76,93.72 102.76,75.44 108.78,69.41 108.78,68.72 110.78,66.72 110.78,58.16 111.53,57.41 111.53,48.72 110.78,47.97 110.78,44.89 111.53,44.14 111.53,41.17 109.66,39.31 109.66,37.27 108.22,35.83 108.22,30.69 107.51,29.98 102.63,29.98 101.66,29.01 101.66,23.04 103.01,21.69 105.23,21.69 108.47,18.45 113.1,18.45 113.96,19.31 126,19.31 128.24,21.54 131.07,21.54 132.49,20.13 157.97,20.13 159.3,18.8 180.07,18.8 184.9,13.98 189.09,13.98 195.16,7.9 200.22,7.9 200.65,7.47 202.61,7.47 204.63,9.49 v1(204.63,9.94) ; v1(219.85,29.2) R964.2
  BOTTOM w0.114: v1(204.63,9.94) 204.63,19.64 213.09,28.1 217.72,28.1 218.3,28.68 219.33,28.68 v1(219.85,29.2)
EC_RTC_RST_R: length 3.9
  TOP w0.114: R964.1 R963.2 221.81,27.46 v1(221.82,27.45) 222.37,26.9 U34.128
EC_SPI_CS#: length 15.1
  TOP w0.114: U34.101 233.17,26.93 233.55,27.32 233.55,28.97 233.59,29.01 233.59,29.41 v1(233.69,29.5)
  BOTTOM w0.114: U33.1 240.73,36.3 240.86,36.17 240.86,35.86 235.83,30.84 TP292.1 235.06,30.84 233.72,29.5 v1(233.69,29.5)
EC_SPI_DIN: length 22.5
  TOP w0.114: U34.102 232.77,27.02 233.08,27.34 233.08,27.91 v1(232.82,28.17)
  BOTTOM w0.114: U33.5 246.34,40.11 245.81,39.58 245.81,38.65 236.99,29.83 235.4,29.83 TP290.1 233.74,28.17 v1(232.82,28.17)
EC_SPI_DO: length 18.5
  TOP w0.114: U34.103 232.37,26.59 231.97,26.99 v1(231.97,27.67)
  BOTTOM w0.114: v1(231.97,27.67) TP291.1 232.47,29.06 233.87,29.06 235.06,30.25 235.84,30.25 241.36,35.78 241.36,37.32 241.11,37.57 U33.2
EC_SPI_HOLD#: length 18.7
  BOTTOM w0.114: TP300.1 R878.2 238.37,30.03 245.91,37.57 U33.7
EC_SPI_SCK: length 22.9
  TOP w0.114: U34.105 231.57,27.05 v1(231.46,27.16)
  BOTTOM w0.114: v1(231.46,27.16) 231.97,26.65 TP293.1 233.69,26.65 234.08,27.04 C1188.1 234.08,27.75 235.74,29.41 237.16,29.41 246.59,38.84 U33.6
EC_SPI_WP#: length 13.8
  BOTTOM w0.114: U33.3 240.98,38.84 241.49,38.33 243.67,38.33 246.06,40.73 248.24,40.73 249.24,39.73 TP301.1 R876.2
EC_WLAN_RST#: length 252
  TOP w0.114: v1(231.96,23.62) 231.96,25.86 U34.104 ; R1111.2 7.57,13.16 v1(7.57,13.53)
  IN1 w0.089: v1(228.45,15.21) 228.45,20.82 231.25,23.62 v1(231.96,23.62)
  IN2 w0.127: v1(228.45,15.21) 227.95,15.71 223.9,15.71 223.6,16.01 222.17,16.01 221.73,16.45 214.97,16.45 214.71,16.2 214.14,16.2 213.78,16.56 175.35,16.56 173.57,14.77 160.88,14.77 157.86,11.75 156.21,11.75 153.92,14.05 141.12,14.05 140.86,13.79 137.77,13.79 137.34,14.22 117.91,14.22 117.74,14.04 v1(115.28,14.04)
  IN4 w0.089: v1(7.57,13.53) 7.57,13.77 8.06,14.26 10.43,14.26 12.49,16.32 18.41,16.32 18.71,16.03 20.56,16.03 21.94,14.66 21.94,9.69 23.3,8.32 25.75,8.32 27.46,10.03 33.32,10.03 33.96,10.67 49.91,10.67 50.73,11.5 50.73,13.36 52.83,15.46 74.8,15.46 75.54,14.72 77.78,14.72 79.44,16.38 96.9,16.38 97.38,15.9 107.46,15.9 108.49,14.87 114.46,14.87 v1(115.28,14.04)
EDCA0_0: length 33.3
  IN4 w0.114: v1(130.7,110.3) 130.1,110.9 130.1,111.79 131.98,113.67 131.98,115.19 132.92,116.12 133.34,116.12 138.14,120.92 138.14,136.51 137.89,136.76 137.62,136.76 136.75,137.63 v1(136.75,137.79)
  BOTTOM w0.14: VRAM1.C2 136.75,137.82 v1(136.75,137.79) ; v1(130.7,110.3) U22.G38
EDCA0_1: length 32.6
  IN4 w0.114: v1(127.16,137.81) 126.9,138.06 126.73,138.06 126.62,137.95 126.62,127.48 126.38,127.25 126.38,117.62 124.99,116.23 124.99,113.71 125.61,113.08 v1(125.61,113.08)
  BOTTOM w0.102: 128.64,110.23 128.81,110.4 U22.F41
  BOTTOM w0.14: v1(125.61,113.08) 125.61,112.23 127.61,110.23 128.64,110.23 ; v1(127.16,137.81) 127.55,138.2 VRAM1.C13
EDCA0_2: length 18.8
  BOTTOM w0.102: 131.12,114.64 131.12,113.89 131.23,113.78 131.23,113.32 131.35,113.2 131.35,112.95 U22.B37
  BOTTOM w0.14: VRAM1.R13 127.47,128.54 127.47,128.34 127.15,128.02 127.15,127.62 126.91,127.38 126.6,127.38 126.19,126.96 126.19,126.48 126.5,126.17 126.5,125.19 128.15,123.54 v1(128.15,121.04) 128.15,117.61 131.12,114.64
EDCA0_3: length 17.7
  BOTTOM w0.102: U22.A31 134.85,119.44
  BOTTOM w0.14: VRAM1.R2 136.43,128.54 136.43,128.32 136.75,128 136.75,127.62 136.95,127.42 137.29,127.42 137.77,126.93 137.77,126.33 134.25,122.81 v1(134.25,121.19) 134.25,120.04 134.85,119.44
EDCA1_0: length 20.2
  BOTTOM w0.102: U22.B24 138.7,112.65 138.38,112.97 138.38,113.19 138.47,113.31 138.47,113.75 138.58,113.86 138.58,114.32 138.15,114.75
  BOTTOM w0.14: 138.15,114.75 138.15,120.14 143.96,125.95 144.17,125.95 144.17,126.57 145,127.4 145.33,127.4 145.57,127.64 145.57,127.99 145.92,128.34 145.92,128.59 VRAM2.C2
EDCA1_1: length 25.3
  BOTTOM w0.102: 141.85,117.98 141.85,113.78 142,113.63 U22.A18
  BOTTOM w0.14: VRAM2.C13 154.89,128.52 154.89,128.31 155.14,128.05 155.14,127.66 155.03,127.54 155.03,127.3 155.14,127.18 155.14,125.89 155.27,125.76 155.27,124.93 152.77,122.43 v1(151.89,122.43) 151.73,122.43 149.79,120.49 144.36,120.49 141.85,117.98
EDCA1_2: length 28
  IN4 w0.114: v1(144.75,117.35) 144.75,117.95 144.11,118.6 144.11,137.31 144.4,137.6 145.33,137.6 v1(145.57,137.84)
  BOTTOM w0.102: U22.B12 145.3,112.65 145.63,112.97 145.63,113.22 145.54,113.31 145.54,113.62 145.62,113.7 145.62,114.58 145.42,114.78
  BOTTOM w0.14: 145.42,114.78 145.42,116.68 v1(144.75,117.35) ; v1(145.57,137.84) VRAM2.R2
EDCA1_3: length 30.2
  IN4 w0.114: v1(149.24,114.81) 149.89,115.46 149.89,118.52 152.84,121.47 152.84,126.83 153.22,127.21 153.22,127.84 153.14,127.92 153.14,131.03 153.2,131.09 153.2,131.79 153.15,131.84 153.15,133.21 153.09,133.26 153.09,134.78 153.51,135.19 153.51,135.44 153.96,135.9 153.96,138.03 154.18,138.25 154.78,138.25 v1(155.17,138.64)
  BOTTOM w0.102: U22.B6 148.84,112.63 148.84,112.88 148.93,112.97 148.93,113.19 148.84,113.31 148.84,113.79 148.72,113.9 148.72,114.4 149.14,114.81 v1(149.24,114.81)
  BOTTOM w0.14: VRAM2.R13 v1(155.17,138.64)
EDCB0_0: length 30
  IN4 w0.114: v1(176.32,116.94) 175.91,116.53 173.41,116.53 172.64,115.76 172.06,115.76 171.94,115.63 171.94,114.8 171.25,114.12 168.88,114.12 168.6,113.85 162.48,113.85 160.81,112.17 155.06,112.17 v1(154.89,112)
  BOTTOM w0.102: 152.63,111.34 152.63,110.78 152.38,110.52 152.06,110.52 151.95,110.63 151.51,110.63 151.39,110.72 151.17,110.72 151.08,110.63 150.84,110.63 U22.F2
  BOTTOM w0.14: 152.63,111.34 153.29,112 v1(154.89,112) ; VRAM3.C13 v1(176.32,116.94)
EDCB0_1: length 28.5
  IN4 w0.114: v1(155.55,106.55) 157,106.55 158.65,104.91 174.38,104.91 175.45,105.98 175.45,106.79 175.52,106.86 v1(175.52,107.34)
  BOTTOM w0.102: 152.98,107.22 152.78,107.41 151.86,107.41 151.78,107.33 151.51,107.33 151.39,107.42 151.17,107.42 150.85,107.1 U22.M2
  BOTTOM w0.14: 152.98,107.22 154.59,107.22 154.78,107.03 155.07,107.03 v1(155.55,106.55) ; v1(175.52,107.34) 175.91,107.74 VRAM3.C2
EDCB0_2: length 27.3
  IN1 w0.114: v1(153.89,103.34) 153.89,103.06 154.09,102.86 155.04,102.86 155.15,102.97 156.35,102.97 161.39,108.01 161.39,116.18 163.33,118.13 164.14,118.13 164.83,117.44 165.42,117.44 v1(165.92,116.94)
  BOTTOM w0.102: 153.5,103.34 153.38,103.46 151.89,103.46 151.79,103.55 151.55,103.55 U22.V1
  BOTTOM w0.14: VRAM3.R13 v1(165.92,116.94) ; 153.5,103.34 v1(153.89,103.34)
EDCB0_3: length 20.3
  BOTTOM w0.102: 152.9,100 152.52,100.37 152.06,100.37 151.95,100.26 151.51,100.26 151.39,100.17 151.17,100.17 150.85,100.5 U22.AD2
  BOTTOM w0.14: 152.9,100 153.4,100 153.45,99.95 156.72,99.95 158.37,101.6 158.37,101.89 160.62,104.15 v1(160.62,105.31) 161.49,106.18 163.9,106.18 164.16,106.44 164.72,106.44 165.07,106.8 165.07,106.99 165.42,107.34 165.62,107.34 165.88,107.6 166.18,107.6 VRAM3.R2
EDCB1_0: length 17
  BOTTOM w0.102: U22.AL1 157.15,96.65
  BOTTOM w0.14: 157.15,96.65 157.96,95.84 v1(158.48,95.84) 161.11,95.84 161.34,95.61 162.3,95.61 163.67,96.99 163.67,97.47 164.07,97.88 164.78,97.88 165.06,97.59 165.06,97.3 165.37,97 165.56,97 165.86,96.7 166.16,96.7 VRAM4.C2
EDCB1_1: length 20.7
  IN1 w0.114: v1(165.9,87.34) 165.9,86.98 165.71,86.78 165.71,86.07 165.55,85.92 158.69,85.92 155.05,89.56 v1(155.05,90.2)
  BOTTOM w0.102: 153.22,92.92 152.07,92.92 151.96,93.03 151.52,93.03 151.2,93.35 U22.AU2
  BOTTOM w0.14: v1(155.05,90.2) 154.72,90.53 154.72,91.43 153.22,92.92 ; v1(165.9,87.34) 166.31,87.74 VRAM4.C13
EDCB1_2: length 34.2
  IN4 w0.114: v1(176.29,87.37) 175.8,86.88 175.66,86.88 175.41,86.63 175.41,85.26 174.98,84.83 169.17,84.83 168.76,85.24 152.53,85.24 150.89,86.88 150.89,87.06 v1(150.7,87.24)
  BOTTOM w0.102: U22.BA6 148.57,91.17 148.57,90.59 148.5,90.51 148.5,89.83 149,89.32
  BOTTOM w0.14: VRAM4.R13 175.91,87.75 v1(176.29,87.37) ; v1(150.7,87.24) 150.25,87.69 150.25,88.36 149.29,89.32 149,89.32
EDCB1_3: length 33.6
  IN4 w0.114: v2(148.56,92.5) 148.82,92.24 150.78,92.24 151.04,92.5 152.59,92.5 153.69,93.59 159.21,93.59 164.05,98.43 175.16,98.43 176.02,97.57 176.02,96.31 175.86,96.15 v1(175.51,96.15)
  BOTTOM w0.14: v2(148.56,92.5) 148.5,92.5 U22.AV7 ; VRAM4.R2 v1(175.51,96.15)
EDP_AUXN: length 186.5
  IN3 w0.114: v1(178.42,62.47) 178.13,62.76 177.64,62.76 177.06,63.34 177.06,65.14 174.37,67.83 174.37,75.56 172.35,77.58 164.64,77.58 162.87,79.34 157.28,79.34 156.89,79.73 149.09,79.73 145.89,82.93 144.59,82.93 143.66,83.86 127.81,83.86 126.37,82.42 118.66,82.42 117.4,83.68 117.4,85.55 115.95,87 114.97,87 111.96,90.02 111.96,111 108.4,114.56 108.4,117.74 105.34,120.81 98.04,120.81 97.41,120.17 94.24,120.17 91.59,122.82 88.92,122.82 88.38,123.35 79.8,123.35 79.26,122.81 75.99,122.81 75.77,122.59 75.77,121.69 74.9,120.82 72.47,120.82 66.24,114.58 65.01,114.58 63.78,113.35 63.78,111.74 62.79,110.75 60.1,110.75 59.96,110.6 59.22,110.6 58.51,111.31 v1(58.45,111.31)
  BOTTOM w0.114: v1(178.42,62.47) 178.12,62.76 177.73,62.76 174.36,59.4 174.36,54.54 174.43,54.47 C676.2 ; U18.E8 58.45,110.9 v1(58.45,111.31)
EDP_AUXN_C: length 4.4
  BOTTOM w0.114: C676.1 174.54,53.69 174.35,53.51 174.35,52.77 174.96,52.16 174.96,50.64 175.1,50.49 CN9.16
EDP_AUXP: length 186.5
  IN3 w0.114: v1(178.42,63.27) 178.12,62.98 177.73,62.98 177.28,63.43 177.28,65.23 174.58,67.92 174.58,75.65 172.44,77.79 164.73,77.79 162.96,79.56 157.37,79.56 156.98,79.95 149.18,79.95 145.98,83.14 144.68,83.14 143.75,84.08 127.72,84.08 126.28,82.64 118.75,82.64 117.62,83.77 117.62,85.64 116.04,87.22 115.06,87.22 112.17,90.11 112.17,111.09 108.62,114.64 108.62,117.83 105.43,121.02 97.95,121.02 97.32,120.39 94.32,120.39 91.68,123.03 89.01,123.03 88.47,123.57 79.71,123.57 79.17,123.02 75.9,123.02 75.56,122.68 75.56,121.78 74.81,121.04 72.38,121.04 66.15,114.8 64.92,114.8 63.56,113.44 63.56,111.83 62.7,110.97 60.01,110.97 59.87,110.82 59.31,110.82 59.13,110.99 v1(59.13,111.32)
  BOTTOM w0.114: v1(178.42,63.27) 178.42,63.08 178.31,62.98 177.64,62.98 174.15,59.49 174.15,54.58 174.04,54.47 C675.2 ; U18.F8 59.13,111.02 v1(59.13,111.32)
EDP_AUXP_C: length 4.5
  BOTTOM w0.114: CN9.15 174.6,50.57 174.74,50.71 174.74,52.07 174.14,52.68 174.14,53.53 173.97,53.69 C675.1
EDP_HPD: length 274.1
  TOP w0.114: v1(115.23,28.03) 116.06,28.86 116.88,28.86 119.19,31.17 127.75,31.17 128.69,30.23 138.08,30.23 139.16,29.15 148.66,29.15 153.4,33.9 153.4,43.13 166.46,56.18 170.72,56.18 v1(171.18,56.65)
  IN1 w0.089: v1(34.1,91.95) 33.53,91.38 33.53,90.83 30.35,87.65 30.35,83.8 v1(31.02,83.14)
  IN4 w0.089: v1(58.34,110.2) 57.79,109.66 52.29,109.66 51.5,110.45 47.77,110.45 47.48,110.75 46.78,110.75 43.96,107.93 42.89,107.93 38.99,104.03 38.99,97.96 36.26,95.24 36.26,94.59 35.2,93.53 35.2,93.05 v1(34.1,91.95) ; v1(115.23,28.03) 115.33,28.13 115.33,30.43 112.31,33.44 104.35,33.44 102.85,34.94 98.93,34.94 95,31.01 64.54,31.01 61.56,33.98 37.41,33.98 36.71,33.29 34.86,33.29 31.67,36.48 31.67,68.73 31.53,68.87 31.53,70.99 34.09,73.56 34.09,80.14 31.09,83.14 v1(31.02,83.14)
  BOTTOM w0.102: U18.G8 59.95,110.2 v1(58.34,110.2)
  BOTTOM w0.114: v1(171.18,56.65) 172.09,55.74 172.09,54.13 R398.1 172.53,53.44 v1(173.63,52.34) 174.1,51.87 CN9.14
EDP_TXN0: length 182.4
  IN3 w0.114: v1(179.33,66.75) 179.04,67.04 179.04,68.06 177.58,69.51 177.58,74.68 173.05,79.21 165.32,79.21 163.54,80.99 158.16,80.99 157.38,81.77 149.94,81.77 147.32,84.4 146.79,84.4 146.22,84.98 144.99,84.98 144.02,85.95 125.04,85.95 124.38,85.28 120.02,85.28 113.6,91.71 113.6,111.68 110.04,115.23 110.04,118.42 106.02,122.45 97.35,122.45 96.49,123.31 93.42,123.31 92.27,124.45 89.67,124.45 89.14,124.99 79.12,124.99 78.58,124.45 75.31,124.45 74.23,123.37 71.71,123.37 68.52,120.18 59.87,120.18 56.6,116.92 56.14,116.92 v1(55.9,117.16)
  BOTTOM w0.102: v1(55.9,117.16) 56.13,116.93 57.54,116.93 58.01,116.46 58.2,116.46 58.67,116 58.75,116 58.85,116.1 U18.E1
  BOTTOM w0.114: v1(179.33,66.75) 179.03,66.44 179.03,65.05 179.29,64.78 179.29,61.78 176.69,59.18 176.69,58.44 C667.2
EDP_TXN0_C: length 2.6
  BOTTOM w0.114: R377.1 176.87,55.21 176.87,56.41 176.56,56.72 176.56,56.96 C667.1
EDP_TXN0_R: length 4.7
  BOTTOM w0.114: CN9.19 176.6,50.51 176.46,50.65 176.46,51.32 176.57,51.44 176.57,53.07 176.87,53.36 176.87,54.22 R377.2
EDP_TXN1: length 180.3
  IN3 w0.114: v1(59.25,114.28) 59.05,114.28 58.97,114.36 58.97,115.08 61.29,117.39 67.14,117.39 72.19,122.44 74.61,122.44 75.69,123.52 78.96,123.52 79.51,124.06 88.75,124.06 89.29,123.53 91.89,123.53 93.03,122.38 96.1,122.38 96.97,121.52 105.63,121.52 109.12,118.04 109.12,114.85 112.67,111.3 112.67,91.31 120.84,83.14 125.69,83.14 127.14,84.59 137.05,84.59 137.48,85.02 143.62,85.02 144.59,84.05 145.78,84.05 149.39,80.44 157.2,80.44 157.58,80.06 163.16,80.06 164.94,78.29 172.66,78.29 176.66,74.29 176.66,66.59 180.25,63 180.25,60.72 180.59,60.38 181.11,60.38 181.24,60.25 v1(181.24,60.1)
  BOTTOM w0.102: v1(59.25,114.28) 58.87,113.9 U18.E4
  BOTTOM w0.114: C669.2 179.18,58.07 178.88,58.07 178.78,58.17 178.78,59.82 179.35,60.39 181.11,60.39 181.24,60.25 v1(181.24,60.1)
EDP_TXN1_C: length 2.5
  BOTTOM w0.114: C669.1 178.91,57.02 178.91,56.79 179.15,56.54 179.15,55.13 R379.1
EDP_TXN1_R: length 5
  BOTTOM w0.114: CN9.22 178.1,50.56 177.96,50.7 177.96,51.1 178.77,51.91 178.77,52.92 179.15,53.31 179.15,53.74 179.13,53.76 R379.2
EDP_TXP0: length 182.4
  IN3 w0.114: v1(178.54,66.75) 178.83,67.04 178.83,67.97 177.37,69.43 177.37,74.59 172.96,79 165.23,79 163.45,80.78 158.07,80.78 157.29,81.56 149.85,81.56 147.23,84.18 146.7,84.18 146.13,84.76 144.9,84.76 143.93,85.73 125.13,85.73 124.46,85.07 119.93,85.07 113.38,91.62 113.38,111.59 109.83,115.14 109.83,118.33 105.93,122.23 97.26,122.23 96.4,123.09 93.33,123.09 92.18,124.24 89.58,124.24 89.05,124.78 79.21,124.78 78.67,124.23 75.4,124.23 74.32,123.15 71.8,123.15 68.61,119.97 59.96,119.97 56.69,116.71 56.1,116.71 56.05,116.66 v1(55.9,116.51)
  BOTTOM w0.102: v1(55.9,116.51) 56.12,116.73 57.46,116.73 57.93,116.26 58.12,116.26 58.58,115.8 58.75,115.8 58.85,115.7 U18.E2
  BOTTOM w0.114: C666.2 176.35,58.15 176.47,58.28 176.47,59.26 179.08,61.87 179.08,64.69 178.81,64.96 178.81,66.47 v1(178.54,66.75)
EDP_TXP0_C: length 2.6
  BOTTOM w0.114: R376.1 176.07,55.21 176.07,56.42 176.35,56.7 176.35,56.99 C666.1
EDP_TXP0_R: length 4.7
  BOTTOM w0.114: CN9.18 176.1,50.56 176.24,50.7 176.24,51.41 176.36,51.52 176.36,53.09 176.07,53.38 176.07,54.22 R376.2
EDP_TXP1: length 180.3
  IN3 w0.114: v1(58.48,114.28) 58.76,114.55 58.76,115.17 61.2,117.61 67.05,117.61 72.1,122.65 74.52,122.65 75.6,123.73 78.87,123.73 79.42,124.28 88.84,124.28 89.38,123.74 91.98,123.74 93.12,122.6 96.19,122.6 97.06,121.73 105.72,121.73 109.33,118.13 109.33,114.94 112.88,111.39 112.88,91.4 120.93,83.35 125.6,83.35 127.05,84.8 136.96,84.8 137.39,85.23 143.71,85.23 144.68,84.27 145.87,84.27 149.48,80.66 157.29,80.66 157.67,80.28 163.25,80.28 165.03,78.5 172.75,78.5 176.87,74.38 176.87,66.68 180.47,63.09 180.47,60.81 180.68,60.6 180.95,60.6 v1(181.24,60.9)
  BOTTOM w0.102: v1(58.48,114.28) 58.85,114.65 U18.E3
  BOTTOM w0.114: v1(181.24,60.9) 180.95,60.61 179.26,60.61 178.56,59.91 178.56,58.47 C668.2
EDP_TXP1_C: length 2.9
  BOTTOM w0.114: C668.1 178.53,57.37 178.69,57.21 178.69,56.84 178.35,56.51 178.35,55.34 R378.1
EDP_TXP1_R: length 5
  BOTTOM w0.114: CN9.21 177.6,50.51 177.74,50.65 177.74,51.19 178.55,52 178.55,53.04 178.35,53.24 178.35,54.09 R378.2
EGPIO119: length 2.8
  TOP w0.114: v2(86.53,112.71) 86.94,113.12 87.35,113.12 R578.1
  BOTTOM w0.102: v2(86.53,112.71) 86.53,112.18 U18.AW7
EN_LCDVCC: length 9.7
  TOP w0.114: U206.4 168.57,51.48 169.11,52.02 170.92,52.02 v1(171.98,50.96) 172.17,50.77 173.53,50.77 R112.1 174.07,50.97 174.44,50.6 D3.3
FAN1_PWM: length 283
  TOP w0.114: v1(206.44,9.63) 206.44,8.69 203.76,6 190.42,6 179.04,17.39 158.63,17.39 157.16,18.85 131.76,18.85 130.49,20.13 128.93,20.13 126.66,17.86 115.79,17.86 114.47,16.54 110.68,16.54 109.97,17.25 108.01,17.25 105.32,19.94 v1(103.8,19.94) 100.22,19.94 97.94,17.66 96.23,17.66 94.01,19.87 82.74,19.87 67.73,34.88 58.34,34.88 55.53,32.07 35.17,32.07 30.77,36.46 30.77,57.05 28.35,59.47 25.17,59.47 24.51,60.12 24.51,65.22 26.96,67.67 28.08,67.67 28.47,68.06 33.92,68.06 37.04,71.17 37.04,85.91 36.5,86.45 35.84,86.45 32.4,89.89 FAN1.1 ; U34.28 v1(219.38,13.41)
  BOTTOM w0.114: v1(206.44,9.63) 210.73,9.63 213.83,12.73 218.7,12.73 v1(219.38,13.41)
FAN1_TACH: length 291.6
  TOP w0.114: U34.47 227.97,8.96 v1(227.78,8.78) ; v1(204.52,7.48) 204.51,7.48 203.42,6.38 190.58,6.38 179.19,17.77 158.81,17.77 157.48,19.09 132.06,19.09 130.64,20.51 128.72,20.51 126.46,18.24 115.63,18.24 114.31,16.92 110.76,16.92 110.05,17.63 108.16,17.63 105.42,20.38 v1(102.07,20.38) 100.11,20.38 97.78,18.04 96.19,18.04 94.11,20.12 82.84,20.12 67.69,35.26 58.38,35.26 55.59,32.47 35.48,32.47 31.15,36.8 31.15,57.21 28.51,59.85 25.32,59.85 24.89,60.28 24.89,65.06 27.12,67.29 28.24,67.29 28.63,67.68 34.08,67.68 37.42,71.02 37.42,85.87 36.6,86.69 36.01,86.69 33.65,89.06 FAN1.2 33.65,91.23 33.29,91.59 R55.1
  BOTTOM w0.114: v1(227.78,8.78) 227.78,7.63 227.36,7.21 204.78,7.21 v1(204.52,7.48)
FAN2_PWM: length 104.8
  TOP w0.114: U34.25 218.77,14.61 218.04,13.88 215.62,13.88 215.31,13.57 215.31,12.74 v1(213.01,10.44) 212.54,9.96 208.98,9.96 205.37,13.57 198.88,13.57 191.44,21.01 191.44,28.29 191.94,28.79 191.94,39.48 190,41.42 190,50.32 184.79,55.53 184.79,64.35 179.89,69.24 179.89,72.99 178.18,74.71 173.24,74.71 172.33,75.61 170.81,75.61 170.65,75.77 FAN2.1
FAN2_TACH: length 119.8
  TOP w0.114: U34.48 228.37,8.24 v1(228.05,7.93) 227.32,7.2 210.29,7.2 205.6,11.89 201.36,11.89 201.18,12.07 199.36,12.07 190.72,20.71 190.72,28.68 190.99,28.96 190.99,36.38 190.72,36.65 190.72,40.27 189.76,41.23 189.76,50.22 184.48,55.51 184.48,64.23 179.6,69.1 179.6,72.94 178.08,74.46 173.14,74.46 172.23,75.37 170.42,75.37 170.07,75.72 170.07,78.44 R75.1 171.9,77.92 FAN2.2
FB_VMEMIO: length 21
  TOP w0.102: v1(152.81,115.05) 152.81,116.53 153.35,117.07
  TOP w0.114: 153.35,117.07 158.84,122.56 TP180.1
  IN1 w0.127: v1(152.81,115.05) 152.11,114.35 152.11,113.84 150.07,111.8 v1(150.07,111.54)
  BOTTOM w0.127: v1(150.07,111.54) 150.25,111.72 U22.C3
FCH_PC: length 25.1
  IN4 w0.508: v1(117.71,58.22) v1(117.71,60.78) 116.4,62.1 116.4,69.33 117.09,70.03 v1(117.71,70.03)
  BOTTOM w0.381: PU30.2 118.34,61.17 118.93,60.58 PR462.2 PR458.1 117.71,60.22 v1(117.71,60.78) ; PU30.5 PC9300.1 115.8,69.83 v1(115.99,70.03) v1(117.71,70.03)
  BOTTOM w0.508: v1(117.71,58.22) 116.5,58.22 116.08,57.79 PR460.2 116.08,57.08 116.35,56.81 PQ65.1
FPVCC: length 5.9
  BOTTOM w0.114: R720.2 124.9,102.35 124.9,102.35 125.27,101.99 127.14,101.99 127.76,101.36 129.19,101.36 129.35,101.21 129.59,101.21 U22.AC40
G9336_DRV: length 11.9
  BOTTOM w0.381: PU20.6 124.46,49.35 123.97,48.85 123.97,47.12 v1(123.82,46.98) 123.58,46.74 119.99,46.74 119.79,46.95 119.79,48.48 119.99,48.69 PR369.2 120.51,49.41 120.12,49.8 PQ54.3
G_WAKEB: length 6.2
  BOTTOM w0.114: R711.1 125.29,89.61 128.71,93.03 129.18,93.03 129.5,93.35 U22.AU40
GFX_PWRGD: length 335.6
  TOP w0.114: R1076.2 242.76,23.82 v1(242.39,24.19)
  IN1 w0.089: v1(36.68,124.27) 35.55,124.27 34.85,123.56 34.85,117.88 31.58,114.61 31.58,97.38 32.62,96.34 32.62,91.21 29.44,88.03 29.44,82.08 v1(31.02,80.5)
  IN4 w0.089: v1(31.02,80.5) 31.5,80.5 32.49,79.51 32.49,73.25 30.61,71.37 30.61,65.05 29.77,64.21 29.77,59.29 30.75,58.31 30.75,36.1 34.48,32.37 37.09,32.37 37.79,33.07 61.18,33.07 64.16,30.1 95.43,30.1 98.58,33.24 101.74,33.24 102.22,32.76 110.8,32.76 112.25,31.3 113.62,31.3 113.98,30.94 113.98,28.58 114.97,27.59 115.56,27.59 116.5,28.53 116.98,28.53 118.02,27.49 118.02,26.62 119.09,25.56 121.3,25.56 122.26,24.6 123.88,24.6 125.41,23.07 126.29,23.07 126.86,22.5 133.43,22.5 133.98,21.96 138.81,21.96 139.41,22.55 147.35,22.55 148.6,23.81 152.7,23.81 153.47,24.59 155.52,24.59 155.74,24.37 172.07,24.37 173.37,23.07 183.18,23.07 185.44,25.32 193.12,25.32 193.72,25.92 200.44,25.92 201.04,25.32 209.72,25.32 210.74,26.34 227.59,26.34 228.94,27.69 228.94,29.86 230.5,31.41 238.43,31.41 242.39,27.46 v1(242.39,24.19)
  BOTTOM w0.114: PU17.20 36.88,124.06 v1(36.68,124.27) 35.8,125.14 35.8,125.68 35.06,126.42 PR509.2
GFX_SVC: length 16.2
  IN3 w0.254: v1(46.51,108.46) 45.63,109.33 45.63,111.5 41.36,115.77 v1(41.36,115.75)
  BOTTOM w0.254: PR309.1 v1(41.36,115.75) ; v1(46.51,108.46) 46.51,106.94 R501.1 47.16,106.28 48.49,106.28 R506.2 R494.2
GFX_SVC_R: length 6.6
  BOTTOM w0.152: 55.2,104.83 55.26,104.83 55.52,104.57 56.38,104.57 U18.B16
  BOTTOM w0.254: 55.2,104.83 53.62,104.83 51.68,106.76 R494.1
GFX_SVD: length 25.2
  IN3 w0.254: v1(40.15,115.77) 40.47,115.77 45,111.24 45,109.07 45.82,108.25 45.82,103.72 45.18,103.08 44.36,103.08 v1(44.02,103.41)
  BOTTOM w0.254: R495.2 49.98,102.96 48.42,102.96 48.19,102.72 R507.2 48.03,102.3 R502.1 46.14,102.83 44.6,102.83 v1(44.02,103.41) ; PR314.1 v1(40.15,115.77)
GFX_SVD_R: length 5.2
  BOTTOM w0.254: U18.A18 55.8,102.45 53.09,102.45 52.09,103.45 R495.1
GFX_SVT: length 25.5
  IN3 w0.254: v1(38.34,116.16) 38.67,116.16 39.01,116.5 41.62,116.5 46.27,111.85 46.27,109.77 46.66,109.37 v1(47.64,109.37)
  BOTTOM w0.114: 55.3,105.4 55.59,105.4 55.85,105.13 56.21,105.13 U18.B15
  BOTTOM w0.254: PR316.1 37.89,116.16 v1(38.34,116.16) ; v1(47.64,109.37) 47.82,109.37 R500.1 49.03,108.16 v1(49.19,108.16) 49.33,108.3 51.77,108.3 52.01,108.06 52.01,107.69 54.3,105.4 55.3,105.4
GPIO0: length 3.1
  BOTTOM w0.114: TP263.1 256.98,14.09 256.98,15.1 256.85,15.23 U28.17
GPIO_0: length 8.8
  BOTTOM w0.114: R683.1 122.94,105.71 124.09,105.71 R681.2 125.14,106.15 v1(125.38,105.91) 125.67,105.62 127.14,105.62 129.51,103.25 U22.W40
GPIO_1: length 8.9
  BOTTOM w0.114: R923.1 122.96,103.4 124.07,103.4 R922.2 124.78,103.87 125.41,104.5 126.68,104.5 128.73,102.46 129.18,102.46 129.49,102.15 U22.AA40
GPIO_2: length 18.2
  TOP w0.114: v2(133.03,102.77) 132.64,102.38 128.26,102.38 123.81,106.83 v1(121.63,106.83) 120.83,106.83 R924.2 119.84,106.79 118.89,106.79 R925.1
  BOTTOM w0.127: U22.AA35 133.03,102.42 v2(133.03,102.77)
GPIO_7_BLON: length 13.7
  TOP w0.114: R719.2 120.79,104.31 121.64,104.31 v1(121.91,104.04) 122.17,104.31 125.16,104.31 128.45,101.02 131.14,101.02 v2(131.53,100.63)
  BOTTOM w0.127: U22.AC37 v2(131.53,100.63)
GPIO_8_ROMSO: length 13.7
  TOP w0.114: R927.1 R926.2 139.69,95.45 TP289.1 139,95.45 v2(138.7,95.75)
  IN2 w0.127: v2(138.7,95.75) 138.24,95.29 138.24,94.38 138.48,94.13 138.48,92.94 138.24,92.7 138.24,90.08 v1(137.66,89.51)
  BOTTOM w0.102: v1(137.66,89.51) 138.93,88.24 138.93,87.99
  BOTTOM w0.114: R1086.1 138.93,87.99
  BOTTOM w0.127: U22.AP25 138.55,95.75 v2(138.7,95.75)
GPIO_9_ROMSI: length 11.3
  TOP w0.114: v2(137.5,95.75) 137.87,96.12 TP288.1
  IN2 w0.127: v2(137.5,95.75) 137.7,95.55 137.7,94.16 137.95,93.91 137.95,93.16 137.7,92.92 137.7,90.35 v1(137.48,90.13)
  BOTTOM w0.102: v1(137.48,90.13) 136.64,89.29 136.64,87.99
  BOTTOM w0.114: R1085.1 136.64,87.99
  BOTTOM w0.127: v2(137.5,95.75) 137.75,95.75 U22.AM25
GPIO_10_ROMSCK: length 11.7
  TOP w0.114: v2(136.6,95.75) 136.6,95.75 TP287.1
  IN2 w0.127: v1(136.79,90.09) 136.79,90.21 137.14,90.56 137.14,92.77 136.87,93.04 136.87,93.81 137.17,94.11 137.17,95.18 v2(136.6,95.75)
  BOTTOM w0.102: v1(136.79,90.09) 134.87,88.17 134.87,87.99
  BOTTOM w0.114: R1084.1 134.87,87.99
  BOTTOM w0.127: U22.AM27 136.65,95.75 v2(136.6,95.75)
GPIO_11: length 8
  BOTTOM w0.114: U22.W41 129.05,103.26 126.94,105.36 124.89,105.36 R928.2 124.07,105.47 122.96,105.47 R929.1
GPIO_12: length 14.5
  BOTTOM w0.114: U22.Y40 129.85,102.7 129.54,103.01 129.26,103.01 129.19,102.94 128.9,102.94 126.73,105.11 125.34,105.11 124.79,104.56 120.01,104.56 R931.1 119.13,105.44 117.84,105.44 R930.2
GPIO_13: length 13.7
  BOTTOM w0.102: 126.14,104.87 126.65,104.87 128.81,102.7
  BOTTOM w0.114: R932.2 117.86,104.32 119.1,104.32 R933.1 120.02,104.32 124.89,104.32 125.44,104.87 126.14,104.87 ; U22.Y41 128.81,102.7
GPIO_15: length 4.3
  BOTTOM w0.102: 126.14,103.94 126.51,103.94 128.3,102.15 U22.AA41
  BOTTOM w0.114: 126.14,103.94 TP312.1
GPIO_20: length 15.4
  BOTTOM w0.102: 126.14,103.45 126.34,103.45 126.63,103.16
  BOTTOM w0.114: 126.63,103.16 127.96,101.83 129.18,101.83 129.26,101.91 129.54,101.91 129.85,101.6 U22.AB40 ; R935.2 117.4,102.07 v1(117.62,101.86) 118.05,101.86 118.91,102.72 R934.1 120.04,102.24 120.64,102.24 121.07,102.67 121.07,102.85 121.38,103.16 124.54,103.16 124.83,103.45 126.14,103.45
GPIO_21_PCC: length 4.3
  BOTTOM w0.114: TP304.1 126.81,102.65 127.86,101.6 U22.AB41
GPIO_22_ROMCSB: length 14.6
  TOP w0.114: R936.1 R937.2 137.16,94.33 TP286.1 137.07,94.41 v2(136.61,94.86)
  IN2 w0.127: v1(136.43,90.64) 136.12,90.96 136.12,94.37 v2(136.61,94.86)
  BOTTOM w0.102: v1(136.43,90.64) 136.54,90.53 138.23,90.53 140.71,88.06 140.71,87.99
  BOTTOM w0.114: R1083.1 140.71,87.99
  BOTTOM w0.127: U22.AP27 137.05,95.3 v2(136.61,94.86)
GPIO_29: length 17.2
  TOP w0.114: R938.1 120.59,111.62 120.59,110.97 R939.2 120.34,110.42 120.57,110.2 v1(121.53,110.2) 121.7,110.02 123.73,110.02 129.25,104.5 131.89,104.5 132.33,104.06 v2(132.33,103.94)
  BOTTOM w0.102: U22.W37 131.95,103.56 v2(132.33,103.94)
GPIO_30: length 2.3
  TOP w0.114: TP311.1 132.33,103.36 131.77,103.92 v2(131.53,103.92)
  BOTTOM w0.102: U22.W38 131.15,103.53 v2(131.53,103.92)
GPIO_SVC: length 12.2
  TOP w0.114: R697.2 139.33,87.54 142.07,90.28 v1(142.07,92.94) 142.07,93.28 v2(142.94,94.15)
  BOTTOM w0.127: U22.AU17 142.55,93.76 v2(142.94,94.15)
GPIO_SVD: length 13.4
  TOP w0.114: v2(142.94,93.35) 143.73,92.56 143.73,90.4 146.43,87.7 146.43,84.27 v1(146.34,84.18) 146.2,84.04 R698.2
  BOTTOM w0.127: U22.AV17 142.55,92.96 v2(142.94,93.35)
GPIO_SVT: length 13.4
  TOP w0.114: v2(142.94,94.95) v1(142.35,94.37) 141.54,93.56 141.54,90.13 139.09,87.66 139.09,84.76 R699.2
  BOTTOM w0.127: U22.AR17 142.55,94.56 v2(142.94,94.95)
GPU_DMINUS: length 1.9
  TOP w0.114: TP281.1 133.1,106.29 v2(133.1,107.18)
  BOTTOM w0.127: U22.N34 133.1,107 v2(133.1,107.18)
GPU_DPLUS: length 1.5
  TOP w0.114: TP280.1 132.36,107.01 v2(132.36,107.18)
  BOTTOM w0.127: U22.N35 132.36,106.94 v2(132.36,107.18)
GPU_FB_VDDC: length 74.5
  IN2 w0.127: v2(145.43,94.97) 144.71,94.25 144.71,93.2 144.11,92.6 144.11,85.97 143.7,85.56 137.4,85.56 136.71,86.24 134.65,86.24 132.39,88.5 130.63,88.5 123.66,81.54 123.66,66.67 122.73,65.73 122.73,55.68 129.18,49.23 v1(132.35,49.23)
  BOTTOM w0.102: U22.AR13 145.17,94.97 v2(145.43,94.97)
  BOTTOM w0.114: PR442.2 132.97,48.7 132.44,49.23 v1(132.35,49.23)
GPU_FB_VDDCI: length 94
  IN2 w0.127: v1(150.08,47.93) 148.58,47.93 145.93,45.29 136.4,45.29 133.62,48.07 133.62,50.33 133.19,50.77 128.4,50.77 123.26,55.91 123.26,65.51 124.19,66.45 124.19,81.31 130.85,87.97 132.17,87.97 134.43,85.71 136.49,85.71 137.18,85.03 143.92,85.03 144.65,85.75 144.65,92.38 145.43,93.16 v2(145.43,93.35)
  BOTTOM w0.102: U22.AV13 145.03,92.95 v2(145.43,93.35)
  BOTTOM w0.254: v1(150.08,47.93) 150.08,47.94 149.57,48.45 PR391.2
GPU_FB_VSS: length 75.1
  TOP w0.114: v1(132.35,49.88) 133.26,49.88 v1(133.59,49.56) 134.2,48.94 PR445.2
  IN2 w0.127: v1(132.35,49.88) 128.91,49.88 122.99,55.8 122.99,65.62 123.93,66.56 123.93,81.43 130.74,88.24 132.28,88.24 134.54,85.98 136.6,85.98 137.29,85.29 143.81,85.29 144.38,85.86 144.38,92.49 144.98,93.09 144.98,93.7 v1(145.43,94.15)
  BOTTOM w0.102: v1(145.43,94.15) 145.03,93.75 U22.AU13
GPU_SVC: length 73.9
  TOP w0.114: v1(144.55,81.55) 144.3,81.29 142.87,81.29 141.95,82.21 140.38,82.21 R697.1 R747.1 R749.2
  BOTTOM w0.114: PR406.2 144.59,43.3 v1(145.48,42.41) 150.6,42.41 151.02,42.83 153.16,42.83 161.82,51.48 161.82,69.52 157.1,74.24 157.1,78.57 153.6,82.07 145.08,82.07 v1(144.55,81.55)
GPU_SVD: length 75.4
  TOP w0.114: v1(143.16,81.99) 142.31,82.84 R750.2 R748.1 R698.1
  BOTTOM w0.114: v1(143.16,81.99) 143.73,82.56 153.8,82.56 157.59,78.78 157.59,74.45 162.31,69.73 162.31,51.28 153.56,42.53 151.32,42.53 150.71,41.91 145.28,41.91 144.16,43.02 142.11,43.02 v1(141.54,43.59) PR410.2
GPU_SVT: length 81.3
  TOP w0.114: R699.1 140.06,81.57 v1(141.63,81.57)
  BOTTOM w0.114: PR413.2 139.56,44.02 141.06,42.52 v1(143.29,42.52) 143.3,42.53 143.96,42.53 145.07,41.42 150.89,41.42 151.71,42.23 153.97,42.23 162.81,51.07 162.81,69.93 158.09,74.65 158.09,78.98 154.01,83.06 143.12,83.06 v1(141.63,81.57)
GPU_VR_HOT: length 202.8
  TOP w0.114: Q64.2 114.67,110.54 C9378.1 114.28,110.01 114.28,91.21 112.47,89.4 v1(112.47,85.5) ; v1(196.21,36.93) 196.21,35.79 198,34 235.28,34 237.81,31.48 237.81,25.09 236.93,24.21 U34.96
  IN2 w0.127: v1(112.47,85.5) 111.92,84.95 111.55,84.95 110.98,84.38 110.98,60.97 116.37,55.58 120.36,55.58 129.82,46.12 129.82,45.15 132.19,42.78 140.68,42.78 142.86,44.96 151.17,44.96 152.46,43.67 177.15,43.67 181.95,38.87 194.28,38.87 v1(196.21,36.93)
GPU_VR_HOT#_IC: length 121.2
  TOP w0.114: v1(111.72,85.5) 112.23,86.01 112.23,89.5 114.04,91.31 114.04,112.45 Q64.3 116.87,113.75 117.06,113.94 117.09,113.96 117.75,113.96 R1091.1 C9377.1 R1096.2 118.64,111.49 118.9,111.74 118.9,112.29 119.49,112.88 119.83,112.88 v1(119.95,112.76) 121.22,112.76 122.81,111.16 123.71,111.16 128.98,105.89 130.86,105.89 131.29,105.47 132.78,105.47 v2(133.31,104.93)
  IN2 w0.127: v1(142.51,43.74) 141.28,42.52 132.08,42.52 129.55,45.04 129.55,46.01 120.25,55.31 116.26,55.31 110.72,60.86 110.72,84.49 v1(111.72,85.5)
  BOTTOM w0.102: v2(133.31,104.93) 132.75,104.37 U22.U35
  BOTTOM w0.114: R1095.2 142.5,43.75 v1(142.51,43.74)
H_PROCHOT_EC: length 29.8
  TOP w0.114: v1(235.16,20.02) 235.35,20.21 U34.86 ; Q42.2 R872.2 213.55,20.6 v1(214.17,19.98)
  IN4 w0.089: v1(214.17,19.98) 214.73,19.43 214.73,17.32 215.57,16.48 220,16.48 222.33,18.81 230.04,18.81 231.87,20.64 234.54,20.64 v1(235.16,20.02)
HDA_BITCLK: length 181.3
  TOP w0.114: R234.1 v1(29.48,18.2) 30.7,19.42 v1(30.7,20.05) ; v1(93.2,112.74) 93.2,113.09 90.47,115.83 89.62,115.83 88.58,116.87 87.86,116.87 EC90.2 86.8,116.31 R561.1
  IN3 w0.127: v1(30.7,20.05) 30.7,21.24 36.92,27.46 43.63,27.46 55.43,39.26 85.44,39.26 88.67,42.49 98.11,42.49 98.99,43.37 107.54,43.37 108.44,44.26 108.44,46.96 109.45,47.97 109.45,67.6 106.71,70.34 106.71,83.17 104.65,85.23 104.65,96.03 105.32,96.7 105.32,101.59 103.63,103.28 103.63,108.23 99.52,112.34 96.2,112.34 95.81,112.74 v1(93.2,112.74)
HDA_BITCLK_R: length 7
  TOP w0.114: CN5.19 23.15,15.3 v1(24.24,16.39) 24.98,17.12 EC28.2 25.62,16.71 25.87,16.46 26.96,16.46 R234.2
HDA_RST#: length 214.4
  TOP w0.114: R563.1 89.16,114.59 89.61,115.04 90.14,115.04 90.91,114.28 90.91,112.96 91.94,111.93 96.1,111.93 97.19,113.02 105.57,113.02 108.71,109.87 108.71,106.91 108.23,106.42 108.23,92.72 105.75,90.24 105.75,76.68 111.78,70.65 111.78,69.96 113.79,67.95 113.79,59.39 114.52,58.66 114.52,38.79 114.21,38.47 114.21,37.15 110.11,33.05 110.11,27.77 109.99,27.65 109.99,21.08 v1(110.95,20.12) 110.74,19.91 v1(110.74,19.44) ; v1(23.07,13.11) 22.91,13.11 22.71,13.3 CN5.23
  IN4 w0.089: v1(110.74,19.44) 110.74,19.68 109.22,21.2 62.96,21.2 61.11,19.35 55.75,19.35 55.02,18.61 50.87,18.61 48.28,16.02 26.82,16.02 24.16,13.35 23.32,13.35 v1(23.07,13.11)
HDA_SDIN0: length 221.2
  TOP w0.114: v1(23.14,14.02) 22.85,14.3 CN5.21 ; v2(83.65,111.09) 83.92,111.09 84.49,111.66 R535.1 84.49,112.09 84.7,112.3 85.51,112.3 86.55,113.34 87.71,113.34 88.03,113.65 88.03,114 87.73,114.3 87.73,114.69 88.13,115.09 89.13,115.09 89.45,115.41 90.29,115.41 91.28,114.43 91.28,113.11 92.09,112.3 95.95,112.3 97.04,113.39 105.72,113.39 109.08,110.03 109.08,106.75 108.6,106.27 108.6,92.56 106.12,90.09 106.12,76.83 112.15,70.81 112.15,70.11 114.16,68.1 114.16,59.54 114.89,58.81 114.89,38.63 114.57,38.32 114.57,36.99 110.48,32.9 110.48,22.24 v1(110.5,22.22) 110.5,21.19 v1(110.59,21.1)
  IN4 w0.089: v1(110.59,21.1) 109.81,21.88 62.68,21.88 60.83,20.03 55.47,20.03 55.18,19.74 41.72,19.74 40.02,18.03 29.6,18.03 28.35,16.78 26.62,16.78 25.41,15.57 23.97,15.57 23.14,14.74 v1(23.14,14.02)
  BOTTOM w0.102: U18.AR8 83.26,110.7 v2(83.65,111.09)
HDA_SDOUT: length 219.4
  TOP w0.114: CN5.20 23.26,14.8 v1(23.64,14.42) ; R558.1 85.66,116.44 86.51,117.29 88.75,117.29 89.79,116.25 90.64,116.25 93.13,113.76 105.87,113.76 109.45,110.18 109.45,106.6 108.97,106.12 108.97,92.41 106.49,89.93 106.49,76.99 112.52,70.96 112.52,70.26 114.53,68.25 114.53,59.7 115.26,58.96 115.26,38.48 114.94,38.16 114.94,36.84 110.85,32.75 110.85,25.39 v1(111.64,24.6) 112.04,24.2 v1(112.04,19.45)
  IN4 w0.089: v1(23.64,14.42) 23.85,14.63 24.96,14.63 26.68,16.36 48.14,16.36 50.73,18.95 54.87,18.95 55.61,19.69 60.97,19.69 62.82,21.54 109.36,21.54 110.31,20.6 111.11,20.6 112.04,19.66 v1(112.04,19.45)
HDA_SYNC: length 211.3
  TOP w0.114: v1(110.13,19.66) 110.13,20.42 109.52,21.03 v1(109.52,26.5) 109.2,26.81 109.2,28.58 109.74,29.11 109.74,33.2 113.84,37.3 113.84,38.62 114.15,38.94 114.15,58.5 113.42,59.24 113.42,67.8 111.41,69.81 111.41,70.5 111.22,70.69 105.39,76.53 105.39,90.39 107.86,92.87 107.86,106.58 108.34,107.06 108.34,109.72 105.41,112.65 97.35,112.65 96.25,111.56 91.78,111.56 90.54,112.81 90.54,113.95 R559.1 ; CN5.22 22.73,13.8 22.99,13.54 23.38,13.54 23.57,13.35 24.01,13.35 v1(24.46,12.91)
  IN4 w0.089: v1(110.13,19.66) 109.1,19.66 108.26,20.51 63.28,20.51 61.41,18.65 56.03,18.65 55.3,17.92 52.36,17.92 49.68,15.24 32.07,15.24 30.79,13.96 27.48,13.96 27.14,13.63 25.78,13.63 25.07,12.91 v1(24.46,12.91)
HDD_LED_EN#: length 41.5
  TOP w0.114: U34.87 235.05,20.61 v1(234.48,20.04) ; Q16.2 v1(199.68,20.25)
  IN4 w0.089: v1(199.68,20.25) 201.41,18.52 211.77,18.52 212.86,17.43 214.3,17.43 215.48,16.25 220.09,16.25 222.42,18.58 230.14,18.58 231.96,20.41 234.11,20.41 v1(234.48,20.04)
HDMI_CFG: length 2.7
  TOP w0.191: U5.23 272.28,69.95 v1(272.26,69.98)
  BOTTOM w0.114: v1(272.26,69.98) 272.4,69.86 v1(272.4,69.09) R345.1
