# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ51: length 71
  IN4 w0.127: v1(98.27,51.77) 98.27,52.57 99.7,54 99.7,57.56 99.83,57.69 100.04,57.69 100.17,57.81 100.17,58.07 100.04,58.19 99.83,58.19 99.7,58.32 99.7,60.85 99.83,60.97 100.09,60.97 100.22,61.1 100.22,61.35 100.09,61.48 99.83,61.48 99.7,61.61 99.7,61.86 99.83,61.99 100.09,61.99 100.22,62.12 100.22,62.37 100.09,62.5 99.83,62.5 99.7,62.62 99.7,65.44 99.47,65.67 99.47,71.98 101.19,73.7 101.19,80.16 98.25,83.1 98.25,83.54 98.13,83.67 97.62,83.67 97.5,83.8 97.5,84.05 97.62,84.18 98.13,84.18 98.25,84.3 98.25,84.56 98.13,84.68 97.5,84.68 97.37,84.81 97.37,85.07 97.5,85.19 98.13,85.19 98.25,85.32 98.25,85.57 98.13,85.7 97.5,85.7 97.37,85.83 97.37,86.08 97.5,86.21 98.13,86.21 98.25,86.34 98.25,86.59 98.13,86.72 97.5,86.72 97.37,86.84 97.37,87.1 97.5,87.22 98.13,87.22 98.25,87.35 98.25,87.61 98.13,87.73 97.5,87.73 97.37,87.86 97.37,88.11 97.5,88.24 98.13,88.24 98.25,88.37 98.25,88.69 98.13,88.82 97.71,88.82 97.6,88.93 97.6,89.2 97.73,89.32 98.13,89.32 98.25,89.45 98.25,93.06 92.48,98.84 89.87,98.84 88.43,100.28 86.61,100.28 v2(86.45,100.44)
  BOTTOM w0.178: CN16.229 98.23,51.81 v1(98.27,51.77) ; U18.AW20 86.15,100.74 v2(86.45,100.44)
M_A_DQ52: length 71.4
  IN4 w0.127: v1(94.22,49.76) 94.5,49.76 94.65,49.61 94.65,49.2 94.3,48.85 94.3,47.64 94.2,47.55 93.87,47.55 93.76,47.66 93.76,52.23 93.89,52.36 94.17,52.36 94.3,52.48 94.3,52.74 94.17,52.86 93.89,52.86 93.76,52.99 93.76,53.4 93.87,53.5 94.07,53.5 94.18,53.61 94.18,54.17 94.83,54.82 94.83,58.35 95.13,58.65 95.13,65.33 95.21,65.41 95.48,65.41 95.59,65.52 95.59,65.78 95.46,65.9 95.13,65.9 95,66.03 95,66.28 95.13,66.41 95.46,66.41 95.59,66.54 95.59,66.79 95.46,66.92 95.13,66.92 95.01,67.04 95.01,73.02 97.31,75.31 97.31,78.49 92.71,83.08 92.71,89.87 92.35,90.24 92.35,91.57 88.7,95.21 88.7,96.1 87.9,96.9 87.08,96.9 86.88,97.1 85.21,97.1 85,97.31 82.87,97.31 82.79,97.39 82.79,97.9 82.9,98 v2(83.25,98)
  BOTTOM w0.178: U18.AR23 82.95,98.3 v2(83.25,98) ; v1(94.22,49.76) 93.8,49.76 93.51,50.06 93.51,51.06 93.73,51.29 CN16.211
M_A_DQ53: length 71
  IN4 w0.127: v1(84.06,97.96) 83.92,97.96 83.58,98.3 83.58,98.62 83.74,98.78 84.4,98.78 85.05,98.13 85.05,97.87 85.58,97.35 87.07,97.35 87.28,97.13 88.05,97.13 89.17,96.02 89.17,95.31 89.57,94.9 89.75,94.9 89.93,95.08 90.32,95.08 93.21,92.19 93.21,83.19 97.74,78.67 97.74,75.13 96.02,73.42 96.02,73.11 95.89,72.99 95.59,72.99 95.46,72.86 95.46,72.6 95.59,72.48 95.89,72.48 96.02,72.35 96.02,72.1 95.89,71.97 95.57,71.97 95.44,71.84 95.44,71.59 95.57,71.46 95.89,71.46 96.02,71.33 96.02,71.08 95.89,70.95 95.57,70.95 95.44,70.83 95.44,70.57 95.57,70.45 95.89,70.45 96.02,70.32 96.02,70.06 95.89,69.94 95.57,69.94 95.44,69.81 95.44,69.56 95.57,69.43 95.89,69.43 96.02,69.3 96.02,69.05 95.89,68.92 95.57,68.92 95.44,68.79 95.44,68.54 95.57,68.41 95.89,68.41 96.02,68.29 96.02,68.03 95.89,67.91 95.57,67.91 95.44,67.78 95.44,67.52 95.57,67.4 95.89,67.4 96.02,67.27 96.02,65.23 95.51,64.71 95.51,61.33 95.63,61.2 95.97,61.2 96.1,61.08 96.1,60.82 95.97,60.7 95.63,60.7 95.51,60.57 95.51,60.36 95.7,60.17 95.7,59.85 95.51,59.66 95.51,58.51 95.34,58.35 95.34,58.17 95.47,58.04 95.87,58.04 96,57.92 96,57.66 95.87,57.54 95.39,57.54 95.29,57.43 95.29,57.16 95.42,57.03 95.87,57.03 96,56.9 96,56.65 95.87,56.52 95.44,56.52 95.31,56.39 95.31,56.14 95.44,56.01 95.87,56.01 96,55.88 96,55.63 95.87,55.5 95.39,55.5 95.26,55.38 95.26,54.62 94.65,54.01 94.65,51.24 94.54,51.12 v1(94.23,51.12)
  BOTTOM w0.178: v1(84.06,97.96) 83.75,98.27 U18.AT23 ; CN16.215 94.73,51.62 v1(94.23,51.12)
M_A_DQ54: length 72.1
  IN4 w0.127: v1(98.34,46.9) 99.17,47.73 99.17,52.18 100.65,53.65 100.65,56.89 101.02,57.26 101.02,64.99 100.57,65.44 100.57,65.84 100.34,66.07 100.34,71.62 102.06,73.34 102.06,80.52 99.12,83.46 99.12,93.01 92.54,99.59 90.02,99.59 88.12,101.49 87.05,101.49 86.71,101.15 84.06,101.15 v2(83.38,100.47)
  BOTTOM w0.178: v1(98.34,46.9) 97.85,46.41 97.85,45.93 97.98,45.8 CN16.228 ; U18.AR20 82.95,100.89 v2(83.38,100.47)
M_A_DQ55: length 71.3
  IN4 w0.127: v1(98.29,50.48) 98.29,49.39 98.18,49.28 97.88,49.28 97.74,49.42 97.74,52.67 99.27,54.2 99.27,65.13 99.04,65.36 99.04,72.16 100.76,73.88 100.76,79.92 96.92,83.76 96.92,89.29 97.28,89.64 97.75,89.64 97.88,89.77 97.88,90.03 97.75,90.15 97.45,90.15 97.32,90.28 97.32,90.53 97.45,90.66 97.75,90.66 97.85,90.76 97.85,93.06 92.31,98.6 89.72,98.6 88.35,99.97 84.52,99.97 v2(84.05,100.44)
  BOTTOM w0.178: v1(98.29,50.48) 98.04,50.22 97.46,50.22 97.23,50.45 CN16.225 ; v2(84.05,100.44) 84.05,100.7 U18.AT20
M_A_DQ56: length 74.2
  IN4 w0.127: v1(94.14,99.2) 99.98,93.36 99.98,83.82 102.92,80.88 102.92,66.51 102.79,66.38 102.54,66.38 102.41,66.51 102.41,71.97 102.28,72.1 102.03,72.1 101.9,71.97 101.9,66 102.03,65.87 102.81,65.87 102.93,65.74 102.93,65.16 102.46,64.68 102.46,58.54 101.89,57.97 101.89,56.72 101.77,56.6 101.64,56.6 101.51,56.47 101.51,56.22 101.64,56.09 101.77,56.09 101.89,55.96 101.89,55.71 101.77,55.58 101.64,55.58 101.51,55.45 101.51,55.2 101.64,55.07 101.83,55.07 101.93,54.97 101.93,54.64 101.83,54.53 101.61,54.53 101.51,54.43 101.51,54.12 101.61,54.02 101.78,54.02 101.89,53.9 101.89,53.62 100.12,51.86 v1(100.12,51.75)
  BOTTOM w0.102: U18.BB23 88.77,98.81 89.14,98.81 89.27,98.94 92.24,98.94 92.42,98.77 93.72,98.77 v1(94.14,99.2)
  BOTTOM w0.178: v1(100.12,51.75) 100.23,51.85 CN16.237
M_A_DQ57: length 74.2
  IN4 w0.127: v1(100.12,50.45) 100.12,50.37 99.94,50.18 99.6,50.18 99.51,50.27 99.51,51.87 101.08,53.45 101.08,56.67 101.44,57.03 101.44,58.29 101.53,58.39 101.83,58.39 102.09,58.65 102.09,61.3 101.96,61.43 101.54,61.43 101.42,61.56 101.42,61.81 101.54,61.94 101.96,61.94 102.09,62.06 102.09,62.32 101.96,62.44 101.56,62.44 101.45,62.56 101.45,62.81 101.59,62.95 101.96,62.95 102.09,63.08 102.09,64.23 101.74,64.58 101.74,64.85 101.83,64.94 102.15,64.94 102.27,65.07 102.27,65.33 102.15,65.46 101.59,65.46 101.44,65.61 101.44,65.92 101.31,66.05 100.95,66.05 100.83,66.18 100.83,66.43 100.95,66.56 101.31,66.56 101.44,66.68 101.44,66.94 101.31,67.07 100.9,67.07 100.77,67.19 100.77,67.45 100.9,67.57 101.31,67.57 101.44,67.7 101.44,67.95 101.31,68.08 100.9,68.08 100.77,68.21 100.77,68.46 100.9,68.59 101.31,68.59 101.44,68.72 101.44,68.97 101.31,69.1 100.9,69.1 100.77,69.22 100.77,69.48 100.9,69.61 101.31,69.61 101.44,69.73 101.44,69.99 101.31,70.11 100.9,70.11 100.77,70.24 100.77,70.49 100.9,70.62 101.31,70.62 101.44,70.75 101.44,71 101.31,71.13 100.96,71.13 100.83,71.26 100.83,71.51 100.96,71.64 101.31,71.64 101.44,71.76 101.44,72.11 101.87,72.55 102.38,72.55 102.49,72.66 102.49,80.7 99.55,83.64 99.55,93.17 v1(93.37,99.35)
  BOTTOM w0.102: U18.BB22 88.46,99.08 89.12,99.08 89.18,99.15 93.17,99.15 v1(93.37,99.35)
  BOTTOM w0.178: v1(100.12,50.45) 99.79,50.12 99.41,50.12 99.23,50.3 CN16.233
M_A_DQ58: length 74.4
  IN4 w0.127: v1(91.02,101.06) 91.02,101.53 92.09,102.6 95.94,102.6 97.47,101.07 98.26,101.07 104.35,94.98 104.35,85.56 107.43,82.48 107.43,67.38 108.42,66.39 108.42,58.08 107.86,57.52 107.86,52.59 105.66,50.39 105.66,48.86 104.71,47.91 104.71,47.34 v1(103.7,46.32)
  BOTTOM w0.102: v1(91.02,101.06) 90.73,100.77 90.1,100.77 90.06,100.74 89.14,100.74 89.08,100.67 88.47,100.67 U18.BB20
  BOTTOM w0.178: v1(103.7,46.32) 103.48,46.11 CN16.250
M_A_DQ59: length 75
  IN4 w0.127: v1(92.24,101.56) 92.94,102.26 95.86,102.26 97.52,100.59 98.13,100.59 103.92,94.8 103.92,85.38 107,82.3 107,67.15 107.98,66.16 107.98,58.28 107.43,57.72 107.43,52.77 104.6,49.94 104.6,48.38 103.84,47.62 v1(103.7,47.62)
  BOTTOM w0.102: v1(92.24,101.56) 91.96,101.84 91.38,101.84 91.17,101.63 90.22,101.63 89.77,101.17 89.21,101.17 89.08,101.3 88.35,101.3 88.19,101.46 87.29,101.46 86.95,101.8 U18.AY19
  BOTTOM w0.178: v1(103.7,47.62) 102.48,46.4 CN16.246
M_A_DQ60: length 74.9
  IN4 w0.127: v1(95.65,98.83) 95.75,98.83 99.94,94.64 99.94,94.4 100.85,93.5 100.85,84.17 103.78,81.24 103.78,64.99 103.28,64.49 103.28,58.26 103.12,58.11 103.12,53.46 101.49,51.82 101.49,45.85 101.69,45.65 103.05,45.65 103.22,45.48 103.22,45.15 103.06,45 101.05,45 100.9,45.14 100.9,46.74 100.76,46.88 v1(100.48,46.88)
  BOTTOM w0.102: U18.BA23 88.1,98.6 88.42,98.28 88.69,98.28 88.72,98.32 89.18,98.32 89.21,98.28 89.48,98.28 89.73,98.54 91.85,98.54 92.2,98.18 95,98.18 95.65,98.84 v1(95.65,98.83)
  BOTTOM w0.178: CN16.236 99.98,46.38 v1(100.48,46.88)
M_A_DQ61: length 74.8
  IN4 w0.127: v1(94.69,99.55) 94.69,99.14 100.41,93.42 100.41,84 102.89,81.51 102.89,81.51 103.35,81.06 103.35,65.04 102.93,64.62 102.93,58.45 102.69,58.21 102.69,57.7 102.56,57.58 102.45,57.58 102.32,57.45 102.32,57.2 102.45,57.07 102.56,57.07 102.69,56.94 102.69,56.69 102.56,56.56 102.45,56.56 102.32,56.43 102.32,56.18 102.45,56.05 102.56,56.05 102.69,55.93 102.69,55.67 102.56,55.54 102.45,55.54 102.32,55.42 102.32,55.16 102.45,55.04 102.56,55.04 102.69,54.91 102.69,54.66 102.56,54.53 102.45,54.53 102.32,54.4 102.32,54.15 102.45,54.02 102.56,54.02 102.69,53.89 102.69,53.61 100.91,51.83 100.67,51.83 100.55,51.7 100.55,51.45 100.67,51.32 100.98,51.32 101.11,51.19 101.11,50.94 100.98,50.81 100.67,50.81 100.55,50.69 100.55,50.43 100.67,50.31 100.98,50.31 101.12,50.16 101.12,49.43 101,49.3 99.76,49.3 99.63,49.17 99.63,48.91 99.75,48.79 101,48.79 101.11,48.69 101.11,48.06 101,47.96 100.57,47.96 100.44,48.09 v1(100.44,48.19)
  BOTTOM w0.102: v1(94.69,99.55) 94.69,99.04 94.13,98.48 92.33,98.48 92.07,98.74 89.49,98.74 U18.BC23
  BOTTOM w0.178: CN16.232 98.98,48.68 99.18,48.87 99.76,48.87 v1(100.44,48.19)
M_A_DQ62: length 73.4
  IN4 w0.127: v1(90.31,100.16) 90.78,100.63 91.31,100.63 91.66,100.99 96.23,100.99 97.21,100 97.49,100 103.05,94.44 103.05,85.02 106.12,81.96 106.12,64.28 105.69,63.85 105.69,63.57 105.78,63.48 105.98,63.48 106.11,63.35 106.11,63.05 105.98,62.92 105.79,62.92 105.58,62.72 105.58,60.06 105.71,59.93 106.46,59.93 106.59,59.8 106.59,59.55 106.46,59.42 105.94,59.42 105.83,59.31 105.83,59.07 105.98,58.91 106.46,58.91 106.59,58.79 106.59,58.53 106.46,58.4 105.7,58.4 105.58,58.28 105.58,58.02 105.7,57.9 106.46,57.9 106.59,57.77 106.59,57.52 106.46,57.39 106.11,57.39 105.98,57.26 105.98,54.14 106.16,53.96 106.16,53.73 106.06,53.62 105.91,53.62 105.73,53.45 105.73,53.27 106.13,52.88 106.13,52.7 105.95,52.52 105.77,52.52 105.35,52.94 105.17,52.94 104.99,52.76 104.99,52.58 105.37,52.2 105.37,52.02 105.19,51.84 105.01,51.84 104.62,52.23 104.46,52.23 104.26,52.02 104.26,51.84 104.64,51.46 104.64,51.29 104.18,50.83 103.99,50.83 v1(103.72,51.1)
  BOTTOM w0.102: U18.BC21 89.38,100.16 v1(90.31,100.16)
  BOTTOM w0.178: CN16.249 103.23,51.59 v1(103.72,51.1)
M_A_DQ63: length 74.3
  IN4 w0.127: v1(92.88,101.45) 93.28,101.85 95.81,101.85 97.3,100.36 97.75,100.36 103.49,94.62 103.49,85.2 106.57,82.12 106.57,65.88 106.69,65.75 107.4,65.75 107.52,65.64 107.52,65.38 107.38,65.24 106.69,65.24 106.57,65.12 106.57,63.39 106.68,63.28 107.34,63.28 107.47,63.15 107.47,62.9 107.34,62.77 106.36,62.77 105.87,62.28 105.87,60.93 107,59.8 107,52.94 103.86,49.8 v1(103.7,49.8)
  BOTTOM w0.102: U18.BB21 88.82,100.47 89.16,100.47 89.22,100.54 90.14,100.54 90.18,100.57 92,100.57 v1(92.88,101.45)
  BOTTOM w0.178: CN16.245 102.23,52.07 102.4,51.9 102.4,50.86 103.45,49.8 v1(103.7,49.8)
M_A_DQS0: length 85.6
  IN4 w0.114: v1(41.25,50.34) 41.05,50.54 40.72,50.54 40.4,50.85 40.4,52.1 39.48,53.02 38.85,53.02 38.63,53.23 38.63,53.85 38.86,54.07 39.21,54.07 39.31,54.17 39.31,54.55 39.16,54.7 38.86,54.7 38.63,54.92 38.63,55.53 38.85,55.75 39.19,55.75 39.31,55.87 39.31,56.26 39.2,56.37 38.89,56.37 38.63,56.63 38.63,57.17 38.89,57.43 39.34,57.43 39.42,57.51 39.42,57.95 39.32,58.05 38.89,58.05 38.63,58.3 38.63,58.85 38.89,59.1 39.2,59.1 39.29,59.19 39.29,59.32 38.88,59.73 38.88,60.16 39.58,60.87 39.58,62.73 39.26,63.05 37.98,63.05 37.74,63.28 37.74,63.65 38.07,63.98 39.41,63.98 39.52,64.09 39.52,64.53 40.15,65.16 40.15,84.47 41.02,85.34 41.02,94.65 44.3,97.94 44.3,98.9 47.19,101.79 47.95,101.79 49.19,103.03 51.55,103.03 51.81,102.78 56.21,102.78 56.99,101.99 57.8,101.99 58.18,102.37 60.65,102.37 v1(61.02,102.74)
  BOTTOM w0.127: U18.H19 61.15,102.61 v1(61.02,102.74) ; v1(41.25,50.34) 41.44,50.53 41.68,50.53 41.77,50.43 41.77,49.52 42.03,49.26 42.5,49.26 42.76,49.52 42.76,50.86 42.09,51.52 42.09,51.94 42.23,52.08 CN16.13
M_A_DQS1: length 66.1
  IN4 w0.114: v1(47.64,46.78) 47.45,46.97 47.45,47.29 46.64,48.09 46.64,56.76 45.76,57.64 45.76,65.92 45.12,66.56 45.12,79.65 46.03,80.56 46.03,81.48 46.14,81.6 46.71,81.6 46.95,81.84 46.95,82.41 46.71,82.65 46.14,82.65 46.03,82.76 46.03,87.24 47.08,88.3 47.08,91.7 48.11,92.73 48.11,94.25 49.56,95.71 49.56,96.56 50.12,97.12 50.12,97.82 50.68,98.38 52.93,98.38 53.17,98.62 53.17,98.84 53.38,99.05 v1(53.45,99.05)
  BOTTOM w0.102: U18.B22 56.68,99.33 56.32,99.33 56.06,99.07 55.84,99.07 55.51,99.4 55.24,99.4 55.13,99.51
  BOTTOM w0.108: v1(53.45,99.05) 53.29,99.05 53.13,99.21 53.13,99.36 53.28,99.51 55.13,99.51
  BOTTOM w0.127: CN16.34 47.48,45.88 47.44,45.93 47.44,46.58 v1(47.64,46.78)
M_A_DQS2: length 66.1
  IN4 w0.114: v1(51.91,49.85) 52.08,50.03 52.6,50.03 52.87,50.3 52.87,51.77 52.63,52.01 52.49,52.01 52.38,52.12 52.38,52.64 52.49,52.76 52.63,52.76 52.87,53 52.87,53.63 52.59,53.91 52.59,65.16 52.29,65.45 52.29,66.05 52.41,66.16 52.81,66.16 53.07,66.42 53.07,66.96 52.81,67.22 52.42,67.22 52.29,67.35 52.29,67.71 52.42,67.84 53.11,67.84 53.36,68.09 53.36,68.64 53.11,68.89 52.42,68.89 52.29,69.02 52.29,69.39 52.42,69.52 53.11,69.52 53.36,69.77 53.36,70.32 53.11,70.57 52.41,70.57 52.29,70.69 52.29,70.92 56.27,74.9 56.27,78.9 52.87,82.3 52.87,85.57 53.69,86.39 53.69,88.69 53.97,88.97 53.97,90.15 54.15,90.34 54.15,91.43 55.14,92.42 55.14,93.25 55.68,93.79 55.68,94.93 56.22,95.47 56.22,97.28 57.1,98.16 57.93,98.16 58.23,98.46 58.73,98.46 59.01,98.74 59.01,98.86 v2(59.22,99.07)
  BOTTOM w0.127: v2(59.22,99.07) 59.55,98.74 U18.F23 ; v1(51.91,49.85) 52.12,50.07 52.49,50.07 52.73,50.31 CN16.55
M_A_DQS3: length 57.2
  IN4 w0.114: v2(59.88,95.57) 59.88,95.25 59.73,95.1 59.35,95.1 59.04,94.8 59.04,92.94 59.21,92.77 59.21,91.58 60.26,90.53 60.26,89.61 59.53,88.88 59.52,88.88 59.36,88.72 59.36,87.83 59.17,87.64 58.92,87.64 58.66,87.39 58.66,86.84 58.92,86.59 59.17,86.59 59.28,86.47 59.28,82.89 60.8,81.37 60.8,73.02 57.89,70.11 57.89,64.28 57.61,63.99 57.61,58.45 57.41,58.25 57.41,52.45 57.61,52.25 57.61,47.52 58.03,47.1 58.28,47.1 v1(58.47,46.91)
  BOTTOM w0.127: U18.G27 60.15,95.3 v2(59.88,95.57) ; v1(58.47,46.91) 58.29,47.09 57.94,47.09 57.82,46.98 57.82,46.04 57.98,45.88 CN16.76
M_A_DQS4: length 53.2
  IN4 w0.114: v1(81.5,96.64) 81.76,96.38 81.85,96.38 82.24,95.99 82.24,94.18 82.6,93.81 82.6,92.84 82.9,92.54 82.9,91.64 84.14,90.39 84.14,89.79 84.69,89.25 84.69,85 84.1,84.41 84.1,73.02 84.68,72.44 84.68,56.84 85.15,56.37 85.15,52.24 85.4,52 85.4,50.78 85.15,50.54 84.81,50.54 v1(84.63,50.35)
  BOTTOM w0.127: U18.AP25 81.79,96.64 v1(81.5,96.64) ; v1(84.63,50.35) 84.8,50.53 85.48,50.53 85.73,50.78 CN16.179
M_A_DQS5: length 59.8
  IN4 w0.114: v1(91.45,46.88) 91.45,47.05 91.62,47.21 92.08,47.21 92.29,47.43 92.29,48.07 90.47,49.89 90.47,56.3 90.58,56.41 91.39,56.41 91.64,56.67 91.64,57.22 91.39,57.47 90.58,57.47 90.47,57.58 90.47,58 90.94,58.47 90.94,66.59 91.1,66.75 91.87,66.75 92.09,66.97 92.09,71 91.36,71.73 91.36,72.48 88.85,74.99 88.85,80.03 89.7,80.88 89.7,86.02 90.21,86.54 90.21,90.18 88.35,92.04 88.35,92.61 86.74,94.22 86.4,94.22 v2(86.19,94.43)
  BOTTOM w0.127: U18.AW27 85.91,94.76 85.91,94.61 86.08,94.43 v2(86.19,94.43) ; v1(91.45,46.88) 91.45,47.11 91.31,47.25 91.07,47.25 90.84,47.02 90.84,46.02 90.98,45.88 CN16.200
M_A_DQS6: length 71.2
  IN4 w0.114: v1(96.72,51.12) 96.72,50.97 96.56,50.81 96.28,50.81 96.18,50.91 96.18,52.84 97.86,54.51 97.86,72.65 99.57,74.37 99.57,79.43 95.73,83.27 95.73,83.65 95.49,83.89 95.16,83.89 95.05,84 95.05,84.39 95.16,84.51 95.49,84.51 95.73,84.75 95.73,85.32 95.49,85.56 95.16,85.56 95.05,85.68 95.05,86.07 95.16,86.18 95.49,86.18 95.73,86.43 95.73,87 95.49,87.24 95.1,87.24 94.98,87.36 94.98,87.74 95.11,87.86 95.49,87.86 95.73,88.1 95.73,88.82 95.52,89.03 95.01,89.03 94.86,89.18 94.86,89.72 95.01,89.87 96,89.87 96.3,90.18 96.3,90.77 96.06,91.01 95.69,91.01 95.52,91.19 95.52,91.7 95.67,91.85 96.48,91.85 96.8,92.17 96.8,92.77 96.47,93.1 95.37,93.1 93.99,94.47 93.99,95 93.86,95.13 91.63,97.36 91.55,97.44 91.37,97.44 89.99,97.44 88.69,98.74 88.51,98.74 85.41,98.74 85.27,98.88 85.27,99.13 85.4,99.26 85.59,99.26 v2(85.65,99.2)
  BOTTOM w0.127: U18.AV22 85.25,99.7 85.25,99.35 85.4,99.2 v2(85.65,99.2) ; v1(96.72,51.12) 96.72,50.97 96.58,50.83 96.17,50.83 96.09,50.91 96.09,51.94 96.23,52.08 CN16.221
M_A_DQS7: length 74.1
  IN4 w0.114: v1(101.94,46.95) 102.14,47.16 102.33,47.16 102.61,46.88 102.96,46.88 103.2,47.12 103.2,48.13 103.27,48.21 103.72,48.21 104.01,48.5 104.01,49.05 103.79,49.26 103.27,49.26 103.2,49.33 103.2,51.82 105.23,53.85 105.23,57.2 105.06,57.36 105.06,65.07 105.19,65.2 105.19,81.82 102.25,84.76 102.25,94.18 95.68,100.75 92.1,100.75 91.84,100.5 91.84,100.38 v1(91.63,100.16)
  BOTTOM w0.102: U18.BA21 87.62,100.2 87.53,100.11 87.53,99.94 87.61,99.86 87.89,99.86 87.94,99.91 88.36,99.91 88.39,99.88 88.67,99.88 88.76,99.97 89.14,99.97 89.35,99.76 91.81,99.76 91.88,99.83 91.88,100.06 91.78,100.16 v1(91.63,100.16)
  BOTTOM w0.127: CN16.242 101.48,45.91 101.34,46.05 101.34,46.96 101.53,47.15 101.74,47.15 v1(101.94,46.95)
M_A_DQS#0: length 85.7
  IN4 w0.114: v1(41.25,51.1) 41.25,50.85 41.16,50.75 40.81,50.75 40.62,50.94 40.62,52.19 39.57,53.24 38.94,53.24 38.85,53.32 38.85,53.76 38.95,53.86 39.3,53.86 39.52,54.08 39.52,54.64 39.25,54.91 38.95,54.91 38.85,55.01 38.85,55.44 38.94,55.53 39.28,55.53 39.52,55.78 39.52,56.35 39.29,56.59 38.98,56.59 38.85,56.72 38.85,57.08 38.98,57.21 39.43,57.21 39.64,57.42 39.64,58.04 39.41,58.27 38.98,58.27 38.85,58.39 38.85,58.76 38.98,58.89 39.29,58.89 39.5,59.1 39.5,59.41 39.09,59.82 39.09,60.07 39.8,60.78 39.8,62.82 39.35,63.27 38.07,63.27 37.96,63.37 37.96,63.56 38.16,63.76 39.5,63.76 39.74,64 39.74,64.44 40.37,65.07 40.37,84.38 41.23,85.25 41.23,94.56 44.51,97.85 44.51,98.81 47.28,101.58 48.04,101.58 49.28,102.82 51.46,102.82 51.72,102.56 56.12,102.56 56.9,101.77 57.89,101.77 58.27,102.15 60.81,102.15 60.91,102.04 60.91,101.87 v2(60.77,101.72)
  BOTTOM w0.127: v1(41.25,51.1) 41.25,50.84 41.34,50.75 41.77,50.75 42,50.53 42,49.61 42.13,49.49 42.41,49.49 42.53,49.61 42.53,50.76 41.87,51.43 41.87,51.94 41.73,52.08 CN16.11 ; U18.G19 60.57,102.42 60.71,102.42 60.77,102.37 v2(60.77,101.72)
M_A_DQS#1: length 66.1
  IN4 w0.114: v1(46.87,46.78) 47.12,46.78 47.23,46.89 47.23,47.2 46.43,48 46.43,56.67 45.54,57.55 45.54,65.83 44.9,66.47 44.9,79.74 45.81,80.65 45.81,81.57 46.05,81.81 46.62,81.81 46.74,81.93 46.74,82.32 46.62,82.43 46.05,82.43 45.81,82.67 45.81,87.33 46.86,88.39 46.86,91.79 47.89,92.82 47.89,94.34 49.35,95.8 49.35,96.65 49.9,97.21 49.9,97.91 50.59,98.59 52.84,98.59 52.93,98.69 52.93,98.88 52.75,99.06 v1(52.59,99.06)
  BOTTOM w0.102: U18.A22 55.75,99.6 55.33,99.6 55.21,99.72 55.15,99.72 55.15,99.72 55.13,99.72
  BOTTOM w0.108: v1(52.59,99.06) 52.86,99.06 52.92,99.12 52.92,99.45 53.19,99.72 55.13,99.72
  BOTTOM w0.127: v1(46.87,46.78) 47.12,46.78 47.21,46.69 47.21,46.11 46.98,45.88 CN16.32
M_A_DQS#2: length 66.1
  IN4 w0.114: v1(58.53,99.11) 58.68,99.11 58.79,99 58.79,98.83 58.64,98.68 58.14,98.68 57.84,98.38 57.01,98.38 56.01,97.37 56.01,95.56 55.46,95.02 55.46,93.88 54.92,93.34 54.92,92.51 53.94,91.52 53.94,90.42 53.75,90.24 53.75,89.06 53.47,88.78 53.47,86.48 52.65,85.66 52.65,82.21 56.05,78.81 56.05,74.99 52.08,71.01 52.08,70.6 52.32,70.35 53.02,70.35 53.14,70.23 53.14,69.86 53.02,69.73 52.33,69.73 52.08,69.48 52.08,68.93 52.33,68.68 53.02,68.68 53.14,68.55 53.14,68.18 53.02,68.06 52.33,68.06 52.08,67.8 52.08,67.26 52.33,67 52.72,67 52.85,66.88 52.85,66.51 52.72,66.38 52.32,66.38 52.08,66.14 52.08,65.36 52.38,65.07 52.38,53.82 52.65,53.54 52.65,53.09 52.54,52.97 52.4,52.97 52.16,52.73 52.16,52.03 52.4,51.79 52.54,51.79 52.65,51.68 52.65,50.39 52.51,50.25 52.03,50.25 51.91,50.37 v1(51.91,50.62)
  BOTTOM w0.127: CN16.53 52.23,52.16 52.5,51.89 52.5,50.4 52.4,50.3 51.98,50.3 51.91,50.37 v1(51.91,50.62) ; U18.E23 58.75,99.05 58.69,99.11 v1(58.53,99.11)
M_A_DQS#3: length 57.3
  IN4 w0.114: v1(58.47,47.67) 58.47,47.39 58.4,47.31 58.12,47.31 57.82,47.6 57.82,52.34 57.63,52.54 57.63,58.16 57.82,58.36 57.82,63.91 58.11,64.19 58.11,70.02 61.02,72.93 61.02,81.46 59.5,82.98 59.5,86.56 59.26,86.8 59,86.8 58.88,86.93 58.88,87.3 59,87.42 59.26,87.42 59.58,87.74 59.58,88.63 59.61,88.66 59.62,88.66 60.48,89.52 60.48,90.62 59.43,91.67 59.43,92.86 59.26,93.03 59.26,94.71 59.44,94.89 59.69,94.89 59.8,94.77 v1(59.8,94.5)
  BOTTOM w0.127: v1(59.8,94.5) 59.92,94.62 59.92,94.88 59.81,95 U18.F27 ; v1(58.47,47.67) 58.47,47.39 58.4,47.32 57.84,47.32 57.6,47.07 57.6,46 57.48,45.88 CN16.74
M_A_DQS#4: length 53.3
  IN4 w0.114: v2(81.45,95.8) 81.45,96.06 81.55,96.16 81.76,96.16 82.02,95.9 82.02,94.09 82.39,93.72 82.39,92.75 82.68,92.45 82.68,91.55 83.93,90.3 83.93,89.7 84.48,89.16 84.48,85.09 83.88,84.5 83.88,72.93 84.47,72.35 84.47,56.75 84.94,56.28 84.94,52.15 85.18,51.91 85.18,50.87 85.07,50.75 84.73,50.75 84.63,50.86 v1(84.63,51.12)
  BOTTOM w0.127: v2(81.45,95.8) 81.45,96.02 81.65,96.22 81.93,96.22 U18.AP26 ; v1(84.63,51.12) 84.63,50.88 84.75,50.75 85.38,50.75 85.5,50.87 85.5,51.91 85.41,52 85.31,52 85.23,52.08 CN16.177
M_A_DQS#5: length 59.8
  IN4 w0.114: v1(91.45,47.64) 91.67,47.43 91.99,47.43 92.08,47.52 92.08,47.98 90.25,49.8 90.25,56.39 90.49,56.63 91.3,56.63 91.43,56.76 91.43,57.13 91.3,57.25 90.49,57.25 90.25,57.49 90.25,58.09 90.72,58.56 90.72,66.68 91.01,66.97 91.78,66.97 91.87,67.06 91.87,70.91 91.14,71.64 91.14,72.39 88.63,74.9 88.63,80.12 89.48,80.97 89.48,86.11 90,86.63 90,90.09 88.14,91.95 88.14,92.52 86.65,94.01 85.72,94.01 85.39,94.34 v1(85.39,94.44)
  BOTTOM w0.127: v1(91.45,47.64) 91.29,47.48 90.98,47.48 90.62,47.12 90.62,46.02 90.48,45.88 CN16.198 ; v1(85.39,94.44) 85.39,94.68 85.35,94.72 U18.AV27
M_A_DQS#6: length 71.1
  IN4 w0.114: v2(84.85,99.2) 84.85,99.09 85.04,98.91 85.04,98.81 85.32,98.52 88.6,98.52 89.9,97.23 91.46,97.23 91.48,97.21 93.71,94.98 93.78,94.91 93.78,94.38 95.28,92.88 96.38,92.88 96.58,92.68 96.58,92.26 96.39,92.07 95.58,92.07 95.3,91.79 95.3,91.1 95.6,90.8 95.97,90.8 96.09,90.68 96.09,90.26 95.91,90.09 94.92,90.09 94.64,89.81 94.64,89.09 94.92,88.82 95.43,88.82 95.52,88.73 95.52,88.19 95.4,88.08 95.02,88.08 94.77,87.83 94.77,87.27 95.01,87.02 95.4,87.02 95.52,86.91 95.52,86.51 95.4,86.4 95.07,86.4 94.83,86.16 94.83,85.59 95.07,85.35 95.4,85.35 95.52,85.23 95.52,84.84 95.4,84.72 95.07,84.72 94.83,84.48 94.83,83.91 95.07,83.67 95.4,83.67 95.52,83.56 95.52,83.18 99.36,79.34 99.36,74.46 97.64,72.74 97.64,54.6 95.96,52.93 95.96,50.82 96.19,50.59 96.49,50.59 v1(96.72,50.36)
  BOTTOM w0.127: CN16.219 95.73,52.08 95.87,51.94 95.87,50.81 96.08,50.6 96.48,50.6 v1(96.72,50.36) ; v2(84.85,99.2) 84.55,99.5 U18.AU22
M_A_DQS#7: length 74.3
  IN4 w0.114: v1(92.29,100.09) 92.08,100.3 92.08,100.43 92.19,100.54 95.59,100.54 102.03,94.09 102.03,84.67 104.97,81.73 104.97,65.29 104.85,65.16 104.85,57.27 105.01,57.11 105.01,53.94 102.98,51.91 102.98,49.24 103.18,49.05 103.71,49.05 103.79,48.96 103.79,48.59 103.63,48.42 103.18,48.42 102.98,48.22 102.98,47.21 102.87,47.09 102.7,47.09 102.42,47.37 102.1,47.37 101.94,47.53 v1(101.94,47.71)
  BOTTOM w0.102: v1(92.29,100.09) 92.09,99.88 92.09,99.74 91.9,99.55 89.27,99.55 89.08,99.74 88.82,99.74 88.75,99.67 88.3,99.67 88.28,99.7 88.02,99.7 87.98,99.66 87.49,99.66 U18.AY21
  BOTTOM w0.127: v1(101.94,47.71) 101.94,47.59 101.72,47.38 101.44,47.38 101.12,47.06 101.12,46.05 100.98,45.91 CN16.240
M_A_EVENT#: length 54.4
  TOP w0.178: R629.2 72.04,46.47 v1(72.3,46.21)
  IN4 w0.127: v1(74.25,93.4) 74.5,93.15 74.5,91.53 74.16,91.19 74.16,85.25 75.01,84.41 75.01,66.24 73.25,64.48 73.25,61.56 73.54,61.27 73.54,58.51 74.41,57.64 74.41,48.47 73.69,47.75 73.69,45.82 73.55,45.68 72.83,45.68 v1(72.3,46.21)
  BOTTOM w0.178: U18.AE29 74.55,93.7 v1(74.25,93.4) ; CN16.134 72.48,46.03 v1(72.3,46.21)
M_A_ODT0: length 53.5
  IN4 w0.127: v1(78.93,51.08) 78.93,51.02 78.6,50.68 78.39,50.68 78.3,50.78 78.3,51.84 78.96,52.5 78.96,57.4 78.77,57.59 78.42,57.59 78.3,57.72 78.3,57.97 78.42,58.1 78.93,58.1 79.06,58.22 79.06,60.18 78.78,60.46 78.78,60.61 78.66,60.74 78.47,60.74 78.34,60.87 78.34,61.33 78.41,61.4 78.66,61.4 78.79,61.53 78.79,61.86 78.69,61.97 78.52,61.97 78.39,62.09 78.39,62.39 78.6,62.6 78.6,64.48 79.27,65.15 79.27,84.98 78.54,85.72 78.54,90.05 79,90.51 79,91.48 78.4,92.08 78.4,94.87 78.3,94.97 v1(77.96,94.97)
  BOTTOM w0.178: U18.AK27 78.3,95.3 v1(77.96,94.97) ; v1(78.93,51.08) 79.57,50.45 79.79,50.45 79.95,50.6 79.95,51.78 79.73,52 CN16.155
M_A_ODT1: length 53.2
  IN4 w0.127: v1(80.76,51.11) 80.58,51.11 80.3,51.39 80.3,52.09 80.48,52.27 80.65,52.27 80.74,52.36 80.74,52.66 80.63,52.77 80.42,52.77 80.29,52.9 80.29,53.15 80.42,53.28 80.59,53.28 80.72,53.41 80.72,53.66 80.59,53.79 80.42,53.79 80.29,53.92 80.29,54.17 80.42,54.3 80.59,54.3 80.72,54.42 80.72,64.75 80.56,64.91 80.56,84.46 80.28,84.74 80.28,86.11 79.91,86.48 79.91,91.3 79.74,91.47 79.74,92.63 79.6,92.77 79.6,96.62 79.2,97.01 78.75,97.01 78.59,96.86 78.59,96.26 v1(79.05,95.8)
  BOTTOM w0.178: v1(80.76,51.11) 81.23,51.58 CN16.161 ; v1(79.05,95.8) 79.05,95.92 79.33,96.2 79.55,96.2 U18.AL26
M_A_PARITY: length 9
  TOP w0.114: v1(80.25,54.73) 80.17,54.64 R628.1
  BOTTOM w0.114: v1(80.25,54.73) 79.33,55.65 75.78,55.65 74.73,54.6 CN16.143
M_A_RAS#: length 58.7
  IN4 w0.127: v1(75.66,97.39) 76.02,97.03 77.95,97.03 78.17,96.8 78.17,96.3 77.96,96.08 77.54,96.08 77.33,95.87 77.33,94.73 77.7,94.36 78.02,94.36 78.17,94.2 78.17,91.92 78.72,91.38 78.72,90.56 78.25,90.08 78.25,85.57 78.77,85.05 78.77,65.14 77.97,64.34 77.97,57.33 78.38,56.91 78.38,52.73 77.98,52.33 77.98,49.4 79.44,47.94 79.44,46.69 v1(78.98,46.23)
  BOTTOM w0.178: v1(78.98,46.23) CN16.152 ; v1(75.66,97.39) 76.05,97.78 U18.AG24
M_A_RESET#: length 53.6
  IN4 w0.127: v1(64.69,93.41) 64.97,93.13 64.97,90.21 64.34,89.58 64.34,89.06 63.6,88.32 63.6,86.11 64.26,85.45 64.26,69.03 62.01,66.78 62.01,56.52 62.12,56.42 62.12,52.85 62.75,52.22 62.75,48.1 64,46.85 v1(65.31,46.85)
  BOTTOM w0.178: v1(65.31,46.85) 65.54,46.85 65.98,46.4 CN16.108 ; v1(64.69,93.41) 64.98,93.7 U18.N29
M_A_WE#: length 53.3
  IN4 w0.127: v1(77.5,54.38) 77.5,56.48 77.1,56.87 77.1,64.54 77.9,65.34 77.9,84.87 77.1,85.67 77.1,86.43 77.1,88.24 76.73,88.61 76.66,88.61 76.54,88.73 76.54,89.01 76.64,89.11 76.74,89.11 76.82,89.19 76.82,89.55 76.74,89.62 76.59,89.62 76.54,89.67 76.54,90.13 76.66,90.26 76.77,90.26 77,90.02 77.14,90.02 77.37,90.26 77.87,90.26 78.47,90.85 78.47,90.97 78.31,91.12 78.16,91.12 77.81,90.77 76.62,90.77 76.55,90.84 76.55,91.15 76.62,91.22 77.78,91.22 77.89,91.33 77.89,92 77.83,92.06 77.65,92.06 77.3,91.71 76.71,91.71 76.61,91.81 76.61,92.29 77.12,92.8 77.12,92.98 77.02,93.08 77.02,93.36 77.59,93.94 v1(77.75,93.94)
  BOTTOM w0.178: CN16.151 78.73,54.95 78.55,55.13 78.12,55.13 77.95,54.95 77.95,54.57 77.76,54.38 v1(77.5,54.38) ; U18.AH28 77.65,94.5 77.75,94.4 v1(77.75,93.94)
M_B0_CS#0: length 35.9
  IN1 w0.102: v1(79.07,62.39) 79.27,62.59 80.45,62.59 80.84,62.98 80.84,65.77 80.53,66.09 80.53,86.04 80.33,86.24 80.33,86.8 v1(80.48,86.95)
  BOTTOM w0.102: 78.75,86.67 78.56,86.86 78.56,87.15 78.34,87.37 78.34,90.21 U18.AJ33
  BOTTOM w0.114: CN17.149 78.23,63.23 v1(79.07,62.39)
  BOTTOM w0.165: 78.75,86.67 78.82,86.59 80.12,86.59 v1(80.48,86.95)
M_B0_CS#1: length 32.2
  IN1 w0.102: v1(80.23,64.32) 80.51,64.32 80.61,64.42 80.61,65.61 80.29,65.93 80.29,85.66 80.01,85.93 80.01,88.29 80.17,88.44 v1(80.48,88.44)
  BOTTOM w0.102: v1(80.48,88.44) 80,87.96 80,87.53 79.9,87.43 79.64,87.43 79.49,87.58 79.49,88.37 79.83,88.71 79.83,90.2 80,90.37 80,90.6 79.87,90.73 79.87,91.08 U18.AL32
  BOTTOM w0.114: CN17.157 80.23,64.32 v1(80.23,64.32)
M_B0_ODT0: length 32.3
  IN1 w0.127: v1(79.08,63.72) 79.5,64.14 79.5,65.09 79.36,65.24 79.36,85.35 79.44,85.43 79.44,88.7 v1(78.99,89.15)
  BOTTOM w0.102: U18.AL30 79.32,92.57 79.32,91.73 79.13,91.54 79.13,91.54 79.13,91.06 79.16,91.03 79.16,90.74 79.13,90.71 79.13,90.26 79.36,90.04 79.36,89.53 v1(78.99,89.15)
  BOTTOM w0.178: v1(79.08,63.72) 79.73,64.37 CN17.155
M_B0_ODT1: length 32.6
  IN1 w0.127: v1(80.23,63) 79.79,63.43 79.79,88.46 v1(80.48,89.15)
  BOTTOM w0.102: U18.AM32 80.13,91.37 80.13,90.77 80.2,90.7 80.2,90.37 80.2,90.37 80.2,90.29 80.05,90.13 80.05,89.58 v1(80.48,89.15)
  BOTTOM w0.178: CN17.161 81.23,64 v1(80.23,63)
M_B_A0: length 36.6
  IN1 w0.127: v1(74.97,58.88) 75.58,59.48 75.58,61.79 75.05,62.31 75.05,64.45 75.58,64.98 75.58,66.2 75.16,66.62 75.16,85.04 74.68,85.51 74.68,87.79 v1(75.55,88.65)
  BOTTOM w0.102: U18.AG31 76.45,91.77 76.33,91.65 76.33,91.64 76.13,91.44 76.13,91.16 76.2,91.08 76.2,90.69 76.15,90.63 76.15,90.33 76.28,90.2 76.28,89.38 v1(75.55,88.65)
  BOTTOM w0.178: CN17.144 v1(74.97,58.88)
M_B_A1: length 34.6
  IN1 w0.127: v1(72.47,89.3) 71.42,88.25 71.42,86.53 70.94,86.05 70.94,84.69 70.7,84.45 70.7,65.43 71.17,64.96 71.17,63.44 v1(71.72,62.89)
  BOTTOM w0.102: U18.AC30 73.25,92.53 72.95,92.23 72.95,91.71 72.73,91.5 72.73,91.06 72.77,91.03 72.77,90.77 72.73,90.74 72.73,90.3 72.89,90.14 72.89,89.72 v1(72.47,89.3)
  BOTTOM w0.178: v1(71.72,62.89) 72.23,63.39 CN17.133
M_B_A2: length 36.4
  IN1 w0.127: v1(71.69,59.52) 71.69,61.47 72.15,61.93 72.15,65.22 71.56,65.81 71.56,84.1 72.1,84.64 72.1,86.31 71.92,86.49 71.92,88.08 v1(72.48,88.64)
  BOTTOM w0.102: v1(72.48,88.64) 73.09,89.26 73.09,90.23 72.94,90.38 72.94,90.63 73,90.69 73,91.08 72.97,91.11 72.97,91.12 72.94,91.15 72.94,91.42 73.25,91.73 U18.AC31
  BOTTOM w0.178: v1(71.69,59.52) 72.15,59.06 72.15,58.64 71.97,58.47 CN17.132
M_B_A3: length 32.9
  IN1 w0.127: v1(71.37,85.86) 71.82,85.41 71.82,84.88 71.13,84.19 71.13,65.62 71.59,65.16 71.59,64.35 v1(71.73,64.22)
  BOTTOM w0.102: 71.99,87.41 71.99,90.11 72.17,90.29 72.17,90.73 72.13,90.76 72.13,91.38 U18.AB32
  BOTTOM w0.165: v1(71.37,85.86) 71.78,85.86 71.97,85.67 71.97,85.16 72.1,85.03 72.45,85.03 72.58,85.16 72.58,86.42 72.43,86.57 72.1,86.57 71.99,86.67 71.99,87.41
  BOTTOM w0.178: v1(71.73,64.22) 71.73,64.35 CN17.131
M_B_A4: length 35.3
  IN1 w0.127: v1(70.09,86) 70.09,84.88 69.84,84.63 69.84,65 70.37,64.46 70.37,60.18 v1(70.45,60.1)
  BOTTOM w0.102: v1(70.09,86) 71.7,87.6 71.7,90.1 71.97,90.37 71.97,90.64 71.65,90.96 U18.AA32
  BOTTOM w0.178: v1(70.45,60.1) 70.97,59.57 CN17.128
M_B_A5: length 34.3
  IN1 w0.127: v1(70.48,58.76) 71.01,59.29 71.01,62.67 70.75,62.92 70.75,64.76 70.27,65.24 70.27,84.52 70.55,84.8 70.55,86.94 v1(70.34,87.15)
  BOTTOM w0.102: U18.AA33 71.49,90.34 71.49,88.3 v1(70.34,87.15)
  BOTTOM w0.178: CN17.126 v1(70.48,58.76)
M_B_A6: length 33.9
  IN1 w0.127: v1(69.49,84.86) 69.4,84.78 69.4,65.04 70.02,64.43 70.02,63.25 v1(69.61,62.84)
  BOTTOM w0.102: 70.01,87.43 71.16,88.59 71.16,91.62 U18.AA31
  BOTTOM w0.165: v1(69.49,84.86) 69.49,86.91 70.01,87.43
  BOTTOM w0.178: CN17.127 70.73,63.96 v1(69.61,62.84)
M_B_A7: length 35.4
  IN1 w0.127: v1(68.97,60.18) 69.12,60.32 69.12,61.49 68.94,61.67 68.94,64.4 68.54,64.8 68.54,84.49 68.17,84.86 68.17,85.96 69.62,87.4 v1(69.62,87.69)
  BOTTOM w0.102: v1(69.62,87.69) 69.94,87.69 70.58,88.32 70.58,88.33 70.83,88.58 70.83,90.88 U18.Y33
  BOTTOM w0.178: v1(68.97,60.18) 69.48,59.68 CN17.122
M_B_A8: length 34.2
  IN1 w0.127: v1(72.54,92.22) 72.02,91.7 72.02,90.67 70.76,89.41 70.76,88.22 68.56,86.02 68.56,85.06 68.97,84.64 68.97,64.95 69.16,64.76 69.16,64 v1(69.58,63.58)
  BOTTOM w0.165: U18.AA30 71.87,92.9 v1(72.54,92.22)
  BOTTOM w0.178: v1(69.58,63.58) 70.23,64.22 CN17.125
M_B_A9: length 34.6
  IN1 w0.127: v1(67.94,62.74) 68.39,63.2 68.39,64.11 67.68,64.83 67.68,84.17 67.16,84.69 v1(67.16,86.55)
  BOTTOM w0.102: U18.W32 70.21,91.14 70.21,90.79 70.37,90.63 70.37,89.35 69.16,88.15 69.16,87.81
  BOTTOM w0.165: v1(67.16,86.55) 67.9,86.55 69.16,87.81
  BOTTOM w0.178: v1(67.94,62.74) 69.13,63.93 69.13,64.55 69.23,64.65 CN17.121
M_B_A10: length 36.7
  IN1 w0.127: v1(75.54,85.87) 76.2,85.22 76.2,66.63 76.37,66.46 76.37,61.19 76.35,61.18 77.43,60.1 v1(78.47,60.1)
  BOTTOM w0.102: U18.AG32 76.45,90.95 76.75,90.65 76.75,90.37 76.69,90.31 76.69,88.87 76.23,88.42 76.23,86.57 75.94,86.27
  BOTTOM w0.165: 75.94,86.27 v1(75.54,85.87)
  BOTTOM w0.178: v1(78.47,60.1) 77.48,59.1 CN17.146
M_B_A11: length 36.5
  IN1 w0.127: v1(68.97,58.83) 68.56,59.25 68.56,61.63 68.71,61.78 68.71,64.2 68.11,64.8 68.11,84.28 67.8,84.59 67.8,86.62 69.04,87.86 69.04,88.04 69.75,88.75 v1(70.34,88.75)
  BOTTOM w0.102: U18.Y32 70.54,91.38 70.54,90.76 70.6,90.7 70.6,89.01 v1(70.34,88.75)
  BOTTOM w0.178: CN17.120 v1(68.97,58.83)
M_B_A12: length 32.3
  IN1 w0.127: v1(67.92,63.41) 67.69,63.41 67.36,63.74 67.36,64.57 67.24,64.69 67.24,84.03 66.71,84.57 66.71,87.15 67.93,88.37 v1(68.47,88.37)
  BOTTOM w0.102: v1(68.47,88.37) 68.93,88.37 70.05,89.49 U18.W33
  BOTTOM w0.178: v1(67.92,63.41) 68.73,64.22 CN17.119
M_B_A13: length 38.2
  IN1 w0.127: v1(78.98,88.49) 78.27,87.78 78.27,85.95 77.72,85.4 77.72,61.92 78.3,61.35 v1(80.05,61.35)
  BOTTOM w0.102: U18.AL31 79.65,91.77 79.34,91.45 79.34,91.15 79.4,91.08 79.4,90.69 79.34,90.63 79.34,90.35 79.4,90.28 79.56,90.12 79.56,89.45 79.4,89.28 79.4,88.91 v1(78.98,88.49)
  BOTTOM w0.178: v1(80.05,61.35) 80.29,61.35 80.7,60.93 80.7,58.56 80.48,58.34 CN17.158
M_B_ALERT#: length 3.8
  TOP w0.114: R634.1 v1(67.29,60.14)
  BOTTOM w0.114: v1(67.29,60.14) 67.97,59.45 CN17.116
M_B_BS#0: length 36.5
  IN1 w0.127: v1(78.46,58.76) 78.93,59.24 78.93,60.28 78.65,60.56 77.74,60.56 76.71,61.59 76.71,86.43 76.27,86.87 76.27,87.68 v1(76.66,88.07)
  BOTTOM w0.102: v1(76.66,88.07) 76.89,88.31 76.89,90.16 76.97,90.24 76.97,90.72 76.92,90.77 76.92,91.37 U18.AH32
  BOTTOM w0.178: v1(78.46,58.76) 78.48,58.74 CN17.150
M_B_BS#1: length 32.4
  IN1 w0.127: v1(75.57,63.57) 75.8,63.34 75.93,63.34 76.01,63.42 76.01,66.27 75.69,66.59 75.69,85.13 75.08,85.75 75.08,87.39 75.15,87.46 75.43,87.46 v1(75.55,87.34)
  BOTTOM w0.102: v1(75.55,87.34) 76,87.79 76,88.47 76.48,88.95 76.48,90.47 U18.AG33
  BOTTOM w0.178: CN17.145 77.23,64.19 76.61,63.57 v1(75.57,63.57)
M_B_CAS#: length 37.4
  IN1 w0.127: v1(80.25,58.78) 80.8,59.34 80.8,61.5 80.53,61.77 78.61,61.77 78.23,62.15 78.23,85.33 78.58,85.68 78.58,86.67 v1(78.98,87.08)
  BOTTOM w0.102: U18.AK32 78.85,91.36 78.54,91.05 78.54,90.26 78.54,90.26 78.54,87.52 v1(78.98,87.08)
  BOTTOM w0.178: v1(80.25,58.78) 79.97,58.51 CN17.156
M_B_CKE0: length 38
  IN1 w0.127: v1(65.68,61.41) 65.13,61.97 65.13,67.45 65.44,67.76 65.44,83.4 64.7,84.14 64.7,87.89 v1(64.88,88.07)
  BOTTOM w0.102: U18.U32 68.45,90.95 68.77,90.63 68.77,90.37 68.44,90.04 68.44,89.78 67.97,89.31 66.73,89.31 65.49,88.07 v1(64.88,88.07)
  BOTTOM w0.178: CN17.109 66.23,64.74 65.57,64.09 65.57,61.53 v1(65.68,61.41)
M_B_CKE1: length 37.2
  IN1 w0.127: v1(66,60.15) 64.69,61.46 64.69,67.69 65.01,68.01 65.01,83.27 64.31,83.97 64.31,88.3 v1(65.37,89.35)
  BOTTOM w0.102: v1(65.37,89.35) 65.57,89.56 67.75,89.56 68.21,90.02 68.21,90.26 U18.U33
  BOTTOM w0.178: CN17.110 66.48,58.41 66.43,58.45 66.43,59.72 v1(66,60.15)
M_B_CLK0: length 38.5
  IN1 w0.102: v1(73.74,87.66) 73.47,87.39 73.31,87.39 73.12,87.21 73.12,85.91 73.52,85.52 73.52,85.36 73.49,85.32 73.49,85.3
  IN1 w0.152: 73.49,85.3 73.49,84.87 73.18,84.57 73.18,83.87 73.44,83.61 73.71,83.61 73.86,83.46 73.86,83.29 73.39,82.82 73.39,82.31 73.61,82.09 73.61,81.81 73.39,81.59 73.39,80.95 73.61,80.73 73.61,80.47 73.39,80.26 73.39,79.76 73.61,79.54 73.61,79.21 73.39,78.99 73.39,78.45 73.61,78.23 73.61,77.83 73.39,77.61 73.39,77.02 73.61,76.8 73.61,76.32 73.39,76.1 73.39,75.48 73.61,75.26 73.61,74.84 73.39,74.62 73.39,74.04 73.61,73.82 73.61,73.2 73.39,72.98 73.39,72.36 73.61,72.14 73.61,71.73 73.39,71.51 73.39,70.86 73.61,70.64 73.61,70.31 73.39,70.09 73.39,69.52 73.61,69.31 73.61,68.85 73.39,68.63 73.39,67.97 73.61,67.75 73.61,67.22 73.39,67 73.39,66.25 73.65,65.99 74.31,65.99 74.51,65.79 74.51,65.39 74.33,65.21 73.57,65.21 73.26,64.89 73.26,63.53 73.65,63.15 74.04,63.15 v1(74.23,62.95)
  BOTTOM w0.102: v1(73.74,87.66) 73.89,87.51 74.36,87.51 74.66,87.82 74.66,90.17 74.85,90.36 U18.AE33
  BOTTOM w0.152: CN17.137 73.23,64.74 73.35,64.62 73.35,64.42 72.94,64.01 72.94,63.38 73.21,63.11 73.71,63.11 73.85,63.26 74.1,63.26 74.23,63.13 v1(74.23,62.95)
M_B_CLK0#: length 38.7
  IN1 w0.102: 73.75,85.3 73.75,85.32 73.72,85.36 73.72,85.6 73.33,86 73.33,87.12 73.39,87.19 73.54,87.19 v1(73.74,86.99)
  IN1 w0.152: v1(74.23,63.71) 74.23,63.61 74.03,63.41 73.76,63.41 73.53,63.64 73.53,64.78 73.68,64.94 74.44,64.94 74.78,65.28 74.78,65.9 74.42,66.26 73.76,66.26 73.66,66.36 73.66,66.89 73.88,67.11 73.88,67.86 73.66,68.08 73.66,68.52 73.88,68.74 73.88,69.42 73.66,69.63 73.66,69.98 73.88,70.2 73.88,70.75 73.66,70.97 73.66,71.4 73.88,71.62 73.88,72.25 73.66,72.47 73.66,72.87 73.88,73.09 73.88,73.93 73.66,74.15 73.66,74.51 73.88,74.73 73.88,75.37 73.66,75.59 73.66,75.99 73.88,76.21 73.88,76.91 73.66,77.13 73.66,77.5 73.88,77.72 73.88,78.34 73.66,78.56 73.66,78.88 73.88,79.1 73.88,79.65 73.66,79.87 73.66,80.15 73.88,80.36 73.88,80.84 73.66,81.06 73.66,81.48 73.88,81.7 73.88,82.2 73.66,82.42 73.66,82.71 74.13,83.18 74.13,83.57 73.82,83.88 73.55,83.88 73.45,83.98 73.45,84.46 73.75,84.76 73.75,85.3
  BOTTOM w0.102: U18.AE32 74.85,90.99 75.15,90.69 75.15,90.37 74.87,90.09 74.87,87.73 74.45,87.31 73.96,87.31 73.74,87.09 v1(73.74,86.99)
  BOTTOM w0.152: v1(74.23,63.71) 74.03,63.51 73.75,63.51 73.6,63.36 73.32,63.36 73.19,63.49 73.19,63.91 73.6,64.32 73.6,64.65 73.73,64.77 CN17.139
M_B_CLK1: length 38.3
  IN1 w0.152: v2(73.75,89.61) 73.55,89.41 73.32,89.41 72.96,89.06 72.96,87.83 72.47,87.33 72.47,84.1 72.34,83.97 72.34,65.82 72.59,65.56 72.59,61.71 72.15,61.27 72.15,59.93 72.47,59.6 72.86,59.6 v1(73.02,59.44)
  BOTTOM w0.102: v2(73.75,89.61) 74.03,89.61 74.13,89.71 74.13,90.51 74.38,90.76 74.38,91.01 74.32,91.07 74.32,91.52 74.51,91.71 74.51,92.21 74.85,92.55 U18.AE30
  BOTTOM w0.152: CN17.138 73.48,58.49 73.48,58.49 73.48,59.46 73.34,59.59 73.17,59.59 v1(73.02,59.44)
M_B_CLK1#: length 38.4
  IN1 w0.152: v1(73.02,60.28) 73.02,59.98 72.91,59.87 72.59,59.87 72.42,60.04 72.42,61.16 72.86,61.6 72.86,65.67 72.6,65.93 72.6,83.86 72.73,83.99 72.73,87.22 73.23,87.72 73.23,88.95 73.43,89.15 73.63,89.15 73.75,89.04 v1(73.75,88.96)
  BOTTOM w0.102: v1(73.75,88.96) 74.01,88.96 74.08,89.03 74.08,89.37 74.33,89.62 74.33,90.42 74.59,90.68 74.59,91.1 74.53,91.15 74.53,91.44 74.71,91.62 74.71,91.96 U18.AE31
  BOTTOM w0.152: CN17.140 73.97,58.49 73.73,58.73 73.73,59.56 73.44,59.85 73.16,59.85 73.02,59.99 v1(73.02,60.28)
M_B_DM0: length 55.1
  IN1 w0.127: v1(42.23,59.54) 41.75,60.03 41.75,60.5 42.71,61.47 42.71,64.72 40.69,66.74 40.69,82.58 44.56,86.45 44.56,89.11 50.01,94.55 52.47,94.55 53.86,95.94 55.85,95.94 56.15,95.64 56.15,94.3 56.27,94.17 56.69,94.17 56.83,94.31 56.83,96.4 57.03,96.61 v1(57.55,96.61)
  BOTTOM w0.178: v1(57.55,96.61) 57.94,97 U18.D25 ; v1(42.23,59.54) 41.8,59.11 41.8,58.58 41.98,58.4 CN17.12
M_B_DM1: length 45.2
  IN1 w0.127: v1(46.24,63.06) 46.42,63.06 46.67,63.31 46.67,67.62 44.58,69.72 44.58,79.75 49.09,84.26 49.09,86.63 49.53,87.07 49.53,87.25 49.33,87.45 49.33,87.63 49.51,87.81 49.69,87.81 49.89,87.61 50.07,87.61 50.25,87.79 50.25,87.97 50.05,88.17 50.05,88.35 50.23,88.53 50.41,88.53 50.61,88.33 50.79,88.33 51.26,88.81 51.26,88.81 52.13,89.67 52.13,91.18 54.17,93.22 54.45,93.22 54.65,93.02 54.65,92.84 v1(54.38,92.57)
  BOTTOM w0.102: v1(54.38,92.57) 54.58,92.57 55.3,93.29 55.76,93.29 55.78,93.31 55.81,93.31 55.81,93.31 56.08,93.31 56.11,93.28 56.59,93.28 56.78,93.47 57.62,93.47 U18.D29
  BOTTOM w0.178: CN17.33 47.22,63.8 46.48,63.06 v1(46.24,63.06)
M_B_DM2: length 40.2
  IN1 w0.127: v1(57.31,87.35) 56.9,87.35 55.59,86.03 55.59,80.04 56.59,79.03 56.59,74.77 53.96,72.13 53.96,69.16 53.37,68.58 53.37,58.44 53.23,58.3 52.89,58.3 52.74,58.44 52.74,59.39 52.62,59.52 v1(51.96,59.52)
  BOTTOM w0.102: 57.31,87.39 57.31,88.96 U18.E33
  BOTTOM w0.108: 57.31,87.39 v1(57.31,87.35)
  BOTTOM w0.178: CN17.54 52.48,59 v1(51.96,59.52)
M_B_DM3: length 38.5
  IN1 w0.127: v1(60.1,83.98) 60.1,82.96 60.48,82.58 60.48,72.49 60.35,72.37 59.75,72.37 59.63,72.24 59.63,71.98 59.75,71.86 60.34,71.86 60.47,71.73 60.47,71.2 60.34,71.07 60.11,71.07 59.88,71.3 58.66,71.3 58.54,71.18 58.54,70.9 58.66,70.77 59.63,70.77 59.75,70.64 59.75,70.41 59.63,70.29 58.66,70.29 58.43,70.06 58.43,69.73 58.84,69.32 58.84,63.07 58.73,62.97 v1(58.44,62.97)
  BOTTOM w0.102: 61.22,85.1 61.22,88.57 62.05,89.4 U18.J33
  BOTTOM w0.127: 61.22,85.1 60.47,84.34
  BOTTOM w0.178: v1(58.44,62.97) 58.06,62.59 57.87,62.59 57.73,62.74 CN17.75 ; 60.47,84.34 v1(60.1,83.98)
M_B_DM4: length 38.3
  IN1 w0.127: v1(85.88,59.53) 85.88,59.61 84.35,61.15 84.35,66.14 83.29,67.19 83.29,71.07 83.12,71.24 83.12,83.78 84.35,85.01 84.35,86.1 v1(83.93,86.52)
  BOTTOM w0.102: U18.AR30 82.54,92.58 82.54,91.16 82.58,91.12 82.58,91.11 82.58,91.11 82.58,90.69 82.58,90.69 82.58,90.67 82.54,90.63 82.54,90.31 82.79,90.06 82.79,90.05 82.81,90.02 82.81,88.72 83.17,88.37 83.17,87.69 83.32,87.54 83.32,87.41
  BOTTOM w0.108: v1(83.93,86.52) 83.32,87.13 83.32,87.41
  BOTTOM w0.178: CN17.178 85.48,58.47 85.38,58.56 85.38,59.03 v1(85.88,59.53)
M_B_DM5: length 39.3
  IN1 w0.127: v1(89.55,63.01) 89.66,62.9 89.9,62.9 90.05,63.04 90.05,73.03 88.31,74.77 88.31,79.02 89.01,79.72 89.01,84.73 87.69,86.05 87.69,87.25 87.23,87.7 87.23,88.49 86.33,89.39 86.33,90.07 86.59,90.33 86.91,90.33 87.42,89.82 87.64,89.82 87.77,89.95 87.77,90.21 87.1,90.89 86.65,90.89 86.55,90.99 86.55,91.29 86.78,91.52 86.78,91.75 86.48,92.05 86.12,92.05 v1(85.7,92.47)
  BOTTOM w0.178: CN17.199 90.72,64.72 90.55,64.54 90.55,64.01 v1(89.55,63.01) ; U18.AW30 86.05,92.82 v1(85.7,92.47)
M_B_DM6: length 45.7
  IN1 w0.127: v1(91.47,89.67) 92.17,88.97 92.17,87.07 94.23,85.01 94.23,84 99.03,79.21 99.03,74.59 96.17,71.73 96.17,68.51 95.27,67.6 95.27,66.42 95.49,66.2 95.49,61.83 96.84,60.48 96.84,57.49 96.72,57.37 96.11,57.37 95.98,57.51 v1(95.98,58.81)
  BOTTOM w0.102: U18.BC30 88.95,92.12 89.15,91.92 89.45,91.92 90.58,90.79 90.58,90.51 91.42,89.67 v1(91.47,89.67)
  BOTTOM w0.178: CN17.220 v1(95.98,58.81)
M_B_DM7: length 53.4
  IN1 w0.127: v1(92.52,94.89) 92.14,94.89 91.97,94.72 91.97,94.51 92.95,93.53 93.26,93.53 93.64,93.91 94.04,93.91 95.08,92.87 95.31,92.87 96.69,91.5 96.69,91.27 99.84,88.11 99.84,85.72 104.21,81.36 104.21,71.35 101.49,68.63 101.49,68.45 101.67,68.27 101.85,68.27 103.85,70.27 104.03,70.27 104.21,70.09 104.21,69.91 102.8,68.5 102.8,68.32 103.25,67.86 103.25,67.68 103.07,67.5 102.89,67.5 102.44,67.96 102.26,67.96 102.08,67.78 102.08,67.6 102.46,67.22 102.46,67.04 102.28,66.86 102.1,66.86 101.84,67.11 101.69,67.11 101.51,66.93 101.51,64.21 v1(101.56,64.16)
  BOTTOM w0.102: 91.37,95.62 91.06,95.62 90.48,96.2 U18.BC26
  BOTTOM w0.108: 91.37,95.62 92.07,94.92 92.49,94.92 v1(92.52,94.89)
  BOTTOM w0.178: CN17.241 101.23,64.5 v1(101.56,64.16)
M_B_DQ0: length 56.7
  IN1 w0.102: 48.8,96.4 v1(48.86,96.4)
  IN1 w0.127: 48.8,96.4 41.24,88.84 41.24,87.99 41.12,87.86 40.26,87.86 40.14,87.73 40.14,87.48 40.26,87.35 40.71,87.35 40.83,87.23 40.83,86.97 40.71,86.85 39.36,86.85 39.23,86.72 39.23,86.46 39.36,86.34 40.71,86.34 40.83,86.21 40.83,85.77 40.7,85.64 40.52,85.64 40.26,85.91 40.08,85.91 39.9,85.73 39.9,85.55 40.16,85.28 40.16,85.1 39.98,84.93 39.8,84.93 39.16,85.57 38.98,85.57 38.8,85.39 38.8,85.21 39.44,84.57 39.44,84.39 38.53,83.48 38.53,64.31 38.92,63.93 39.06,63.93 39.18,64.06 39.18,64.27 39.31,64.39 39.56,64.39 39.69,64.27 39.69,63.84 39.46,63.62 39.46,63.44 39.63,63.28 39.81,63.28 v1(40.22,63.7)
  BOTTOM w0.102: 54.9,96.49 55.41,97 U18.A25
  BOTTOM w0.108: 54.9,96.49 52.22,96.49 51.92,96.79 51.04,96.79 50.66,96.4 v1(48.86,96.4)
  BOTTOM w0.178: v1(40.22,63.7) 39.9,63.7 39.73,63.87 CN17.3
M_B_DQ1: length 57
  IN1 w0.127: v1(49.46,97.53) 48.9,97.53 47.97,96.61 47.97,96.18 38.8,87.01 38.8,85.99 38.1,85.3 38.1,64.14 39.79,62.45 39.79,61.86 40.07,61.58 41.01,61.58 41.13,61.46 41.13,61.11 41.01,60.98 40.01,60.98 39.79,60.76 39.79,60.41 v1(39.92,60.28)
  BOTTOM w0.102: U18.C25 56.85,97.3 56.17,97.3 56.16,97.29 55.74,97.29 55.73,97.3 55.42,97.3 55.25,97.13 55.25,97.12 54.85,96.72 53.64,96.72
  BOTTOM w0.108: 53.64,96.72 53.63,96.71 52.48,96.71 52.08,97.12 49.88,97.12 v1(49.46,97.53)
  BOTTOM w0.178: CN17.8 40.98,59.22 v1(39.92,60.28)
M_B_DQ2: length 56.1
  IN1 w0.127: v1(51.96,94.04) 51.7,93.78 51.7,93.07 51.83,92.94 52.39,92.94 52.52,92.82 52.52,92.55 52.39,92.42 49.71,92.42 46.5,89.21 46.5,88.57 46.37,88.45 45.99,88.45 45.86,88.32 45.86,88.04 45.99,87.91 46.37,87.91 46.5,87.79 46.5,87.51 46.37,87.38 45.99,87.38 45.86,87.25 45.86,87.03 45.99,86.9 46.29,86.9 46.41,86.77 46.41,86.47 46.29,86.34 45.99,86.34 45.86,86.21 45.86,85.91 41.99,82.04 41.99,68.45 42.41,68.03 42.41,67.85 41.99,67.43 41.99,67.28 42.21,67.06 42.36,67.06 42.8,67.51 42.93,67.51 43.17,67.27 43.17,67.14 42.74,66.71 42.74,66.53 43.96,65.31 43.96,61.38 44.09,61.25 44.27,61.25 44.4,61.37 v1(44.4,62.81)
  BOTTOM w0.102: U18.C27 56.8,95.4 56.5,95.1 56.2,95.1 56.19,95.11 55.71,95.11 55.7,95.1 54.34,95.1 53.25,94.01 53.1,94.01 53.02,94.09 53.02,94.24 52.93,94.33 52.03,94.33 51.96,94.26 v1(51.96,94.04)
  BOTTOM w0.178: CN17.17 43.22,62.95 43.36,62.81 v1(44.4,62.81)
M_B_DQ3: length 55.7
  IN1 w0.127: v1(52.13,93.39) 52.99,93.39 53.15,93.55 53.15,94.7 53.68,95.23 55.51,95.23 55.64,95.1 55.64,94.08 55.49,93.93 55.21,93.93 55.08,94.06 55.08,94.5 54.88,94.7 53.94,94.7 53.79,94.54 53.79,93.32 52.53,92.07 49.97,92.07 46.93,89.03 46.93,86.37 42.42,81.86 42.42,68.63 43.71,67.34 43.71,67.06 43.34,66.69 43.34,66.51 43.52,66.33 43.7,66.33 44.12,66.75 44.3,66.75 44.49,66.56 44.49,66.38 44.03,65.92 44.03,65.77 44.46,65.34 44.46,64.37 v1(44.39,64.29)
  BOTTOM w0.102: v1(52.13,93.39) 52.97,93.39 54.46,94.88 55.81,94.88 55.82,94.9 56.08,94.9 56.09,94.88 56.61,94.88 56.74,95.02 57.36,95.02 57.75,95.4 U18.D27
  BOTTOM w0.178: v1(44.39,64.29) 44.22,64.45 CN17.21
M_B_DQ4: length 55.6
  IN1 w0.127: v1(57.38,97.46) 54.24,98.18 48.93,98.18 47.41,96.66 47.41,96.3 38.37,87.26 38.37,86.17 37.67,85.47 37.67,63.96 39.5,62.13 39.5,59.2 v1(39.97,58.73)
  BOTTOM w0.178: v1(57.38,97.46) 57.05,97.8 U18.B24 ; CN17.4 39.98,58.72 v1(39.97,58.73)
M_B_DQ5: length 56.1
  IN1 w0.127: v1(51.59,96.35) 51.81,96.57 54.2,96.57 54.33,96.69 54.33,96.99 54.21,97.11 50.16,97.11 48.74,95.69 48.7,95.69 41.68,88.66 41.68,87.64 41.26,87.23 41.26,85.59 38.97,83.3 38.97,64.85 39.05,64.76 40.6,64.76 40.73,64.64 40.73,63.15 40.6,63.02 v1(40.22,63.02)
  BOTTOM w0.102: 53.02,96.28 55,96.28 55.08,96.36 55.4,96.36 56.03,97 U18.B25
  BOTTOM w0.108: 53.02,96.28 51.66,96.28 v1(51.59,96.35)
  BOTTOM w0.178: v1(40.22,63.02) 40.73,63.52 CN17.7
M_B_DQ6: length 56.5
  IN1 w0.127: v1(50.68,92.92) 50.68,93.48 50.58,93.58 50.25,93.58 50.13,93.45 50.13,93.02 50.01,92.9 49.58,92.9 45.43,88.75 45.43,86.09 41.56,82.22 41.56,67.1 43.6,65.06 43.6,61.19 43.19,60.79 43.19,58.51 43.32,58.39 43.72,58.39 43.85,58.52 43.85,60.69 43.94,60.78 v1(44.4,60.78)
  BOTTOM w0.102: v1(50.68,92.92) 50.68,94.27 50.56,94.39 50.56,94.66 50.69,94.79 53.34,94.79 54.21,95.65 55.33,95.65 55.38,95.7 55.7,95.7 55.82,95.58 56.17,95.58 U18.B27
  BOTTOM w0.178: v1(44.4,60.78) 42.98,59.35 CN17.16
M_B_DQ7: length 55.7
  IN1 w0.127: v1(44.41,59.4) 45.36,58.45 46.11,58.45 46.34,58.22 46.34,57.77 46.18,57.61 42.94,57.61 42.76,57.79 42.76,61 43.14,61.38 43.14,64.9 41.12,66.92 41.12,82.4 44.99,86.27 44.99,88.93 50.1,94.03 v1(51.28,94.03)
  BOTTOM w0.102: v1(51.28,94.03) 51.8,94.56 53.45,94.56 54.29,95.4 U18.A27
  BOTTOM w0.178: CN17.20 43.98,58.97 v1(44.41,59.4)
M_B_DQ8: length 45.5
  IN1 w0.127: v1(51.65,91.53) 51.65,91.45 51.31,91.11 50.84,91.11 50.62,90.89 50.62,90.57 50.91,90.29 50.91,90.07 50.48,89.64 49.95,89.64 48.23,87.92 48.23,85.3 48.04,85.12 47.51,85.12 47.51,85.12 44.01,81.62 44.01,81.36 44.25,81.12 44.25,80.79 44.11,80.65 43.9,80.65 43.72,80.46 43.72,69.36 45.76,67.32 45.76,61.58 45.91,61.42 46.09,61.42 46.23,61.56 v1(46.23,61.68)
  BOTTOM w0.102: U18.A29 55.23,93.8 54.61,93.18 53.85,93.18 52.2,91.53 v1(51.65,91.53)
  BOTTOM w0.178: CN17.25 45.22,62.68 v1(46.23,61.68)
M_B_DQ9: length 45.5
  IN1 w0.127: v1(46.24,64.36) 46.19,64.41 46.19,67.5 44.15,69.54 44.15,79.93 45.01,80.79 45.01,80.97 44.68,81.3 44.68,81.48 44.86,81.66 45.04,81.66 45.37,81.33 45.55,81.33 45.73,81.51 45.73,81.69 45.3,82.12 45.3,82.3 45.48,82.48 45.66,82.48 46.09,82.05 46.27,82.05 46.45,82.23 46.45,82.41 46.02,82.84 46.02,83.02 46.2,83.2 46.38,83.2 46.81,82.77 46.99,82.77 47.17,82.95 47.17,83.13 46.74,83.56 46.74,83.74 46.92,83.92 47.1,83.92 47.53,83.49 47.71,83.49 47.89,83.67 47.89,83.85 47.46,84.28 47.46,84.46 47.64,84.64 47.82,84.64 48.25,84.21 48.43,84.21 48.66,84.44 48.66,87.56 50.29,89.2 50.7,89.2 v1(51.65,90.14)
  BOTTOM w0.102: U18.C29 56.8,93.8 56.49,93.49 56.21,93.49 56.19,93.51 56.17,93.51 56.17,93.52 55.73,93.52 55.73,93.51 55.7,93.51 55.68,93.49 55.21,93.49 54.7,92.98 54,92.98 52.44,91.41 52.44,90.93 51.71,90.21
  BOTTOM w0.127: 51.71,90.21 v1(51.65,90.14)
  BOTTOM w0.178: CN17.29 46.22,64.37 v1(46.24,64.36)
M_B_DQ10: length 45
  IN1 w0.127: v1(50.01,60.49) 49.74,60.23 49.31,60.23 49.18,60.36 49.18,60.77 49.31,60.9 49.44,60.9 49.57,61.03 49.57,61.28 49.44,61.41 49.31,61.41 49.18,61.53 49.18,64.7 49.01,64.88 48.85,64.88 48.73,65 48.73,65.23 48.85,65.36 49.24,65.36 49.41,65.53 49.41,71.24 47.17,73.47 47.17,78.67 49.68,81.18 50.27,81.18 50.4,81.31 50.4,81.9 50.55,82.05 50.81,82.05 50.91,81.95 50.91,81.31 51.03,81.18 51.58,81.18 51.68,81.29 51.68,82.18 51.55,82.31 51.37,82.31 51.25,82.43 51.25,82.69 51.37,82.82 51.55,82.82 51.68,82.94 51.68,85.32 54.54,88.17 v1(54.54,89.6)
  BOTTOM w0.108: U18.B32 56.45,91.11 56.07,90.73 56.07,90.57 55.1,89.6 v1(54.54,89.6)
  BOTTOM w0.178: v1(50.01,60.49) 49.19,59.68 49.19,58.68 49.48,58.39 CN17.42
M_B_DQ11: length 45.1
  IN1 w0.127: v2(57.49,91.78) 57.49,90.85 57.34,90.7 56.91,90.7 56.78,90.83 56.78,91.71 56.66,91.84 56.38,91.84 56.25,91.7 56.25,90.55 55.1,89.4 55.1,88.33 52.11,85.34 52.11,80.98 51.88,80.75 49.86,80.75 47.6,78.49 47.6,73.65 49.84,71.42 49.84,64.86 49.55,64.58 49.55,61.92 49.67,61.8 49.92,61.8 v1(50.01,61.89)
  BOTTOM w0.108: v2(57.49,91.78) 57.96,91.78 U18.D32
  BOTTOM w0.178: v1(50.01,61.89) 48.48,60.36 CN17.38
