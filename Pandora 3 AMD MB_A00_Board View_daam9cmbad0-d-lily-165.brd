# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Nets (continued)
GND: C199.2 C215.2 C228.2 C254.2 C287.2 C302.2 C310.2 C323.2 C334.2 C336.2 C339.1 C341.2 C343.2 C345.2 C347.2 C352.1 C356.1 C357.1 C359.2 C360.1 C370.1 C371.2 C391.2 C413.1 C414.1 C415.2 C458.2 C459.2 C463.2 C464.2 C478.2 C479.2 C481.2 C482.2 C483.2 C486.2 C487.1 C489.2 C490.1 C496.1 C497.1 C502.2 C503.2 C504.2 C509.2 C512.2 C513.2 C517.2 C526.2 C529.2 C530.2 C531.2 C533.2 C573.2 C593.1 C623.2 C624.1 C625.2 C626.2 C627.2 C628.1 C632.1 C634.1 C635.2 C638.1 C645.2 C648.2 C659.1 C660.2 C661.1 C662.1 C663.1 C664.2 C665.2 C674.2 C681.2 C682.2 C684.2 C688.1 C689.2 C690.2 C691.2 C692.2 C694.1 C700.2 C701.2 C703.2 C712.2 C714.2 C716.2 C723.1 C724.2 C725.2 C728.2 C729.2 C730.2 C733.2 C734.2 C735.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.2 C751.2 C752.2 C753.1 C754.2 C755.2 C756.2 C757.1 C758.1 C759.2 C760.1 C761.1 C762.2 C763.2 C764.2 C766.1 C767.1 C768.1 C769.1 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C779.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C792.2 C793.2 C798.2 C799.2 C800.2 C801.2 C802.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.2 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C823.2 C824.2 C825.2 C826.2 C827.2 C828.2 C829.2 C830.2 C831.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C838.2 C839.2 C840.2 C841.2 C842.2 C843.2 C844.2 C845.2 C846.2 C847.2 C848.2 C849.2 C850.2 C851.2 C852.2 C853.2 C854.2 C860.2 C862.2 C863.2 C864.2 C865.2 C866.2 C867.2 C868.2 C869.2 C870.2 C871.2 C872.2 C873.2 C874.2 C875.2 C876.2 C877.2 C878.2 C879.2 C880.2 C881.2 C882.2 C883.2 C884.2 C885.2 C886.2 C887.2 C888.1 C889.2 C890.2 C891.2 C892.2 C893.2 C894.2 C895.2 C896.2 C897.2 C898.2 C899.2 C900.2 C901.2 C902.2 C903.2 C904.2 C905.2 C906.2 C907.2 C908.2 C909.2 C910.2 C911.2 C912.2 C913.2 C914.2 C915.2 C916.2 C917.2 C918.1 C919.2 C920.2 C921.2 C922.2 C923.2 C924.2 C925.2 C926.2 C927.2 C928.2 C929.2 C930.2 C931.2 C932.2 C933.2 C934.2 C935.2 C936.2 C937.2 C938.2 C939.2 C940.2 C941.2 C942.2 C943.2 C944.2 C945.2 C946.2 C964.2 C965.2 C968.2 C969.2 C970.2 C971.1 C973.1 C974.2 C977.2 C978.2 C979.1 C980.2 C981.2 C982.2 C983.2 C984.2 C985.2 C986.2 C987.2 C988.2 C989.2 C990.2 C991.1 C992.1 C993.1 C994.1 C995.2 C996.1 C997.2 C998.1 C999.1 C1000.1 C1001.2 C1002.2 C1003.2 C1004.2 C1005.2 C1006.2 C1007.2 C1008.2 C1009.1 C1010.1 C1011.1 C1012.2 C1013.2 C1014.2 C1015.2 C1016.2 C1017.2 C1018.2 C1019.2 C1020.2 C1021.2 C1022.2 C1023.2 C1024.2 C1025.1 C1026.1 C1027.1 C1028.1 C1029.1 C1030.1 C1031.1 C1032.1 C1033.1 C1034.1 C1035.1 C1036.1 C1037.1 C1038.1 C1039.1 C1040.1 C1041.1 C1042.1 C1043.1 C1044.1 C1045.1 C1046.1 C1047.1 C1048.1 C1049.1 C1050.1 C1051.1 C1052.1 C1053.1 C1054.1 C1055.1 C1056.1 C1057.1 C1058.1 C1059.1 C1060.1 C1061.2 C1062.2 C1063.2 C1064.2 C1065.2 C1066.2 C1067.2 C1068.2 C1069.2 C1070.1 C1071.2 C1072.2 C1073.2 C1074.2 C1075.2 C1076.2 C1077.2 C1078.2 C1079.2 C1080.2 C1081.2 C1082.2 C1083.2 C1084.2 C1085.2 C1086.2 C1087.2 C1088.2 C1089.1 C1090.2 C1091.2 C1092.2 C1093.2 C1094.2 C1095.2 C1096.2 C1097.2 C1098.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.1 C1123.1 C1125.1 C1126.1 C1127.1 C1131.1 C1132.1 C1133.2 C1134.1 C1135.1 C1144.1 C1175.2 C1176.1 C1177.1 C1178.1 C1181.2 C1182.1 C1183.2 C1188.2 C1190.2 C1191.1 C1192.1 C1200.2 C1202.2 C1206.2 C1209.2 C1211.1 C1225.2 C1227.1 C1230.1 C1231.2 C1232.2 C1236.1 C1237.1 C1238.2 C1239.2 C9362.2 C9363.2 C9364.2 C9365.2 C9366.2 C9367.2 C9368.1 C9369.1 C9370.2 C9371.2 C9372.2 C9373.2 C9374.1 C9375.1 C9376.1 C9377.2 C9378.2 C9379.2 C9380.2 C9381.2 C9382.2 C9383.2 C9384.2 C9385.1 C9386.1 C9387.1 C9388.1 C9389.2 C9390.2 C9391.2 C9392.2 C9393.2 C9394.2 C9395.2 C9396.2 C9397.2 C9398.2 C9399.2 C9400.2 C9401.2 C9402.2 C9403.2 C9404.2 C9405.2 CN1.5 CN1.6 CN2.1 CN2.31 CN2.32 CN3.5 CN3.6 CN3.9(GND1) CN3.10(GND2) CN4.5 CN4.9 CN4.10 CN5.3 CN5.6 CN5.9 CN5.12 CN5.15 CN5.18 CN5.28 CN5.41 CN5.42 CN5.43 CN5.44 CN6.9(GND1) CN6.10(GND2) CN6.11(GND3) CN6.12(GND4) CN7.2(D2GND) CN7.5(D1GND) CN7.8(D0GND) CN7.11(CKGND) CN7.17(DDCGND) CN7.20(GND1) CN7.21(GND2) CN7.22(GND3) CN7.23(GND4) CN8.4(GND5) CN8.7(GND4) CN8.11(GND1) CN8.12 CN8.13(GND2) CN8.14(GND3) CN9.3 CN9.17 CN9.20 CN9.23 CN9.26 CN9.29 CN9.41 CN9.42 CN9.43 CN9.44 CN10.1(GND) CN10.7(GND#7) CN10.18(GND#18) CN10.33(GND#33) CN10.39(GND#39) CN10.45(GND#45) CN10.51(GND#51) CN10.57(GND#57) CN10.63(GND#63) CN10.69(GND#69) CN10.75(GND#75) CN10.76(GND#76) CN10.77(GND#77) CN11.A1 CN11.A2 CN11.A3 CN11.B1 CN11.B2 CN11.B3 CN12.2(GND8) CN12.4(GND7) CN12.8(GND6) CN12.9(GND5) CN12.10(GND4) CN12.14(GND3) CN12.17(GND2) CN12.20(GND1) CN12.21(GND9) CN12.22(GND10) CN12.23(GND11) CN12.24(GND12) CN13.3(GND1) CN13.5(GND2) CN13.7(GND3) CN13.17(GND4) CN16.1(VSS1) CN16.2(VSS48) CN16.5(VSS2) CN16.6(VSS49) CN16.9(VSS3) CN16.10(VSS50) CN16.14(VSS51) CN16.15(VSS4) CN16.18(VSS52) CN16.19(VSS5) CN16.22(VSS53) CN16.23(VSS6) CN16.26(VSS54) CN16.27(VSS7) CN16.30(VSS55) CN16.31(VSS8) CN16.35(VSS9) CN16.36(VSS56) CN16.39(VSS10) CN16.40(VSS57) CN16.43(VSS11) CN16.44(VSS58) CN16.47(VSS12) CN16.48(VSS59) CN16.51(VSS13) CN16.52(VSS60) CN16.56(VSS61) CN16.57(VSS14) CN16.60(VSS62) CN16.61(VSS15) CN16.64(VSS63) CN16.65(VSS16) CN16.68(VSS64) CN16.69(VSS17) CN16.72(VSS65) CN16.73(VSS18) CN16.77(VSS19) CN16.78(VSS66) CN16.81(VSS20) CN16.82(VSS67) CN16.85(VSS21) CN16.86(VSS68) CN16.89(VSS22) CN16.90(VSS69) CN16.93(VSS23) CN16.94(VSS70) CN16.98(VSS71) CN16.99(VSS24) CN16.102(VSS72) CN16.103(VSS25) CN16.106(VSS73) CN16.107(VSS26) CN16.167(VSS27) CN16.168(VSS74) CN16.171(VSS28) CN16.172(VSS75) CN16.175(VSS29) CN16.176(VSS76) CN16.180(VSS77) CN16.181(VSS30) CN16.184(VSS78) CN16.185(VSS31) CN16.188(VSS79) CN16.189(VSS32) CN16.192(VSS80) CN16.193(VSS33) CN16.196(VSS81) CN16.197(VSS34) CN16.201(VSS35) CN16.202(VSS82) CN16.205(VSS36) CN16.206(VSS83) CN16.209(VSS37) CN16.210(VSS84) CN16.213(VSS38) CN16.214(VSS85) CN16.217(VSS39) CN16.218(VSS86) CN16.222(VSS87) CN16.223(VSS40) CN16.226(VSS88) CN16.227(VSS41) CN16.230(VSS89) CN16.231(VSS42) CN16.234(VSS90) CN16.235(VSS43) CN16.238(VSS91) CN16.239(VSS44) CN16.243(VSS45) CN16.244(VSS92) CN16.247(VSS46) CN16.248(VSS93) CN16.251(VSS47) CN16.252(VSS94) CN16.261(GND) CN16.262(GND#2-262) CN17.1(VSS1) CN17.2(VSS48) CN17.5(VSS2) CN17.6(VSS49) CN17.9(VSS3) CN17.10(VSS50) CN17.14(VSS51) CN17.15(VSS4) CN17.18(VSS52) CN17.19(VSS5) CN17.22(VSS53) CN17.23(VSS6) CN17.26(VSS54) CN17.27(VSS7) CN17.30(VSS55) CN17.31(VSS8) CN17.35(VSS9) CN17.36(VSS56) CN17.39(VSS10) CN17.40(VSS57) CN17.43(VSS11) CN17.44(VSS58) CN17.47(VSS12) CN17.48(VSS59) CN17.51(VSS13) CN17.52(VSS60) CN17.56(VSS61) CN17.57(VSS14) CN17.60(VSS62) CN17.61(VSS15) CN17.64(VSS63) CN17.65(VSS16) CN17.68(VSS64) CN17.69(VSS17) CN17.72(VSS65) CN17.73(VSS18) CN17.77(VSS19) CN17.78(VSS66) CN17.81(VSS20) CN17.82(VSS67) CN17.85(VSS21) CN17.86(VSS68) CN17.89(VSS22) CN17.90(VSS69) CN17.93(VSS23) CN17.94(VSS70) CN17.98(VSS71) CN17.99(VSS24) CN17.102(VSS72) CN17.103(VSS25) CN17.106(VSS73) CN17.107(VSS26) CN17.167(VSS27) CN17.168(VSS74) CN17.171(VSS28) CN17.172(VSS75) CN17.175(VSS29) CN17.176(VSS76) CN17.180(VSS77) CN17.181(VSS30) CN17.184(VSS78) CN17.185(VSS31) CN17.188(VSS79) CN17.189(VSS32) CN17.192(VSS80) CN17.193(VSS33) CN17.196(VSS81) CN17.197(VSS34) CN17.201(VSS35) CN17.202(VSS82) CN17.205(VSS36) CN17.206(VSS83) CN17.209(VSS37) CN17.210(VSS84) CN17.213(VSS38) CN17.214(VSS85) CN17.217(VSS39) CN17.218(VSS86) CN17.222(VSS87) CN17.223(VSS40) CN17.226(VSS88) CN17.227(VSS41) CN17.230(VSS89) CN17.231(VSS42) CN17.234(VSS90) CN17.235(VSS43) CN17.238(VSS91) CN17.239(VSS44) CN17.243(VSS45) CN17.244(VSS92) CN17.247(VSS46) CN17.248(VSS93) CN17.251(VSS47) CN17.252(VSS94) CN17.261(GND) CN17.262(GND#2-262) CON1.1(PRESENCE IND/GND) CON1.3(GND) CON1.21(SSD IND) CON1.27(GND#27) CON1.33(GND#33) CON1.39(GND#39) CON1.45(GND#45) CON1.51(GND#51) CON1.57(GND#57) CON1.71(GND#71) CON1.73(GND#73) CON1.75(USB3.0 IND) CON1.76(GND#76) CON1.77(GND#77) CS3.2 CS4.2 CS6.1 CS8.1 EC11.1 EC12.1 EC13.1 EC14.1 EC15.1 EC16.1 EC17.1 EC18.1 EC20.2 EC24.1 EC25.1 EC26.2 EC28.1 EC29.1 EC30.1 EC31.1 EC32.1 EC33.1 EC34.2 EC35.2 EC36.2 EC37.2 EC38.2 EC42.2 EC43.2 EC44.2 EC45.2 EC54.2 EC55.2 EC56.2 EC57.2 EC59.2 EC60.2 EC61.2 EC62.2 EC63.1 EC64.1 EC65.2 EC66.2 EC67.2 EC68.2 EC69.2 EC70.2 EC71.2 EC72.2 EC73.2 EC74.2 EC75.2 EC76.2 EC77.2 EC78.2 EC79.2 EC80.2 EC81.2 EC87.2 EC88.2 EC89.2 EC90.1 EC91.1 EC139.2 EC140.2 EC141.2 EC142.2 EC143.2 EC144.2 EC145.2 EC146.2 EC147.2 EC148.2 EC151.2 EC152.2 EC153.2 EC154.2 EC155.2 EC156.2 EC157.2 EC158.2 EC159.2 EC160.2 EC161.2 EC162.1 EC163.1 EC164.1 EC165.1 EC166.1 ESD1.2 EU1.3(GND1) EU1.8(GND) FAN1.3 FAN1.5 FAN1.6 FAN2.3 FAN2.5 FAN2.6 H1.1(GND) H2.1(GND) H3.1(GND) H4.1(GND) H5.1(GND) H6.1(GND) H7.1(GND) H8.1(GND) H9.1(GND) H10.1(GND) H11.1(GND) H12.1(GND) H13.1(GND) H16.1(GND) H17.1(GND) H18.1(GND) H19.1(GND) J1.5 J1.6 J2.3 J2.5(GND1) J2.6(GNN2) J3.6 J3.7(GND1) J3.8(GND2) JBAT1.1(BATT1-) JBAT1.2(BATT2-) JBAT1.3(BATT3-) JBAT1.5(SYSPRES#) JBAT1.12(GND1) JBAT1.13(GND2) JCARD1.5(VSS1) JCARD1.8(VSS2) JCARD1.12(GND1) JCARD1.13(GND2) JCARD1.14(GND3) JCARD1.15(GND4) L15.2 PAD1.1 PAD2.1 PC81.2 PC82.2 PC86.2 PC87.2 PC88.2 PC90.2 PC142.1 PC144.2 PC147.2 PC188.2 PC191.2 PC221.2 PC222.2 PC223.2 PC224.2 PC225.2 PC226.2 PC227.2 PC228.2 PC229.2 PC230.2 PC231.2 PC232.2 PC233.2 PC237.2 PC238.2 PC239.2 PC240.2 PC243.2 PC244.2 PC245.2 PC246.2 PC247.2 PC248.2 PC250.2 PC251.2 PC9092.2 PC9093.2 PC9094.1 PC9096.2 PC9097.2 PC9099.1 PC9105.2 PC9106.2 PC9107.2 PC9108.2 PC9109.2 PC9110.2 PC9111.2 PC9112.2 PC9113.2 PC9116.2 PC9117.2 PC9119.2 PC9120.2 PC9121.2 PC9122.1 PC9123.1 PC9128.2 PC9129.2 PC9130.2 PC9131.1 PC9136.1 PC9138.2 PC9140.2 PC9141.2 PC9142.2 PC9143.2 PC9144.1 PC9145.2 PC9146.2 PC9147.2 PC9148.2 PC9151.2 PC9152.2 PC9153.2 PC9154.2 PC9155.2 PC9156.1 PC9158.2 PC9159.2 PC9160.2 PC9166.1 PC9167.2 PC9168.2 PC9169.2 PC9171.2 PC9172.2 PC9173.2 PC9176.1 PC9177.2 PC9178.1 PC9186.2 PC9190.2 PC9191.2 PC9192.2 PC9195.2 PC9196.2 PC9197.2 PC9198.2 PC9199.2 PC9200.2 PC9201.2 PC9202.2 PC9203.2 PC9204.1 PC9205.2 PC9206.2 PC9207.1 PC9208.2 PC9209.1 PC9210.2 PC9211.2 PC9212.2 PC9213.2 PC9214.2 PC9216.2 PC9217.2 PC9221.2 PC9222.2 PC9225.2 PC9226.2 PC9227.2 PC9228.2 PC9229.2 PC9230.2 PC9233.2 PC9234.2 PC9235.2 PC9236.2 PC9237.2 PC9238.2 PC9239.2 PC9240.1 PC9244.1 PC9247.2 PC9248.2 PC9249.2 PC9250.2 PC9253.2 PC9254.2 PC9255.2 PC9256.2 PC9258.2 PC9261.2 PC9262.2 PC9263.2 PC9264.1 PC9265.1 PC9266.1 PC9267.2 PC9269.2 PC9270.2 PC9275.1 PC9277.2 PC9279.2 PC9280.2 PC9283.1 PC9284.2 PC9285.1 PC9286.2 PC9287.2 PC9288.2 PC9291.2 PC9292.2 PC9293.2 PC9294.2 PC9295.2 PC9296.2 PC9297.2 PC9298.2 PC9300.2 PC9302.2 PC9303.2 PC9304.2 PC9305.2 PC9306.2 PC9307.2 PC9308.2 PC9309.2 PC9310.2 PC9311.2 PC9312.2 PC9313.2 PC9314.2 PC9315.2 PC9316.2 PC9317.1 PC9318.1 PC9319.2 PC9320.2 PC9321.2 PC9322.2 PC9323.2 PC9324.2 PC9325.2 PC9326.2 PC9327.2 PC9328.2 PC9329.2 PC9330.1 PC9331.1 PC9332.2 PC9333.1 PC9334.2 PC9335.2 PC9336.2 PC9337.2 PC9340.2 PC9341.2 PC9342.2 PC9345.2 PC9346.2 PC9347.2 PC9348.2 PC9349.2 PC9350.2 PC9351.2 PC9353.2 PC9354.2 PC9355.2 PC9356.2 PC9357.2 PC9358.2 PC9359.2 PC9360.2 PC9361.2 PC9362.2 PC9363.2 PC9364.2 PC9365.1 PC9366.2 PC9367.1 PC9368.2 PC9369.1 PC9370.2 PC9371.1 PC9372.1 PC9373.1 PC9374.1 PC9375.1 PD1.2 PD2.2(ANODE) PQ28.1(EMITTER) PQ31.1(E) PQ32.1(S1) PQ32.2(S2) PQ32.3(S3) PQ35.1(S1) PQ35.2(S2) PQ35.3(S3) PQ36.1(E) PQ42.1(E1) PQ42.2(E2) PQ42.3(E3) PQ43.1(S) PQ43.4(S) PQ45.10(S2) PQ46.10(S2) PQ47.10(S2) PQ48.10(S2) PQ49.10(S2) PQ58.1(E1) PQ58.2(E2) PQ58.3(E3) PQ59.10(S2) PQ60.10(S2) PQ61.10(S2) PQ62.10(S2) PQ66.1 PQ70.1(S) PQ70.4(S) PQ71.1(S) PQ71.4(S) PR60.2 PR62.1 PR113.1 PR186.2 PR195.2 PR199.2 PR204.2 PR206.2 PR208.1 PR210.1 PR225.2 PR229.2 PR235.2 PR236.2 PR242.2 PR244.2 PR256.1 PR260.2 PR274.2 PR280.1 PR281.1 PR282.1 PR283.1 PR287.1 PR299.2 PR301.2 PR307.1 PR310.1 PR313.2 PR325.2 PR326.1 PR327.2 PR328.1 PR331.1 PR334.2 PR347.2 PR361.2 PR364.2 PR370.1 PR375.2 PR382.2 PR388.2 PR398.2 PR400.1 PR412.2 PR424.1 PR425.1 PR426.1 PR427.1 PR430.1 PR434.2 PR446.2 PR451.2 PR454.2 PR460.1 PR472.2 PR495.1 PU2.21(GPAD1) PU2.22(GPAD2) PU2.23(GPAD3) PU2.24(GPAD4) PU2.25(GPAD5) PU2.26(GPAD6) PU9.4(VTTGND1) PU9.11(PGND) PU9.30(VTTGND2) PU9.32(GND) PU9.33(VTTGND3) PU15.22(GND1) PU15.29(GND2) PU15.30(GND3) PU15.31(GND4) PU15.32(GND5) PU15.33(GND6) PU15.34(GND7) PU15.35(GND8) PU15.36(GND9) PU15.37(GND10) PU15.38(GND11) PU16.41(EP) PU17.41(EP) PU18.3(P\F\M\) PU18.4(AGND) PU18.12(PGND1) PU18.13(PGND2) PU18.14(PGND3) PU18.15(PGND4) PU18.19(PGND5) PU19.3(P\F\M\) PU19.4(AGND) PU19.12(PGND1) PU19.13(PGND2) PU19.14(PGND3) PU19.15(PGND4) PU19.19(PGND5) PU20.2(GND) PU21.8(GND) PU21.9 PU23.8(GND) PU23.9 PU24.41(EP) PU25.3(P\F\M\) PU25.4(AGND) PU25.12(PGND1) PU25.13(PGND2) PU25.14(PGND3) PU25.15(PGND4) PU25.19(PGND5) PU27.11(GND1) PU27.15(GND2) PU28.11(GND1) PU28.15(GND2) PU29.11(GND1) PU29.15(GND2) PU30.4(GROUND) Q6.1(S) Q8.1 Q11.1 Q12.1(S) Q13.1(S) Q13.4(S) Q16.1(S) Q16.4(S) Q21.1(S) Q23.1(S) Q23.4(S) Q25.1(S) Q25.4(S) Q30.1(S) Q31.1(S) Q31.4(S) Q36.1(S1) Q36.4(S2) Q37.1 Q41.1(S1) Q41.4(S2) Q42.1 Q45.1(S) Q50.1(S) Q52.3(D) Q53.3(D) Q54.3(D) Q55.3(D) Q56.3(D) Q57.3(D) Q58.3(D) Q59.3(D) Q60.3(D) Q61.3(D) Q62.3(D) Q63.3(D) Q64.1(S) R58.2 R93.1 R94.2 R95.2 R110.2 R112.2 R117.2 R128.1 R133.1 R178.2 R263.1 R346.2 R348.2 R352.2 R397.2 R398.2 R446.2 R462.1 R472.2 R476.2 R483.2 R485.2 R487.2 R488.2 R489.2 R490.2 R491.1 R492.1 R493.1 R497.2 R499.2 R506.1 R507.1 R515.1 R517.1 R518.1 R530.2 R531.1 R534.2 R535.2 R537.2 R538.2 R540.2 R541.2 R542.2 R544.2 R547.2 R548.2 R569.1 R572.1 R574.1 R578.2 R579.1 R581.2 R583.2 R587.1 R591.2 R602.2 R603.2 R604.2 R605.2 R606.1 R607.1 R608.1 R622.2 R628.2 R632.1 R635.2 R640.1 R646.2 R649.1 R650.1 R651.2 R652.2 R666.1 R667.1 R670.2 R673.2 R674.2 R675.2 R681.1 R707.2 R711.2 R717.1 R719.1 R720.1 R766.1 R767.1 R776.1 R777.1 R778.1 R779.1 R780.2 R781.2 R782.2 R783.2 R784.2 R786.2 R792.1 R793.1 R794.1 R795.1 R800.1 R801.1 R802.1 R803.1 R808.1 R809.1 R810.1 R811.1 R821.2 R834.2 R836.2 R872.1 R915.2 R916.2 R919.2 R920.2 R921.2 R922.1 R924.1 R926.1 R928.1 R930.1 R932.1 R935.1 R937.1 R939.1 R941.1 R943.1 R945.1 R946.1 R948.1 R950.1 R952.1 R954.1 R956.1 R958.1 R963.1 R967.2 R971.1 R981.1 R982.1 R985.1 R986.1 R1002.2 R1003.2 R1007.2 R1008.2 R1009.2 R1013.1 R1014.1 R1067.2 R1068.2 R1072.2 R1074.1 R1092.2 R1093.2 R1096.1 RTCBT1.2 RTCBT1.3(G1) RTCBT1.4(G2) U2.33(GND) U5.8(I2C_CTL_EN) U5.15(GND1) U5.35(GND2) U5.41(EPAD) U5.42(SGND1) U5.43(SGND2) U5.44(SGND3) U5.45(SGND4) U5.46(SGND5) U5.47(SGND6) U5.48(SGND7) U5.49(SGND8) U5.50(SGND9) U7.14(GND) U7.17(PWPD) U9.5(GND) U18.A8(VSS_1) U18.A12(VSS_2) U18.A16(VSS_3) U18.A20(VSS_4) U18.A24(VSS_5) U18.A28(VSS_6) U18.A32(VSS_7) U18.AB1(VSS_110) U18.AB2(VSS_111) U18.AB4(VSS_112) U18.AB10(VSS_113) U18.AB13(VSS_114) U18.AB16(VSS_115) U18.AB19(VSS_116) U18.AB22(VSS_117) U18.AD4(VSS_118) U18.AD9(VSS_119) U18.AD12(VSS_120) U18.AD15(VSS_121) U18.AD18(VSS_122) U18.AD21(VSS_123) U18.AD24(VSS_124) U18.AE10(VSS_125) U18.AE13(VSS_126) U18.AE16(VSS_127) U18.AE19(VSS_128) U18.AE22(VSS_129) U18.AF1(VSS_130) U18.AF4(VSS_131) U18.AG9(VSS_132) U18.AG12(VSS_133) U18.AG15(VSS_134) U18.AG18(VSS_135) U18.AG21(VSS_136) U18.AH4(VSS_137) U18.AH10(VSS_138) U18.AH13(VSS_139) U18.AH16(VSS_140) U18.AH19(VSS_141) U18.AH22(VSS_142) U18.AK1(VSS_143) U18.AK4(VSS_144) U18.AK12(VSS_145) U18.AK15(VSS_146) U18.AK18(VSS_147) U18.AK21(VSS_214) U18.AL10(VSS_215) U18.AL16(VSS_148) U18.AL19(VSS_149) U18.AL22(VSS_150) U18.AM4(VSS_151) U18.AN9(VSS_152) U18.AN10(VSS_153) U18.AN15(VSS_154) U18.AN18(VSS_155) U18.AN21(VSS_156) U18.AN25(VSS_157) U18.AN28(VSS_158) U18.AP1(VSS_159) U18.AP2(VSS_160) U18.AP4(VSS_161) U18.AP7(VSS_162) U18.AP22(VSS_163) U18.AP27(VSS_164) U18.AP30(VSS_165) U18.AP33(VSS_166) U18.AR6(VSS_167) U18.AR25(VSS_168) U18.AR28(VSS_169) U18.AT4(VSS_170) U18.AT19(VSS_171) U18.AT22(VSS_172) U18.AT30(VSS_173) U18.AU5(VSS_174) U18.AU8(VSS_175) U18.AU11(VSS_176) U18.AU14(VSS_177) U18.AU20(VSS_178) U18.AU23(VSS_179) U18.AU27(VSS_180) U18.AV4(VSS_181) U18.AV7(VSS_182) U18.AV9(VSS_183) U18.AV12(VSS_184) U18.AV15(VSS_185) U18.AV25(VSS_186) U18.AV30(VSS_187) U18.AV33(VSS_188) U18.AW22(VSS_189) U18.AY4(VSS_190) U18.AY6(VSS_191) U18.AY8(VSS_192) U18.AY10(VSS_193) U18.AY12(VSS_194) U18.AY14(VSS_195) U18.AY16(VSS_196) U18.AY20(VSS_197) U18.AY22(VSS_198) U18.AY24(VSS_199) U18.AY26(VSS_200) U18.AY28(VSS_201) U18.AY30(VSS_202) U18.B2(VSS_8) U18.B8(VSS_9) U18.B12(VSS_10) U18.B33(VSS_11) U18.BB1(VSS_203) U18.BB33(VSS_204) U18.BC4(VSS_205) U18.BC8(VSS_206) U18.BC12(VSS_207) U18.BC16(VSS_208) U18.BC20(VSS_209) U18.BC24(VSS_210) U18.BC28(VSS_211) U18.BC32(VSS_212) U18.C3(VSS_12) U18.D4(VSS_13) U18.D6(VSS_14) U18.D8(VSS_15) U18.D10(VSS_16) U18.D12(VSS_17) U18.D14(VSS_18) U18.D16(VSS_19) U18.D18(VSS_20) U18.D20(VSS_21) U18.D22(VSS_22) U18.D24(VSS_23) U18.D26(VSS_24) U18.D28(VSS_25) U18.D30(VSS_26) U18.F1(VSS_27) U18.F2(VSS_28) U18.F4(VSS_29) U18.F9(VSS_30) U18.F19(VSS_31) U18.F22(VSS_32) U18.F25(VSS_33) U18.F30(VSS_34) U18.F33(VSS_35) U18.G7(VSS_36) U18.G17(VSS_37) U18.G20(VSS_38) U18.G23(VSS_39) U18.G26(VSS_40) U18.H4(VSS_41) U18.H30(VSS_42) U18.J5(VSS_43) U18.J15(VSS_44) U18.J19(VSS_45) U18.J22(VSS_46) U18.J25(VSS_47) U18.J28(VSS_48) U18.K1(VSS_49) U18.K2(VSS_50) U18.K4(VSS_51) U18.K10(VSS_52) U18.K22(VSS_53) U18.K27(VSS_54) U18.K30(VSS_55) U18.K33(VSS_56) U18.L5(VSS_57) U18.L12(VSS_58) U18.L15(VSS_59) U18.L18(VSS_60) U18.L21(VSS_61) U18.L24(VSS_213) U18.L25(VSS_62) U18.L28(VSS_63) U18.M4(VSS_64) U18.M30(VSS_65) U18.N10(VSS_66) U18.N13(VSS_67) U18.N16(VSS_68) U18.N19(VSS_69) U18.N22(VSS_70) U18.N27(VSS_71) U18.P1(VSS_72) U18.P2(VSS_73) U18.P4(VSS_74) U18.P5(VSS_75) U18.P12(VSS_76) U18.P15(VSS_77) U18.P18(VSS_78) U18.P21(VSS_79) U18.P30(VSS_80) U18.P33(VSS_81) U18.T4(VSS_82) U18.T10(VSS_83) U18.T13(VSS_84) U18.T16(VSS_85) U18.T19(VSS_86) U18.T22(VSS_87) U18.T30(VSS_88) U18.U5(VSS_89) U18.U12(VSS_90) U18.U15(VSS_91) U18.U18(VSS_92) U18.U21(VSS_93) U18.U24(VSS_94) U18.V1(VSS_95) U18.V2(VSS_96) U18.V4(VSS_97) U18.W10(VSS_98) U18.W13(VSS_99) U18.W16(VSS_100) U18.W19(VSS_101) U18.W22(VSS_102) U18.Y4(VSS_103) U18.Y5(VSS_104) U18.Y12(VSS_105) U18.Y15(VSS_106) U18.Y18(VSS_107) U18.Y21(VSS_108) U18.Y24(VSS_109) U19.2(GND) U20.4(VSS) U21.2(GND) U22.A2(VSS#0) U22.A5(VSS#1) U22.A9(VSS#2) U22.A13(VSS#3) U22.A17(VSS#4) U22.A21(VSS#5) U22.A25(VSS#6) U22.A29(VSS#7) U22.A33(VSS#8) U22.A37(VSS#9) U22.A40(VSS#10) U22.AA1(VSS#113) U22.AA3(VSS#114) U22.AA5(VSS#115) U22.AA10(VSS#116) U22.AA17(VSS#117) U22.AA19(VSS#118) U22.AA25(VSS#119) U22.AA27(VSS#120) U22.AA32(VSS#121) U22.AA39(VSS#122) U22.AC3(VSS#123) U22.AC7(VSS#124) U22.AC11(VSS#125) U22.AC17(VSS#126) U22.AC19(VSS#127) U22.AC25(VSS#128) U22.AC27(VSS#129) U22.AC39(VSS#130) U22.AE1(VSS#131) U22.AE3(VSS#132) U22.AE5(VSS#133) U22.AE10(VSS#134) U22.AE17(VSS#135) U22.AE19(VSS#136) U22.AE25(VSS#137) U22.AE27(VSS#138) U22.AE32(VSS#139) U22.AE35(VSS#140) U22.AE39(VSS#141) U22.AG3(VSS#142) U22.AG7(VSS#143) U22.AG11(VSS#144) U22.AG17(VSS#145) U22.AG19(VSS#146) U22.AG25(VSS#147) U22.AG27(VSS#148) U22.AG39(VSS#149) U22.AG40(VSS#150) U22.AG41(VSS#151) U22.AJ1(VSS#152) U22.AJ3(VSS#153) U22.AJ5(VSS#154) U22.AJ10(VSS#155) U22.AJ11(VSS#156) U22.AJ35(VSS#157) U22.AJ39(VSS#158) U22.AL3(VSS#159) U22.AL7(VSS#160) U22.AL10(VSS#161) U22.AL11(VSS#162) U22.AL32(VSS#163) U22.AL35(VSS#164) U22.AL39(VSS#165) U22.AM17(VSS#AM17) U22.AM23(VSS#AM23) U22.AN1(VSS#166) U22.AN3(VSS#167) U22.AN7(VSS#168) U22.AN35(VSS#169) U22.AN39(VSS#170) U22.AN40(VSS#171) U22.AN41(VSS#172) U22.AP13(VSS#173) U22.AP17(VSS#174) U22.AR3(VSS#175) U22.AR7(VSS#176) U22.AR11(VSS#177) U22.AR19(VSS#178) U22.AR21(VSS#179) U22.AR25(VSS#180) U22.AR27(VSS#181) U22.AR31(VSS#182) U22.AR35(VSS#183) U22.AR39(VSS#184) U22.AU1(VSS#185) U22.AU3(VSS#186) U22.AU9(VSS#187) U22.AU23(VSS#188) U22.AU29(VSS#189) U22.AW3(VSS#190) U22.AW5(VSS#191) U22.AW7(VSS#192) U22.AW9(VSS#193) U22.AW11(VSS#194) U22.AW13(VSS#195) U22.AW15(VSS#196) U22.AW17(VSS#197) U22.AW19(VSS#198) U22.AW21(VSS#199) U22.AW23(VSS#200) U22.AW25(VSS#201) U22.AW27(VSS#202) U22.AW29(VSS#203) U22.AW31(VSS#204) U22.AW33(VSS#205) U22.AW35(VSS#206) U22.AW37(VSS#207) U22.AW39(VSS#208) U22.AY1(VSS#209) U22.AY2(VSS#210) U22.AY9(VSS#211) U22.AY12(VSS#212) U22.AY17(VSS#213) U22.AY23(VSS#214) U22.AY29(VSS#215) U22.AY37(VSS#216) U22.AY40(VSS#217) U22.AY41(VSS#218) U22.B1(VSS#11) U22.B40(VSS#12) U22.B41(VSS#13) U22.BA2(VSS#219) U22.BA5(VSS#220) U22.BA9(VSS#221) U22.BA17(VSS#222) U22.BA23(VSS#223) U22.BA29(VSS#224) U22.BA37(VSS#225) U22.BA40(VSS#226) U22.C5(VSS#14) U22.C7(VSS#15) U22.C9(VSS#16) U22.C11(VSS#17) U22.C13(VSS#18) U22.C15(VSS#19) U22.C17(VSS#20) U22.C19(VSS#21) U22.C21(VSS#22) U22.C23(VSS#23) U22.C25(VSS#24) U22.C27(VSS#25) U22.C29(VSS#26) U22.C31(VSS#27) U22.C33(VSS#28) U22.C35(VSS#29) U22.C37(VSS#30) U22.C39(VSS#31) U22.E1(VSS#32) U22.E3(VSS#33) U22.E4(VSS#34) U22.E9(VSS#35) U22.E13(VSS#36) U22.E17(VSS#37) U22.E21(VSS#38) U22.E25(VSS#39) U22.E29(VSS#40) U22.E39(VSS#41) U22.E41(VSS#42) U22.G3(VSS#43) U22.G7(VSS#44) U22.G11(VSS#45) U22.G15(VSS#46) U22.G19(VSS#47) U22.G23(VSS#48) U22.G27(VSS#49) U22.G31(VSS#50) U22.G35(VSS#51) U22.G39(VSS#52) U22.J1(VSS#53) U22.J3(VSS#54) U22.J5(VSS#55) U22.J34(VSS#56) U22.J37(VSS#57) U22.J39(VSS#58) U22.J40(VSS#59) U22.J41(VSS#60) U22.K21(VSS#61) U22.K25(VSS#62) U22.K29(VSS#63) U22.K40(VSS#64) U22.L3(VSS#65) U22.L7(VSS#66) U22.L11(VSS#67) U22.L15(VSS#68) U22.L19(VSS#69) U22.L23(VSS#70) U22.L27(VSS#71) U22.L31(VSS#72) U22.L35(VSS#73) U22.L39(VSS#74) U22.N1(VSS#75) U22.N3(VSS#76) U22.N5(VSS#77) U22.N17(VSS#78) U22.N19(VSS#79) U22.N25(VSS#80) U22.N27(VSS#81) U22.N32(VSS#82) U22.N37(VSS#83) U22.N39(VSS#84) U22.R3(VSS#85) U22.R7(VSS#86) U22.R11(VSS#87) U22.R17(VSS#88) U22.R19(VSS#89) U22.R25(VSS#90) U22.R27(VSS#91) U22.R32(VSS#92) U22.R35(VSS#93) U22.R39(VSS#94) U22.U1(VSS#95) U22.U3(VSS#96) U22.U5(VSS#97) U22.U17(VSS#98) U22.U19(VSS#99) U22.U25(VSS#100) U22.U27(VSS#101) U22.U32(VSS#102) U22.U37(VSS#103) U22.U39(VSS#104) U22.W3(VSS#105) U22.W7(VSS#106) U22.W11(VSS#107) U22.W17(VSS#108) U22.W19(VSS#109) U22.W25(VSS#110) U22.W27(VSS#111) U22.W39(VSS#112) U24.3(GND) U27.6(VSS) U28.25(GND_PAD) U29.9(GND) U33.4(GND) U34.1(VSS1) U34.27(VSS2) U34.49(VSS3) U34.91(VSS4) U34.113(VSS5) U34.122(VSS6) U202.3(GND) U203.3(GND) U205.3(GND) U206.2(GND) U207.2(GND) U208.4(VSS) U209.9(GND) U210.9(GND) VRAM1.A1(VSSQ_A1) VRAM1.A3(VSSQ_A3) VRAM1.A12(VSSQ_A12) VRAM1.A14(VSSQ_A14) VRAM1.B5(VSS_B5) VRAM1.B10(VSS_B10) VRAM1.C1(VSSQ_C1) VRAM1.C3(VSSQ_C3) VRAM1.C4(VSSQ_C4) VRAM1.C11(VSSQ_C11) VRAM1.C12(VSSQ_C12) VRAM1.C14(VSSQ_C14) VRAM1.D10(VSS_D10) VRAM1.E1(VSSQ_E1) VRAM1.E3(VSSQ_E3) VRAM1.E12(VSSQ_E12) VRAM1.E14(VSSQ_E14) VRAM1.F5(VSSQ_F5) VRAM1.F10(VSSQ_F10) VRAM1.G5(VSS_G5) VRAM1.G10(VSS_G10) VRAM1.H1(VSS_H1) VRAM1.H2(VSSQ_H2) VRAM1.H13(VSSQ_H13) VRAM1.H14(VSS_H14) VRAM1.K1(VSS_K1) VRAM1.K2(VSSQ_K2) VRAM1.K13(VSSQ_K13) VRAM1.K14(VSS_K14) VRAM1.L5(VSS_L5) VRAM1.L10(VSS_L10) VRAM1.M5(VSSQ_M5) VRAM1.M10(VSSQ_M10) VRAM1.N1(VSSQ_N1) VRAM1.N3(VSSQ_N3) VRAM1.N12(VSSQ_N12) VRAM1.N14(VSSQ_N14) VRAM1.P10(VSS_P10) VRAM1.R1(VSSQ_R1) VRAM1.R3(VSSQ_R3) VRAM1.R4(VSSQ_R4) VRAM1.R11(VSSQ_R11) VRAM1.R12(VSSQ_R12) VRAM1.R14(VSSQ_R14) VRAM1.T5(VSS_T5) VRAM1.T10(VSS_T10) VRAM1.U1(VSSQ_V1) VRAM1.U3(VSSQ_V3) VRAM1.U12(VSSQ_V12) VRAM1.U14(VSSQ_V14) VRAM2.A1(VSSQ_A1) VRAM2.A3(VSSQ_A3) VRAM2.A12(VSSQ_A12) VRAM2.A14(VSSQ_A14) VRAM2.B5(VSS_B5) VRAM2.B10(VSS_B10) VRAM2.C1(VSSQ_C1) VRAM2.C3(VSSQ_C3) VRAM2.C4(VSSQ_C4) VRAM2.C11(VSSQ_C11) VRAM2.C12(VSSQ_C12) VRAM2.C14(VSSQ_C14) VRAM2.D10(VSS_D10) VRAM2.E1(VSSQ_E1) VRAM2.E3(VSSQ_E3) VRAM2.E12(VSSQ_E12) VRAM2.E14(VSSQ_E14) VRAM2.F5(VSSQ_F5) VRAM2.F10(VSSQ_F10) VRAM2.G5(VSS_G5) VRAM2.G10(VSS_G10) VRAM2.H1(VSS_H1) VRAM2.H2(VSSQ_H2) VRAM2.H13(VSSQ_H13) VRAM2.H14(VSS_H14) VRAM2.K1(VSS_K1) VRAM2.K2(VSSQ_K2) VRAM2.K13(VSSQ_K13) VRAM2.K14(VSS_K14) VRAM2.L5(VSS_L5) VRAM2.L10(VSS_L10) VRAM2.M5(VSSQ_M5) VRAM2.M10(VSSQ_M10) VRAM2.N1(VSSQ_N1) VRAM2.N3(VSSQ_N3) VRAM2.N12(VSSQ_N12) VRAM2.N14(VSSQ_N14) VRAM2.P10(VSS_P10) VRAM2.R1(VSSQ_R1) VRAM2.R3(VSSQ_R3) VRAM2.R4(VSSQ_R4) VRAM2.R11(VSSQ_R11) VRAM2.R12(VSSQ_R12) VRAM2.R14(VSSQ_R14) VRAM2.T5(VSS_T5) VRAM2.T10(VSS_T10) VRAM2.U1(VSSQ_V1) VRAM2.U3(VSSQ_V3) VRAM2.U12(VSSQ_V12) VRAM2.U14(VSSQ_V14) VRAM3.A1(VSSQ_A1) VRAM3.A3(VSSQ_A3) VRAM3.A12(VSSQ_A12) VRAM3.A14(VSSQ_A14) VRAM3.B5(VSS_B5) VRAM3.B10(VSS_B10) VRAM3.C1(VSSQ_C1) VRAM3.C3(VSSQ_C3) VRAM3.C4(VSSQ_C4) VRAM3.C11(VSSQ_C11) VRAM3.C12(VSSQ_C12) VRAM3.C14(VSSQ_C14) VRAM3.D10(VSS_D10) VRAM3.E1(VSSQ_E1) VRAM3.E3(VSSQ_E3) VRAM3.E12(VSSQ_E12) VRAM3.E14(VSSQ_E14) VRAM3.F5(VSSQ_F5) VRAM3.F10(VSSQ_F10) VRAM3.G5(VSS_G5) VRAM3.G10(VSS_G10) VRAM3.H1(VSS_H1) VRAM3.H2(VSSQ_H2) VRAM3.H13(VSSQ_H13) VRAM3.H14(VSS_H14) VRAM3.K1(VSS_K1) VRAM3.K2(VSSQ_K2) VRAM3.K13(VSSQ_K13) VRAM3.K14(VSS_K14) VRAM3.L5(VSS_L5) VRAM3.L10(VSS_L10) VRAM3.M5(VSSQ_M5) VRAM3.M10(VSSQ_M10) VRAM3.N1(VSSQ_N1) VRAM3.N3(VSSQ_N3) VRAM3.N12(VSSQ_N12) VRAM3.N14(VSSQ_N14) VRAM3.P10(VSS_P10) VRAM3.R1(VSSQ_R1) VRAM3.R3(VSSQ_R3) VRAM3.R4(VSSQ_R4) VRAM3.R11(VSSQ_R11) VRAM3.R12(VSSQ_R12) VRAM3.R14(VSSQ_R14) VRAM3.T5(VSS_T5) VRAM3.T10(VSS_T10) VRAM3.U1(VSSQ_V1) VRAM3.U3(VSSQ_V3) VRAM3.U12(VSSQ_V12) VRAM3.U14(VSSQ_V14) VRAM4.A1(VSSQ_A1) VRAM4.A3(VSSQ_A3) VRAM4.A12(VSSQ_A12) VRAM4.A14(VSSQ_A14) VRAM4.B5(VSS_B5) VRAM4.B10(VSS_B10) VRAM4.C1(VSSQ_C1) VRAM4.C3(VSSQ_C3) VRAM4.C4(VSSQ_C4) VRAM4.C11(VSSQ_C11) VRAM4.C12(VSSQ_C12) VRAM4.C14(VSSQ_C14) VRAM4.D10(VSS_D10) VRAM4.E1(VSSQ_E1) VRAM4.E3(VSSQ_E3) VRAM4.E12(VSSQ_E12) VRAM4.E14(VSSQ_E14) VRAM4.F5(VSSQ_F5) VRAM4.F10(VSSQ_F10) VRAM4.G5(VSS_G5) VRAM4.G10(VSS_G10) VRAM4.H1(VSS_H1) VRAM4.H2(VSSQ_H2) VRAM4.H13(VSSQ_H13) VRAM4.H14(VSS_H14) VRAM4.K1(VSS_K1) VRAM4.K2(VSSQ_K2) VRAM4.K13(VSSQ_K13) VRAM4.K14(VSS_K14) VRAM4.L5(VSS_L5) VRAM4.L10(VSS_L10) VRAM4.M5(VSSQ_M5) VRAM4.M10(VSSQ_M10) VRAM4.N1(VSSQ_N1) VRAM4.N3(VSSQ_N3) VRAM4.N12(VSSQ_N12) VRAM4.N14(VSSQ_N14) VRAM4.P10(VSS_P10) VRAM4.R1(VSSQ_R1) VRAM4.R3(VSSQ_R3) VRAM4.R4(VSSQ_R4) VRAM4.R11(VSSQ_R11) VRAM4.R12(VSSQ_R12) VRAM4.R14(VSSQ_R14) VRAM4.T5(VSS_T5) VRAM4.T10(VSS_T10) VRAM4.U1(VSSQ_V1) VRAM4.U3(VSSQ_V3) VRAM4.U12(VSSQ_V12) VRAM4.U14(VSSQ_V14) Y1.2(NC1) Y1.4 Y4.2(NC1) Y4.4 Y6.2(NC1) Y6.4
V18: C1132.2 U28.24(V18)
VDD10: C343.1 C356.2 C357.2 C359.1 C360.2 C625.1 C626.1 C645.1 R962.2 U2.3(AVDD10(NC)) U2.8(AVDD10_1) U2.22(DVDD10(NC)) U2.30(AVDD10)
VDDC_VMEM_EN: PR414.2 PR450.1 R1035.1 U205.4(O)
VSS_SENSE: R503.2 R505.2 R1066.2 U18.H12(VSS_SENSE)
32K_X1: C762.1 R553.1 U18.AT1(X32K_X1) Y3.1
32K_X2: C763.1 R553.2 U18.AT2(X32K_X2) Y3.2
48M_X1: C766.2 R586.2 U18.T2(X48M_X1) Y4.1
48M_X2: C767.2 R586.1 U18.T1(X48M_X2) Y4.3(NC)
5388_S3: PC144.1 PR479.2 PR480.2 PU9.5(S3)
5388_S5: D50.2(IN) D52.2(IN) PC9361.1 PR111.1 PR120.2 PU9.6(S5)
5388BST: PR469.1 PU9.27(BST)
5388BST_S: PC9338.1 PR469.2
5388CS: PC138.1 PR103.1 PU9.10(CS)
5388FB: PC151.1 PR113.2 PR121.1 PU9.3(VDDQSET)
5388FB_S: PC151.2 PR121.2 SJ6.2
5388PHASE: PC9219.1 PC9338.2 PL25.2 PU9.17(LX1) PU9.25(LX2)
36001_C1: R833.2 R834.1 U29.12(C1)
36001_C2: R835.2 R836.1 U29.6(C2)
62771_COMP: PC9125.1 PC9127.1 PR287.2 PU16.19(COMP)
62771_COMP_CI: PC9251.1 PC9252.1 PR400.2 PU24.36(COMP_NB)
62771_COMP_GFX: PC9162.1 PC9164.1 PR331.2 PU17.19(COMP)
62771_COMP_GPU: PC9271.1 PC9274.1 PR430.2 PU24.19(COMP)
62771_COMP_NB: PC9102.1 PC9104.1 PR256.2 PU16.36(COMP_NB)
62771_EN: PC9364.1 PR270.2 PU16.8(ENABLE)
62771_EN_GFX: PC9366.1 PR318.2 PU17.8(ENABLE)
62771_EN_GPU: PC9369.2 PR414.1 PU24.8(ENABLE)
62771_FB: PC9125.2 PR288.2 PR289.2 PR292.2 PR295.2 PU16.18(FB)
62771_FB_CI: PC9252.2 PR393.2 PR394.2 PR396.2 PR401.2 PU24.37(FB_NB)
62771_FB_GFX: PC9162.2 PR332.2 PR333.2 PR336.2 PR339.2 PU17.18(FB)
62771_FB_GPU: PC9271.2 PR431.2 PR432.2 PR433.2 PR436.2 PU24.18(FB)
62771_FB_NB: PC9104.2 PR249.2 PR250.2 PR253.2 PR257.2 PU16.37(FB_NB)
62771_PWROK: PC9365.2 PR273.2 PU16.9(PWROK)
62771_PWROK_GFX: PC9367.2 PR321.2 PU17.9(PWROK)
62771_PWROK_GPU: PC9264.2 PR416.1 PU24.9(PWROK)
62771_RTN: PC9144.2 PR300.2 PR301.1 PU16.17(RTN)
62771_RTN_GFX: PC9178.2 PR346.2 PR347.1 PU17.17(RTN)
62771_RTN_GPU: PC9285.2 PR445.1 PR446.1 PU24.17(RTN)
62771_SVC: PR265.2 PU16.3(SVC)
62771_SVC_GFX: PR309.2 PU17.3(SVC)
62771_SVC_GPU: PR406.1 PU24.3(SVC)
62771_SVD: PR267.2 PU16.5(SVD)
62771_SVD_GFX: PR314.2 PU17.5(SVD)
62771_SVD_GPU: PR410.1 PU24.5(SVD)
62771_SVT: PR269.2 PU16.7(SVT)
62771_SVT_GFX: PR316.2 PU17.7(SVT)
62771_SVT_GPU: PR413.1 PU24.7(SVT)
62771_VDDIO: PR268.2 PU16.6(VDDIO)
62771_VDDIO_GPU: PR411.1 PU24.6(VDDIO)
62771_VRHOT: PR266.2 PU16.4(VR_HOT_L)
62771_VRHOT_GFX: PR311.2 PU17.4(VR_HOT_L)
62771_VRHOT_GPU: PR409.2 PU24.4(VR_HOT_L) R1095.1
62771_VRHOT_GPU#_R: PR409.1 R1089.1 U34.97(HSCK/GPH4/ID4)
62771_VSEN: PC9133.1 PC9136.2 PR294.2 PR295.1 PR297.2 PU16.16(VSEN)
62771_VSEN_CI: PC9240.2 PC9242.1 PR390.2 PR391.1 PR393.1 PU24.38(VSEN_NB)
62771_VSEN_GFX: PC9170.1 PC9176.2 PR338.2 PR339.1 PR342.2 PU17.16(VSEN)
62771_VSEN_GPU: PC9278.1 PC9283.2 PR436.1 PR438.2 PR442.1 PU24.16(VSEN)
62771_VSEN_NB: PC9094.2 PC9095.1 PR246.2 PR247.2 PR249.1 PU16.38(VSEN_NB)
+APU_VDD_33: C882.1 R623.2 U18.AP19(VDD_33_1) U18.AP21(VDD_33_2)
+APU_VDD_33_S5: C883.1 C884.1 R624.2 U18.AP15(VDD_33_S5_1) U18.AR15(VDD_33_S5_2)
+APU_VDDIO_AZ: C830.1 C831.1 C832.1 R618.2 U18.AR19(VDDIO_AUDIO)
+CARD_3V: C1191.2 C1192.2 C1230.2 JCARD1.6(VDD) U28.5(CARD_3V3)
+DC_IN: FL1.2 FL2.2 PC84.1 PC239.1 PD4.2 PQ40.5(D1) PQ40.6(D2) PQ40.7(D3) PQ40.8(D4) PR61.1 PR185.1 PR194.1 PR228.1 PR243.1 PR515.1
+DC_IN_SS: PC85.1 PQ30.1 PQ40.1(S1) PQ40.2(S2) PQ40.3(S3) PQ41.1(S1) PQ41.2(S2) PQ41.3(S3) PR201.2 PR218.1
+DCIN_JACK: CN11.A6 CN11.A7 CN11.A8 CN11.B6 CN11.B7 CN11.B8 EC36.1 EC37.1 EC38.1 FL1.1 FL2.1 TP326.1 TP327.1 TP328.1
+DOCK_PSID: CN11.A5 CN11.B5 EL14.1
+KB_LED_PWR: C502.1 FS1.2 J1.1
+LCDVCC: C458.1 C459.1 C674.1 CN9.10 CN9.11 CN9.12 U206.1(OUT)
+LED_BL: C463.1 C464.1 CN9.37 CN9.38 CN9.39 CN9.40 Q7.3(D) R118.1
+PWR_SRC: C485.1 C489.1 C623.1 C665.1 C682.1 C690.1 C747.1 C748.1 C9374.2 C9396.1 C9397.1 C9398.1 C9399.1 C9400.1 C9401.1 C9402.1 C9403.1 C9404.1 C9405.1 CS6.2 EC34.1 EC35.1 EC87.1 EC88.1 EC89.1 EC139.1 EC140.1 EC141.1 EC142.1 EC143.1 EC144.1 EC145.1 EC146.1 EC147.1 EC148.1 EC151.1 EC152.1 EC153.1 EC154.1 EC155.1 EC156.1 EC157.1 EC158.1 EC159.1 EC160.1 EC161.1 PC230.1 PC231.1 PC232.1 PC240.1 PC243.1 PC244.1 PC247.1 PC9092.1 PC9093.1 PC9096.1 PC9097.1 PC9112.1 PC9113.1 PC9128.1 PC9129.1 PC9130.1 PC9147.1 PC9148.1 PC9158.1 PC9159.1 PC9160.1 PC9190.1 PC9191.1 PC9192.1 PC9216.1 PC9217.1 PC9238.1 PC9239.1 PC9256.1 PC9258.1 PC9267.1 PC9269.1 PC9270.1 PC9286.1 PC9287.1 PC9288.1 PC9345.1 PC9348.1 PC9349.1 PC9357.1 PC9358.1 PC9359.1 PC9360.1 PC9376.2 PQ33.5(D1) PQ33.6(D2) PQ33.7(D3) PQ33.8(D4) PQ37.5(D1) PQ37.6(D2) PQ37.7(D3) PQ37.8(D4) PQ38.5(D1) PQ38.6(D2) PQ38.7(D3) PQ38.8(D4) PQ39.5(D1) PQ39.6(D2) PQ39.7(D3) PQ39.8(D4) PQ45.3(D1A) PQ45.4(D1B) PQ45.9(D1C) PQ46.3(D1A) PQ46.4(D1B) PQ46.9(D1C) PQ47.3(D1A) PQ47.4(D1B) PQ47.9(D1C) PQ48.3(D1A) PQ48.4(D1B) PQ48.9(D1C) PQ49.3(D1A) PQ49.4(D1B) PQ49.9(D1C) PQ57.5(D1) PQ57.6(D2) PQ57.7(D3) PQ57.8(D4) PQ59.3(D1A) PQ59.4(D1B) PQ59.9(D1C) PQ60.3(D1A) PQ60.4(D1B) PQ60.9(D1C) PQ61.3(D1A) PQ61.4(D1B) PQ61.9(D1C) PQ62.3(D1A) PQ62.4(D1B) PQ62.9(D1C) PR115.1 PR232.2 PR360.2 PR449.1 PR477.1 PU2.12(VIN) PU9.21(VIN1) PU9.22(VIN2) PU9.23(VIN3) PU9.24(VIN4) PU9.34(VIN5) PU18.7(NC) PU18.8(IN1) PU18.9(IN2) PU18.22(IN3) PU19.7(NC) PU19.8(IN1) PU19.9(IN2) PU19.22(IN3) PU25.7(NC) PU25.8(IN1) PU25.9(IN2) PU25.22(IN3) Q7.1(S) R135.1
+RTC_1: RTCBT1.1 RTCR1.1
+SMDDR_VREF: PC147.1 PU9.1(VTTREF)
+SMDDR_VTT: C896.1 C897.1 C926.1 C927.1 CN16.258(VTT) CN17.258(VTT) PC9222.1 PU9.29(VTT) PU9.31(VTTSNS)
+USB_RE_PWR: C1144.2 R833.1 R835.1 R1080.2 U29.3(VDD(1V8))
+USB_SIDE3_PWR: C481.1 C482.1 C483.1 C684.1 CN8.1(VBUS) U7.12(OUT)
+V_VDDQ: C771.1 C772.1 C773.1 C774.1 C775.1 C782.1 C783.1 C784.1 C785.1 C786.1 C787.1 C788.1 C789.1 C790.1 C798.1 C799.1 C800.1 C801.1 C811.1 C812.1 C813.1 C814.1 C815.1 C816.1 C890.1 C891.1 C892.1 C893.1 C894.1 C895.1 C900.1 C901.1 C902.1 C903.1 C904.1 C905.1 C909.1 C910.1 C911.1 C912.1 C913.1 C914.1 C915.1 C916.1 C920.1 C921.1 C922.1 C923.1 C924.1 C925.1 C930.1 C931.1 C932.1 C933.1 C934.1 C935.1 C939.1 C940.1 C941.1 C942.1 C943.1 C944.1 C945.1 C946.1 C9382.1 CN16.111(VDD1) CN16.112(VDD2) CN16.117(VDD3) CN16.118(VDD4) CN16.123(VDD5) CN16.124(VDD6) CN16.129(VDD7) CN16.130(VDD8) CN16.135(VDD9) CN16.136(VDD10) CN16.141(VDD11) CN16.142(VDD12) CN16.147(VDD13) CN16.148(VDD14) CN16.153(VDD15) CN16.154(VDD16) CN16.159(VDD17) CN16.160(VDD18) CN16.163(VDD19) CN17.111(VDD1) CN17.112(VDD2) CN17.117(VDD3) CN17.118(VDD4) CN17.123(VDD5) CN17.124(VDD6) CN17.129(VDD7) CN17.130(VDD8) CN17.135(VDD9) CN17.136(VDD10) CN17.141(VDD11) CN17.142(VDD12) CN17.147(VDD13) CN17.148(VDD14) CN17.153(VDD15) CN17.154(VDD16) CN17.159(VDD17) CN17.160(VDD18) CN17.163(VDD19) CS3.1 PC9221.1 PC9225.1 PC9226.1 PC9227.1 PC9228.1 PC9229.1 PL25.1 R463.1 R464.1 R627.2 R629.1 R630.2 R634.2 R636.1 R638.2 SJ6.1 SJ7.1 SJ9.1 U18.AB24(VDDIO_MEM_S3_14) U18.AB27(VDDIO_MEM_S3_15) U18.AB30(VDDIO_MEM_S3_16) U18.AB33(VDDIO_MEM_S3_17) U18.AD25(VDDIO_MEM_S3_18) U18.AD28(VDDIO_MEM_S3_19) U18.AD30(VDDIO_MEM_S3_20) U18.AE24(VDDIO_MEM_S3_21) U18.AE27(VDDIO_MEM_S3_22) U18.AF30(VDDIO_MEM_S3_23) U18.AF33(VDDIO_MEM_S3_24) U18.AG25(VDDIO_MEM_S3_25) U18.AG28(VDDIO_MEM_S3_26) U18.AH24(VDDIO_MEM_S3_27) U18.AH27(VDDIO_MEM_S3_28) U18.AH30(VDDIO_MEM_S3_29) U18.AK25(VDDIO_MEM_S3_30) U18.AK28(VDDIO_MEM_S3_31) U18.AK30(VDDIO_MEM_S3_32) U18.AK33(VDDIO_MEM_S3_33) U18.AL27(VDDIO_MEM_S3_34) U18.AM30(VDDIO_MEM_S3_35) U18.P25(VDDIO_MEM_S3_1) U18.P28(VDDIO_MEM_S3_2) U18.T24(VDDIO_MEM_S3_3) U18.T27(VDDIO_MEM_S3_4) U18.U25(VDDIO_MEM_S3_5) U18.U28(VDDIO_MEM_S3_6) U18.V30(VDDIO_MEM_S3_7) U18.V33(VDDIO_MEM_S3_8) U18.W24(VDDIO_MEM_S3_9) U18.W27(VDDIO_MEM_S3_10) U18.Y25(VDDIO_MEM_S3_11) U18.Y28(VDDIO_MEM_S3_12) U18.Y30(VDDIO_MEM_S3_13)
+VCHGR: EC29.2 EC30.2 EC31.2 JBAT1.9(BATT3+) JBAT1.10(BATT2+) JBAT1.11(BATT1+) PC227.1 PC228.1 PD3.2 PR220.2
+VCHGR_P: PL15.2 PQ33.1(S1) PQ33.2(S2) PQ33.3(S3) PR190.2 PR220.1
+VGPU_CORE: C982.1 C984.1 C985.1 C986.1 C987.1 C988.1 C989.1 C993.2 C994.2 C995.1 C996.2 C997.1 C998.2 C999.2 C1000.2 C1001.1 PC9261.1 PC9262.1 PC9263.1 PC9277.1 PC9279.1 PC9280.1 PL27.2 PL28.2 PR438.1 R1077.1 U22.AA13(VDDC#24) U22.AA15(VDDC#25) U22.AA21(VDDC#26) U22.AA23(VDDC#27) U22.AA29(VDDC#28) U22.AA31(VDDC#29) U22.AC13(VDDC#30) U22.AC15(VDDC#31) U22.AC21(VDDC#32) U22.AC23(VDDC#33) U22.AC29(VDDC#34) U22.AC31(VDDC#35) U22.AE13(VDDC#36) U22.AE15(VDDC#37) U22.AE21(VDDC#38) U22.AE23(VDDC#39) U22.AE29(VDDC#40) U22.AE31(VDDC#41) U22.AG13(VDDC#42) U22.AG15(VDDC#43) U22.AG21(VDDC#44) U22.AG23(VDDC#45) U22.AG29(VDDC#46) U22.AG31(VDDC#47) U22.AJ13(VDDC#48) U22.AJ15(VDDC#49) U22.AJ17(VDDC#50) U22.AJ19(VDDC#51) U22.AJ21(VDDC#52) U22.AJ23(VDDC#53) U22.AJ25(VDDC#54) U22.AJ27(VDDC#55) U22.AJ29(VDDC#56) U22.AJ31(VDDC#57) U22.AL13(VDDC#58) U22.AL15(VDDC#59) U22.AL17(VDDC#60) U22.AL19(VDDC#61) U22.AL21(VDDC#62) U22.AL23(VDDC#63) U22.AL25(VDDC#64) U22.AL27(VDDC#65) U22.AL29(VDDC#66) U22.AL31(VDDC#67) U22.N13(VDDC#0) U22.N15(VDDC#1) U22.N21(VDDC#2) U22.N23(VDDC#3) U22.N29(VDDC#4) U22.N31(VDDC#5) U22.R13(VDDC#6) U22.R15(VDDC#7) U22.R21(VDDC#8) U22.R23(VDDC#9) U22.R29(VDDC#10) U22.R31(VDDC#11) U22.U13(VDDC#12) U22.U15(VDDC#13) U22.U21(VDDC#14) U22.U23(VDDC#15) U22.U29(VDDC#16) U22.U31(VDDC#17) U22.W13(VDDC#18) U22.W15(VDDC#19) U22.W21(VDDC#20) U22.W23(VDDC#21) U22.W29(VDDC#22) U22.W31(VDDC#23)
+VREF_CA_A0: C888.2 C898.1 C899.1 C9380.1 C9381.1 CN16.164(VREF_CA) JP51.1 R630.1 R632.2
+VREF_CA_B0: C918.2 C928.1 C929.1 C9379.1 C9383.1 CN17.164(VREF_CA) JP51.2 R638.1 R640.2
AC_PRESENT: R1005.1 U18.AG3(AC_PRES/USB_OC4_L/IR_RX0/AGPIO2) U34.112(RING#/PWRFAIL#/CK32KOUT/LPCRST#)
ACAV_IN: D43.1(OUT) PQ36.2(B) PR230.1 PR236.1 PR237.2 Q30.2(G)
ACCEL_INTH#_R: TP254.1 U18.BA19(GENINT2_L/AGPIO90)
ACZ_BCLK_R: R534.1 R561.2 U18.AU6(AZ_BITCLK/I2S_BCLK_MIC)
ACZ_RST#_R: R540.1 R563.2 U18.AU9(AZ_RST_L/I2S_LR_MIC)
ACZ_SDIN1: R537.1 U18.AP6(AZ_SDIN1/I2S_LR_PLAYBACK)
ACZ_SDIN2: R538.1 U18.AR5(AZ_SDIN2/I2S_DATA_PLAYBACK)
ACZ_SDOUT_R: R544.1 R558.2 U18.AR7(AZ_SDOUT/I2S_DATA_MIC1)
ACZ_SPKR: CN5.24 R1052.2
ACZ_SPKR_R: R1052.1 U18.BA17(SPKR/AGPIO91)
ACZ_SYNC_R: R542.1 R559.2 U18.AT9(AZ_SYNC/I2S_BCLK_PLAYBACK)
ADBIA0: U22.H21(ADBIA0) VRAM1.J4(ABI$)
ADBIA1: U22.H19(ADBIA1) VRAM2.J4(ABI$)
ADBIB0: U22.W8(ADBIB0) VRAM3.J4(ABI$)
ADBIB1: U22.AA8(ADBIB1) VRAM4.J4(ABI$)
AGPIO3: R595.2 R605.1 U18.AL5(AGPIO3)
AGPIO5: R545.2 R1092.1 U18.AJ1(AGPIO5)
AGPIO8: R546.2 R1093.1 TP322.1 U18.AJ4(AGPIO8)
AGPIO10: R543.1 U18.AE8(S0A3_GPIO/AGPIO10)
AGPIO11: R597.2 R607.2 U18.AN5(BLINK/USB_OC7_L/AGPIO11)
AGPIO65: R527.2 U18.AU15(AGPIO65)
AGPIO66: TP249.1 U18.AT15(AGPIO66/SHUTDOWN_L)
AGPIO76: R583.1 U18.AW12(SPI_TPM_CS_L/AGPIO76)
AGPIO86: TP324.1 U18.BB13(LPC_SMI_L/AGPIO86)
ALW_ON: PR205.1 Q31.2(G) U34.83(EGCS#/GPE2)
ANALOGIO: R767.2 U22.AY38(ANALOGIO)
APU_ALERT#: R473.2 U18.B17(ALERT_L)
APU_AN30: TP155.1 U18.AN30(RSVD_4)
APU_DBRDY: CN13.14(CPU_DBRDY0) U18.C13(DBRDY)
APU_DBREQ#: C756.1 R519.1 R520.1 U18.A11(DBREQ_L)
APU_DISP_BLEN: D4.1(INA) D18.2 Q32.3(D1) R470.2 U34.120(TMRI0/GPC4(3))
APU_DISP_ON: D3.1(INA) D17.2 Q32.6(D2) R469.2
APU_DISP_ON_R: Q32.1(S2) U18.G6(DP_DIGON)
APU_DPST_PWM: Q44.6(D2) R482.2 R1038.2
APU_DPST_PWM_R: Q44.1(S2) U18.F11(DP_VARY_BL)
APU_I2C_INT#: D6.2(IN) R460.2 R1012.2 U18.BB19(FANOUT0/AGPIO85)
APU_LVDS_BLON_R: Q32.4(S1) U18.G5(DP_BLON)
APU_MA_VREFDQ: TP110.1 U18.B19(MA_VREFDQ)
APU_MB_VREFDQ: TP111.1 U18.A19(MB_VREFDQ)
APU_PROCHOT#_R: Q44.4(S1) R471.2 U18.A15(PROCHOT_L)
APU_PWRGD: C752.1 PR273.1 PR321.1 R468.2 R478.1 R491.2 U18.C19(PWROK) U19.3(A2)
APU_PWROK_BUF: CN13.10(CPU_PWROK_BUF) R514.2 U19.4(Y2)
APU_RST#: C751.1 R467.2 TP121.1 U18.D15(RESET_L) U19.1(A1)
APU_RST_L_BUF: CN13.12(CPU_RST_L_BUF) R516.2 U19.6(Y1)
APU_S5_MUX_CTRL: PQ66.2 PR456.1 U18.AH8(S5_MUX_CTRL/EGPIO42)
APU_SIC: Q33.4(S1) R474.2 U18.B18(SIC)
APU_SID: Q33.1(S2) R475.2 U18.C17(SID)
APU_SPI_CLK: EC26.1 EC91.2 R610.1 U18.BC6(SPI_CLK/ESPI_CLK/EGPIO117)
APU_SPI_CS0#: R609.1 U18.BB8(SPI_CS1_L/EGPIO118)
APU_SPI_HOLD#: R614.2 U18.BA7(SPI_HOLD_L/EGPIO133)
APU_SPI_SI: R612.1 U18.BA9(SPI_DI/ESPI_DATA/EGPIO120)
APU_SPI_SO: R611.1 U18.AY7(SPI_DO/EGPIO121)
APU_SPI_WP: R613.2 U18.AW11(SPI_WP_L/EGPIO122)
APU_SVC: PR265.1 R484.2
APU_SVD: PR267.1 R486.2
APU_SVT: PR269.1 R480.1 U18.C15(SVT0)
APU_TCK: CN13.2(CPU_TCK) R509.1 U18.D13(TCK)
APU_TDI: C755.1 R511.1 R512.1 U18.H15(TDI)
APU_TDO: CN13.8(CPU_TDO) U18.H14(TDO)
APU_TEST0: R568.1 R569.2 U18.AH6(TEST0)
APU_TEST1: R571.1 R572.2 TP126.1 U18.AK8(TEST1/TMS)
APU_TEST2: R573.1 R574.2 U18.AE3(TEST2)
APU_TEST11: R488.1 U18.B11(TEST11)
APU_TEST14: R483.1 U18.B10(TEST14)
APU_TEST15: TP117.1 U18.D11(TEST15)
APU_TEST16: R485.1 U18.A10(TEST16)
APU_TEST17: R487.1 U18.C11(TEST17)
APU_TEST18: CN13.20(CPU_PLLTEST1) R489.1 U18.A14(TEST18)
APU_TEST19: CN13.18(CPU_PLLTEST0) R490.1 U18.B14(TEST19)
APU_TEST28_H: TP118.1 U18.A13(TEST28_H)
APU_TEST28_L: TP119.1 U18.B13(TEST28_L)
APU_TEST31: TP120.1 U18.P26(TEST31)
APU_TEST37: R498.1 R499.1 U18.A17(TEST37)
APU_TEST410: TP113.1 U18.AK24(TEST410)
APU_TEST411: TP114.1 U18.AL24(TEST411)
APU_THERMDA: TP115.1 U18.P24(TEST4)
APU_THERMDC: TP116.1 U18.N24(TEST5)
APU_TMS: CN13.4(CPU_TMS) R510.1 U18.G15(TMS)
APU_TRST#: C754.1 R508.1 R513.2 U18.J14(TRST_L)
APU_U30: TP153.1 U18.U30(RSVD_2)
APU_U31: TP154.1 U18.U31(RSVD_3)
APU_VDD_RUN_FB_H: PR297.1 U18.G12(VDDCR_CPU_SENSE)
APU_VDD_RUN_FB_L: PR300.1 R505.1
APU_VDDGFX_RUN_FB_H: PR342.1 U18.H11(VDDCR_GFX_SENSE)
APU_VDDGFX_RUN_FB_L: PR346.1 R503.1
APU_VDDNB_RUN_FB_H: PR247.1 U18.J12(VDDCR_NB_SENSE)
APU_VDDP_RUN_FB_H: PR493.2 U18.AY18(VDDP_SENSE)
APU_VDDP_RUN_FB_L: PR492.1 R1066.1
AUD_SPK_L+: CN1.1 CN3.1 EC45.1
AUD_SPK_L-: CN1.2 CN3.2 EC44.1
AUD_SPK_R+: CN1.4 CN3.4 EC42.1
AUD_SPK_R-: CN1.3 CN3.3 EC43.1
AUX_ZVSS: R921.1 U22.BA12(AUX_ZVSS)
BAT_LED_AMBER: Q13.5(G) U34.32(PWM6/SSCK/GPA6)
BAT_LED_AMBER#: EC164.2 Q13.3(D) R1108.1
BAT_LED_W#: EC166.2 Q13.6(D) R1109.1
BAT_LED_WHITE: Q13.2(G) Q16.3(D) R967.1 U34.2(CK32KE/GPJ7(3))
BEEP: CN5.25 R1053.1
BEEP_R: R1053.2 U34.34(PWM7/RIG1#/GPA7)
BID1: R970.1 R971.2 U34.71(ADC5/DCD1#/GPI5(3))
BIOS_CS#_B: R600.2 R609.2 TP294.1 U20.1(CE#)
BIOS_HOLD#_B: R601.1 R614.1 TP299.1 U20.7(HOLD#)
BIOS_RD#_B: R612.2 TP296.1 U20.2(SO)
BIOS_SPI_CLK_B: R610.2 TP295.1 U20.6(SCK)
BIOS_WP_B: R599.1 R613.1 TP298.1 U20.3(WP#)
BIOS_WR#_B: R611.2 TP297.1 U20.5(SI)
BLON_PWM: R717.2 U22.AC38(BL_PWM_DIM)
BOARD_ID0: TP246.1 U18.BC3(SD0_DATA0/EGPIO97)
BOARD_ID1: TP245.1 U18.BA3(SD0_DATA1/EGPIO98)
BOARD_ID2: TP124.1 U18.BC5(SD0_DATA2/EGPIO99)
BOARD_ID3: TP125.1 U18.BA5(SD0_DATA3/EGPIO100)
BOOT_1: PR290.1 PU16.21(BOOT1)
BOOT_2: PR271.1 PU16.30(BOOT2)
BOOT_CI: PR392.1 PU24.31(BOOT_NB)
BOOT_GFX1: PR330.1 PU17.21(BOOT1)
BOOT_GFX2: PR308.1 PU17.30(BOOT2)
BOOT_GPU1: PR429.1 PU24.21(BOOT1)
BOOT_GPU2: PR408.1 PU24.30(BOOT2)
BOOT_NB: PR252.1 PU16.31(BOOT_NB)
BP_0: R643.1 TP278.1 U22.AA38(BP_0)
BP_1: R644.1 TP277.1 U22.AA37(BP_1)
BT_RADIO_DIS#: CN10.54(BT_DISABLE#) U34.99(HMOSI/GPH6/ID6)
CAP_LED: Q21.2(G) R352.1 U34.117(PECI/SMCLK2/GPF6(3))
CAP_LED_L: CN2.4 R350.2
CASA0B: U22.D23(CASA0B) VRAM1.L3(CAS$__RAS$)
CASA1B: U22.D17(CASA1B) VRAM2.G3(RAS$__CAS$)
CASB0B: U22.U4(CASB0B) VRAM3.L3(CAS$__RAS$)
CASB1B: U22.AC4(CASB1B) VRAM4.G3(RAS$__CAS$)
CHGR_ACDET: PC246.1 PR228.2 PR229.1 PU15.6(ACDET)
CHGR_ACDRV: PR217.2 PU15.4(ACDRV)
CHGR_ACN: PC241.2 PC250.1 PR232.2P PU15.1(ACN)
CHGR_ACOK: PR230.2 PU15.5(ACOK)
CHGR_ACP: PC241.1 PC251.1 PR232.1P PU15.2(ACP)
CHGR_BATDRV: PR187.1 PU15.18(BATDRV)
CHGR_BATDRV_P: PQ33.4(G) PR187.2
CHGR_BATSRC: PR190.1 PU15.17(BATSRC)
CHGR_BST: PR483.1 PU15.25(BTST)
CHGR_CMSRC: PR218.2 PU15.3(CMSRC)
CHGR_HIDRV: PQ37.4(G) PU15.26(HIDRV) TP102.1
CHGR_IDCHG: PU15.8(IDCHG) TP101.1
CHGR_LODRV: PQ32.4(G) PU15.23(LODRV) TP98.1
CHGR_PHASE: PC236.2 PC242.1 PL15.1 PQ32.5(D1) PQ32.6(D2) PQ32.7(D3) PQ32.8(D4) PQ37.1(S1) PQ37.2(S2) PQ37.3(S3) PU15.27(PHASE)
CHGR_PROCHOT#: PR215.2 PU15.10(P\R\O\C\H\O\T\)
CHGR_REGN: PC226.1 PR237.1 PU15.24(REGN)
CHGR_SRN: PR188.2 PU15.19(SRN)
CHGR_SRP: PR189.2 PU15.20(SRP)
CHGR_TB_STAT: PR191.2 PU15.16(T\B\_\S\T\A\T\)
CHGR_VCC: PC245.1 PR234.2 PU15.28(VCC)
CKEA0: U22.G21(CKEA0) VRAM1.J3(CKE$)
CKEA1: U22.E19(CKEA1) VRAM2.J3(CKE$)
CKEB0: U22.W5(CKEB0) VRAM3.J3(CKE$)
CKEB1: U22.AA7(CKEB1) VRAM4.J3(CKE$)
CLK_PCI_EC: C768.2 R589.1 U34.13(LPCCLK/GPM4(3))
CLK_PCIE_LANN: R812.2 U2.16(REFCLK_N)
CLK_PCIE_LANN_R: R812.1 U18.W3(GPP_CLK1N)
CLK_PCIE_LANP: R813.2 U2.15(REFCLK_P)
CLK_PCIE_LANP_R: R813.1 U18.W4(GPP_CLK1P)
CLK_PCIE_WLANN: CN10.49(REFCLKN) R585.2
CLK_PCIE_WLANN_R: R585.1 U18.U2(GPP_CLK0N)
CLK_PCIE_WLANP: CN10.47(REFCLKP) R584.2
CLK_PCIE_WLANP_R: R584.1 U18.U1(GPP_CLK0P)
CLK_REQ3: R528.1 U18.BB18(CLK_REQ3_L/SATA_IS1_L/SATA_ZP1_)
CLK_VGA_N: R816.2 U22.AU33(PCIE_REFCLKN)
CLK_VGA_N_R: R816.1 U18.U3(GFX_CLKN)
CLK_VGA_P: R817.2 U22.AV33(PCIE_REFCLKP)
CLK_VGA_P_R: R817.1 U18.U4(GFX_CLKP)
CLKA0: R772.2 U22.E31(CLKA0) VRAM1.J12(CK)
CLKA0B: R768.2 U22.D31(CLKA0B) VRAM1.J11(CK$)
CLKA1: R773.2 U22.D7(CLKA1) VRAM2.J12(CK)
CLKA1B: R769.2 U22.D9(CLKA1B) VRAM2.J11(CK$)
CLKB0: R774.2 U22.G4(CLKB0) VRAM3.J12(CK)
CLKB0B: R770.2 U22.J4(CLKB0B) VRAM3.J11(CK$)
CLKB1: R775.2 U22.AL5(CLKB1) VRAM4.J12(CK)
CLKB1B: R771.2 U22.AL4(CLKB1B) VRAM4.J11(CK$)
CLKREQB: Q50.2(G) R707.1 R960.1 U22.AV40(CLKREQB)
CLKRUN#: R1070.1 U18.BC11(LPC_CLKRUN_L/AGPIO88) U34.93(CLKRUN#/GPH0/ID0)
COMP_OUT1: PC9299.2 PQ63.2 PQ64.2 PR455.1 PR462.1 PU30.1(OUTPUT) PU30.6(MINUS INPUT)
CORE_PWM_PROCHOT#: PQ43.3(D) PR215.1 PR266.1 PR311.1 Q42.3 Q44.3(D1) R481.2
CSA0B_0: U22.H31(CSA0B_0) VRAM1.G12(CS$__WE$)
CSA1B_0: U22.E7(CSA1B_0) VRAM2.L12(WE$__CS$)
CSB0B_0: U22.G5(CSB0B_0) VRAM3.G12(CS$__WE$)
CSB1B_0: U22.AL8(CSB1B_0) VRAM4.L12(WE$__CS$)
DB_USB3_0_C1: R981.2 R984.1 U209.12(C1)
DB_USB3_0_C2: R982.2 R983.1 U209.6(C2)
DB_USB3_1_C1: R985.2 R988.1 U210.12(C1)
DB_USB3_1_C2: R986.2 R987.1 U210.6(C2)
DBGDATA_0: R944.1 R945.2 U22.L40(DBGDATA_0)
DBGDATA_1: R946.2 R947.1 U22.L41(DBGDATA_1)
DBGDATA_2: R948.2 R949.1 U22.M40(DBGDATA_2)
DBGDATA_3: R950.2 R951.1 U22.M41(DBGDATA_3)
DBGDATA_4: R952.2 R953.1 U22.N40(DBGDATA_4)
DBGDATA_5: R954.2 R955.1 U22.N41(DBGDATA_5)
DBGDATA_6: R956.2 R957.1 U22.P40(DBGDATA_6)
DBGDATA_7: R958.2 R959.1 U22.P41(DBGDATA_7)
DCR_EN: R1010.2 R1037.1 U18.AL6(AGPIO4)
DCR_EN_R: CN9.33 R1037.2
DDBIA0_0: U22.J38(DDBIA0_0) VRAM1.D2(DBI0$__DBI3$)
DDBIA0_1: U22.F40(DDBIA0_1) VRAM1.D13(DBI1$__DBI2$)
DDBIA0_2: U22.A38(DDBIA0_2) VRAM1.P13(DBI2$__DBI1$)
DDBIA0_3: U22.B30(DDBIA0_3) VRAM1.P2(DBI3$__DBI0$)
DDBIA1_0: U22.B25(DDBIA1_0) VRAM2.D2(DBI0$__DBI3$)
DDBIA1_1: U22.B18(DDBIA1_1) VRAM2.D13(DBI1$__DBI2$)
DDBIA1_2: U22.A12(DDBIA1_2) VRAM2.P2(DBI3$__DBI0$)
DDBIA1_3: U22.B5(DDBIA1_3) VRAM2.P13(DBI2$__DBI1$)
DDBIB0_0: U22.E2(DDBIB0_0) VRAM3.D13(DBI1$__DBI2$)
DDBIB0_1: U22.M1(DDBIB0_1) VRAM3.D2(DBI0$__DBI3$)
DDBIB0_2: U22.V2(DDBIB0_2) VRAM3.P13(DBI2$__DBI1$)
DDBIB0_3: U22.AE2(DDBIB0_3) VRAM3.P2(DBI3$__DBI0$)
DDBIB1_0: U22.AK2(DDBIB1_0) VRAM4.D2(DBI0$__DBI3$)
DDBIB1_1: U22.AV1(DDBIB1_1) VRAM4.D13(DBI1$__DBI2$)
DDBIB1_2: U22.AY6(DDBIB1_2) VRAM4.P13(DBI2$__DBI1$)
DDBIB1_3: U22.AV9(DDBIB1_3) VRAM4.P2(DBI3$__DBI0$)
DDR0_SA0: CN16.256(SA0) R913.2 R915.1
DDR0_SA1: CN16.260(SA1) R914.2 R916.1
DDR1_SA0: CN17.256(SA0) R917.2 R919.1
DDR1_SA1: CN17.260(SA1) R918.2 R920.1
DDR4_RUNON: PR479.1 U34.77(HDIO3/GPJ1(3))
DDR4_SUSON: PR120.1 U34.76(TACH2/HDIO2/GPJ0(3))
DDR4_SUSON_2V5: PR386.1 U34.68(ADC2/GPI2(3))
DDR_PWRGD: PU9.8(PGOOD) R202.2
DGPU_HOLD_RST#: R657.2 U18.AR14(AGPIO71/SGPIO_DATAOUT)
DGPU_HOLD_RST#_R: R657.1 R658.2 U24.1(I1)
DGPU_PWR_EN: R1022.2 R1024.2 R1034.2 R1079.1 U18.BC13(AGPIO72/SGPIO_DATAIN)
DGPU_PWROK: PR407.1 PR416.2 PR496.2 PR512.2 PU25.1(PGOOD) Q51.1(S) R1020.2 R1073.1
DGPU_PWROK_R: Q51.3(D) R1027.1 R1073.2 U18.BC17(CLK_REQ2_L/AGPIO116) U34.107(FDIO2/DTR1#/SBUSY/GPG1/ID7(DN))
DGPUT_CLK: Q40.1(S) R691.1 R732.2
DGPUT_CLK_R: R691.2 U22.AW40(SMBCLK)
DGPUT_DATA: Q40.4(S) R693.1 R731.2
DGPUT_DATA_R: R693.2 U22.AW41(SMBDAT)
DIECRACKMON: R646.1 TP276.1 U22.B2(TEST6)
DMIC_CLK: R246.1 R1051.1
DMIC_CLK_C: CN9.5 EC64.2 R1051.2
DMIC_CLK_R: CN5.29 EC32.2 R246.2
DMIC_DATA: R248.1 R1050.1
DMIC_DATA_C: CN9.4 EC63.2 R1050.2
DMIC_DATA_R: CN5.30 EC33.2 R248.2
DP_AUX_ZVSS: R472.1 U18.B9(DP_AUX_ZVSS)
DP_STEREOSYNC: R496.1 R497.1 U18.E11(DP_STEREOSYNC/TEST36)
DP_ZVSS: R476.1 U18.A9(DP_ZVSS)
DQA0_0: U22.L34(DQA0_0) VRAM1.E2(DQ5__DQ29)
DQA0_1: U22.L37(DQA0_1) VRAM1.F4(DQ6__DQ30)
DQA0_2: U22.L38(DQA0_2) VRAM1.E4(DQ4__DQ28)
DQA0_3: U22.J35(DQA0_3) VRAM1.F2(DQ7__DQ31)
DQA0_4: U22.G37(DQA0_4) VRAM1.B2(DQ3__DQ27)
DQA0_5: U22.E38(DQA0_5) VRAM1.B4(DQ2__DQ26)
DQA0_6: U22.E35(DQA0_6) VRAM1.A4(DQ0__DQ24)
DQA0_7: U22.D35(DQA0_7) VRAM1.A2(DQ1__DQ25)
DQA0_8: U22.H41(DQA0_8) VRAM1.B13(DQ11__DQ19)
DQA0_9: U22.H40(DQA0_9) VRAM1.A13(DQ9__DQ17)
DQA0_10: U22.G41(DQA0_10) VRAM1.A11(DQ8__DQ16)
DQA0_11: U22.G40(DQA0_11) VRAM1.B11(DQ10__DQ18)
DQA0_12: U22.E40(DQA0_12) VRAM1.E13(DQ13__DQ21)
DQA0_13: U22.D41(DQA0_13) VRAM1.F13(DQ15__DQ23)
DQA0_14: U22.D40(DQA0_14) VRAM1.F11(DQ14__DQ22)
DQA0_15: U22.C41(DQA0_15) VRAM1.E11(DQ12__DQ20)
DQA0_16: U22.C40(DQA0_16) VRAM1.M11(DQ22__DQ14)
DQA0_17: U22.B39(DQA0_17) VRAM1.M13(DQ23__DQ15)
DQA0_18: U22.A39(DQA0_18) VRAM1.N13(DQ21__DQ13)
DQA0_19: U22.B38(DQA0_19) VRAM1.N11(DQ20__DQ12)
DQA0_20: U22.B36(DQA0_20) VRAM1.T13(DQ19__DQ11)
DQA0_21: U22.A36(DQA0_21) VRAM1.U13(DQ17__DQ9)
DQA0_22: U22.B35(DQA0_22) VRAM1.T11(DQ18__DQ10)
DQA0_23: U22.A35(DQA0_23) VRAM1.U11(DQ16__DQ8)
DQA0_24: U22.B33(DQA0_24) VRAM1.U4(DQ24__DQ0)
DQA0_25: U22.B32(DQA0_25) VRAM1.T4(DQ26__DQ2)
DQA0_26: U22.A32(DQA0_26) VRAM1.U2(DQ25__DQ1)
DQA0_27: U22.B31(DQA0_27) VRAM1.T2(DQ27__DQ3)
DQA0_28: U22.A30(DQA0_28) VRAM1.N4(DQ28__DQ4)
DQA0_29: U22.B29(DQA0_29) VRAM1.N2(DQ29__DQ5)
DQA0_30: U22.B28(DQA0_30) VRAM1.M2(DQ31__DQ7)
DQA0_31: U22.A28(DQA0_31) VRAM1.M4(DQ30__DQ6)
DQA1_0: U22.B27(DQA1_0) VRAM2.F4(DQ6__DQ30)
DQA1_1: U22.A27(DQA1_1) VRAM2.F2(DQ7__DQ31)
DQA1_2: U22.B26(DQA1_2) VRAM2.E2(DQ5__DQ29)
DQA1_3: U22.A26(DQA1_3) VRAM2.E4(DQ4__DQ28)
DQA1_4: U22.A24(DQA1_4) VRAM2.B2(DQ3__DQ27)
DQA1_5: U22.B23(DQA1_5) VRAM2.A2(DQ1__DQ25)
DQA1_6: U22.A23(DQA1_6) VRAM2.B4(DQ2__DQ26)
DQA1_7: U22.B22(DQA1_7) VRAM2.A4(DQ0__DQ24)
DQA1_8: U22.B20(DQA1_8) VRAM2.A11(DQ8__DQ16)
DQA1_9: U22.A20(DQA1_9) VRAM2.B11(DQ10__DQ18)
DQA1_10: U22.B19(DQA1_10) VRAM2.A13(DQ9__DQ17)
DQA1_11: U22.A19(DQA1_11) VRAM2.B13(DQ11__DQ19)
DQA1_12: U22.B17(DQA1_12) VRAM2.E11(DQ12__DQ20)
DQA1_13: U22.A16(DQA1_13) VRAM2.E13(DQ13__DQ21)
DQA1_14: U22.B16(DQA1_14) VRAM2.F13(DQ15__DQ23)
DQA1_15: U22.A15(DQA1_15) VRAM2.F11(DQ14__DQ22)
DQA1_16: U22.B15(DQA1_16) VRAM2.U4(DQ24__DQ0)
DQA1_17: U22.A14(DQA1_17) VRAM2.U2(DQ25__DQ1)
DQA1_18: U22.B14(DQA1_18) VRAM2.T2(DQ27__DQ3)
DQA1_19: U22.B13(DQA1_19) VRAM2.T4(DQ26__DQ2)
DQA1_20: U22.A11(DQA1_20) VRAM2.M4(DQ30__DQ6)
DQA1_21: U22.B11(DQA1_21) VRAM2.N4(DQ28__DQ4)
DQA1_22: U22.A10(DQA1_22) VRAM2.N2(DQ29__DQ5)
DQA1_23: U22.B10(DQA1_23) VRAM2.M2(DQ31__DQ7)
DQA1_24: U22.B8(DQA1_24) VRAM2.M11(DQ22__DQ14)
DQA1_25: U22.A7(DQA1_25) VRAM2.N11(DQ20__DQ12)
DQA1_26: U22.B7(DQA1_26) VRAM2.N13(DQ21__DQ13)
DQA1_27: U22.A6(DQA1_27) VRAM2.M13(DQ23__DQ15)
DQA1_28: U22.A4(DQA1_28) VRAM2.T11(DQ18__DQ10)
DQA1_29: U22.B4(DQA1_29) VRAM2.T13(DQ19__DQ11)
DQA1_30: U22.A3(DQA1_30) VRAM2.U13(DQ17__DQ9)
DQA1_31: U22.B3(DQA1_31) VRAM2.U11(DQ16__DQ8)
DQB0_0: U22.C2(DQB0_0) VRAM3.A11(DQ8__DQ16)
DQB0_1: U22.C1(DQB0_1) VRAM3.A13(DQ9__DQ17)
DQB0_2: U22.D2(DQB0_2) VRAM3.B13(DQ11__DQ19)
DQB0_3: U22.D1(DQB0_3) VRAM3.B11(DQ10__DQ18)
DQB0_4: U22.F1(DQB0_4) VRAM3.F13(DQ15__DQ23)
DQB0_5: U22.G2(DQB0_5) VRAM3.E13(DQ13__DQ21)
DQB0_6: U22.G1(DQB0_6) VRAM3.E11(DQ12__DQ20)
DQB0_7: U22.H2(DQB0_7) VRAM3.F11(DQ14__DQ22)
DQB0_8: U22.K2(DQB0_8) VRAM3.F2(DQ7__DQ31)
DQB0_9: U22.K1(DQB0_9) VRAM3.E2(DQ5__DQ29)
DQB0_10: U22.L2(DQB0_10) VRAM3.E4(DQ4__DQ28)
DQB0_11: U22.L1(DQB0_11) VRAM3.F4(DQ6__DQ30)
DQB0_12: U22.N2(DQB0_12) VRAM3.B4(DQ2__DQ26)
DQB0_13: U22.P2(DQB0_13) VRAM3.B2(DQ3__DQ27)
DQB0_14: U22.P1(DQB0_14) VRAM3.A2(DQ1__DQ25)
DQB0_15: U22.R2(DQB0_15) VRAM3.A4(DQ0__DQ24)
DQB0_16: U22.R1(DQB0_16) VRAM3.M11(DQ22__DQ14)
DQB0_17: U22.T2(DQB0_17) VRAM3.M13(DQ23__DQ15)
DQB0_18: U22.T1(DQB0_18) VRAM3.N13(DQ21__DQ13)
DQB0_19: U22.U2(DQB0_19) VRAM3.N11(DQ20__DQ12)
DQB0_20: U22.W1(DQB0_20) VRAM3.T13(DQ19__DQ11)
