# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_RXN0: length 173.3
  IN4 w0.102: v2(84.95,114.36) 85.17,114.14 85.17,113.87 85.5,113.54 86.54,113.54 86.98,113.1 89.37,113.1 90.69,111.78 95.34,111.78 96.26,110.86 99.39,110.86 103.65,106.6 104.67,106.6 105.8,105.47 105.8,103.14 107.73,101.21 107.73,86.1 110.22,83.61 110.22,68.58 111.38,67.42 111.38,44.53 111.84,44.07 111.84,41.91 118.67,35.07 127.57,26.18 129.21,26.18 129.78,25.61 145.24,25.61 146.27,26.63 150.42,26.63 151.45,27.66 171.61,27.66 172.29,26.98 176.19,26.98 v1(176.32,26.86)
  BOTTOM w0.102: v1(176.32,26.86) 176.52,26.66 176.52,26.34 180.53,20.53 180.65,20.35 180.86,20.05 C1106.2 ; v2(84.95,114.36) 84.95,114.37 84.95,115.23 85.25,115.53 U18.AV1
SATA_RXN0_C: length 3.2
  BOTTOM w0.102: C1106.1 182.29,20.53 182.46,20.53 183.17,19.82 183.41,19.82 183.55,19.67 CON1.43
SATA_RXN1: length 147.6
  IN3 w0.114: v1(27.86,21.82) 27.68,21.82 27.6,21.89 27.6,22.15 27.77,22.32 28.58,22.32 30.7,24.44 32.64,29.87 32.64,60.96 34.23,64.39 37.4,67.56 41.61,77.74 48.06,97.53 52.73,102.2 58.6,104.77 59.43,105.6 62.82,105.6 62.92,105.55 64.59,104.68 68.09,104.68 71.67,106.76 72.02,106.76 72.51,107.25 72.51,110.38 72.68,110.55 72.68,111.96 73.82,113.1 75.46,114 78.07,114 79.82,113.54 81.36,113.54 82.38,112.53 82.42,112.48 83.84,112.18 84.5,112.18 84.66,112.02 85.57,112.02 85.92,112.37 85.92,112.7 87.08,113.87 87.08,114.19 v2(87.29,114.39)
  BOTTOM w0.102: U18.AW4 86.6,113.9 87.09,114.39 v2(87.29,114.39)
  BOTTOM w0.114: v1(27.86,21.82) 27.62,21.58 27.62,21.33 27.91,21.04 28.54,21.04 32.08,17.5 32.12,17.46 34.01,11.9 34.01,10.62 C740.2
SATA_RXN1_C: length 2.5
  BOTTOM w0.114: CN12.16 34.42,8 34.27,8.16 34.27,8.48 33.86,8.88 33.86,9.11 C740.1
SATA_RXP0: length 173.3
  IN4 w0.102: v2(85.61,114.38) 85.45,114.22 85.45,113.98 85.61,113.82 86.65,113.82 87.09,113.38 89.48,113.38 90.81,112.06 95.46,112.06 96.38,111.14 99.51,111.14 103.76,106.88 104.79,106.88 106.08,105.59 106.08,103.26 108.01,101.33 108.01,86.21 110.5,83.72 110.5,68.69 111.66,67.54 111.66,44.65 112.12,44.19 112.12,42.03 118.79,35.35 118.79,35.35 127.69,26.46 129.32,26.46 129.89,25.89 145.13,25.89 146.16,26.91 150.31,26.91 151.33,27.94 171.73,27.94 172.4,27.26 175.81,27.26 175.86,27.31 176.55,27.31 v1(177.02,26.84)
  BOTTOM w0.102: v1(177.02,26.84) 176.91,26.84 176.73,26.66 176.73,26.41 180.66,20.73 180.82,20.56 181.01,20.56 181.14,20.69 181.14,21.08 C1105.2 ; U18.AV2 85.15,115 85.15,114.73 85.5,114.38 v2(85.61,114.38)
SATA_RXP0_C: length 3.2
  BOTTOM w0.102: C1105.1 182.25,20.74 182.55,20.74 183.26,20.03 183.41,20.03 183.55,20.17 CON1.41
SATA_RXP1: length 147.6
  IN3 w0.114: v2(86.5,114.37) 86.76,114.37 86.87,114.27 86.87,113.96 85.7,112.79 85.7,112.46 85.48,112.23 84.75,112.23 84.59,112.4 83.87,112.4 82.53,112.68 81.45,113.76 79.85,113.76 78.1,114.22 75.4,114.22 73.69,113.27 72.46,112.05 72.46,110.64 72.3,110.47 72.3,107.34 71.93,106.97 71.61,106.97 68.03,104.89 64.65,104.89 62.87,105.82 59.34,105.82 58.48,104.95 52.61,102.38 47.87,97.65 44.63,87.73 41.42,77.86 41.4,77.82 37.21,67.68 36.97,67.43 34.45,64.91 34.4,64.87 34.05,64.52 32.43,61.01 32.43,29.91 30.51,24.56 28.49,22.54 27.68,22.54 27.39,22.24 27.39,21.89 27.31,21.82 v1(27.06,21.82)
  BOTTOM w0.102: U18.AW3 86.17,114.7 v2(86.5,114.37)
  BOTTOM w0.114: v1(27.06,21.82) 27.31,21.82 27.4,21.72 27.4,21.24 27.82,20.82 28.45,20.82 31.93,17.35 33.8,11.87 33.8,10.44 33.68,10.33 C739.2
SATA_RXP1_C: length 2.5
  BOTTOM w0.114: CN12.15 33.92,8.02 34.05,8.15 34.05,8.39 33.65,8.79 33.65,9.11 C739.1
SATA_TXN0: length 176.9
  IN4 w0.102: v1(173.63,28.69) 173.62,28.7 151.02,28.7 149.99,27.68 127.64,27.68 112.88,42.44 112.88,44.54 112.42,45 112.42,67.89 111.26,69.05 111.26,84.04 108.78,86.53 108.78,101.65 106.85,103.58 106.85,105.9 104.66,108.09 103.71,108.09 98.98,112.82 96.47,112.82 95.42,113.87 90.33,113.87 89.09,115.12 86.96,115.12 86.89,115.18 82.97,115.18 82.56,114.78 82.56,114.01 82.88,113.7 83.94,113.7 v2(84.05,113.59)
  BOTTOM w0.102: v2(84.05,113.59) 84.36,113.9 U18.AU4 ; v1(173.63,28.69) 173.63,28.54 174.14,28.03 174.18,27.99 180.65,19.29 180.73,19.18 180.73,19.13 180.96,18.9 C1103.2
SATA_TXN0_C: length 2.9
  BOTTOM w0.102: C1103.1 182.2,18.51 183.5,18.51 183.67,18.67 CON1.47
SATA_TXN1: length 147.7
  IN3 w0.114: v2(87.25,115.56) 87.48,115.33 87.48,115.23 87.35,115.1 75.4,115.1 73.54,114.14 72.34,112.94 71.99,112.94 71.3,112.25 71.3,110.59 70.83,109.21 70.59,108.97 68.86,107.24 65.7,106.67 64.19,106.67 62.87,106.99 57.35,106.99 56.39,106.03 54.33,105.11 47.51,98.29 47.42,98.2 47.13,97.92 40.69,78.17 40.68,78.13 36.46,67.94 33.61,65.08 33.57,65.05 33.36,64.84 31.72,61.23 31.72,30.04 29.94,25.15 28.73,23.94 27.68,23.94 27.37,23.64 27.37,23.2 27.25,23.08 v1(27.07,23.08)
  BOTTOM w0.102: v2(87.25,115.56) 86.91,115.9 U18.AY1
  BOTTOM w0.114: C741.2 35.94,10.33 36.01,10.39 36.01,10.91 32.57,19.6 30.61,21.56 29.63,21.56 28.85,22.33 27.62,22.33 27.38,22.57 27.38,22.76 v1(27.07,23.08)
SATA_TXN1_C: length 2.5
  BOTTOM w0.114: C741.1 35.8,9.06 35.8,8.92 35.56,8.68 35.56,8.17 35.42,8.03 CN12.18
SATA_TXP0: length 176.9
  IN4 w0.102: v1(173.27,28.14) 173.27,28.22 173.07,28.42 151.13,28.42 150.11,27.4 127.52,27.4 112.6,42.32 112.6,44.43 112.14,44.89 112.14,67.78 110.99,68.93 110.99,83.92 108.5,86.41 108.5,101.53 106.57,103.46 106.57,105.79 104.54,107.81 103.59,107.81 98.86,112.54 96.36,112.54 95.3,113.59 90.21,113.59 88.97,114.84 86.84,114.84 86.78,114.9 83.08,114.9 82.84,114.66 82.84,114.13 83,113.97 83.8,113.97 v2(84.06,114.23)
  BOTTOM w0.102: U18.AU3 84.45,114.63 v2(84.06,114.23) ; v1(173.27,28.14) 173.73,28.14 173.98,27.89 180.48,19.16 180.48,18.31 C1104.2
SATA_TXP0_C: length 2.9
  BOTTOM w0.102: CON1.49 183.61,18.17 183.49,18.29 182.34,18.29 C1104.1
SATA_TXP1: length 147.7
  IN3 w0.114: v1(27.86,23.08) 27.59,23.35 27.59,23.55 27.77,23.72 28.81,23.72 30.12,25.03 31.93,30 31.93,61.19 32.74,62.95 33.54,64.72 36.64,67.81 40.88,78.05 47.32,97.8 54.42,104.89 54.45,104.93 56.52,105.85 57.44,106.77 62.85,106.77 64.16,106.46 65.72,106.46 68.96,107.04 70.74,108.81 71.02,109.09 71.51,110.55 71.51,112.16 72.08,112.72 72.43,112.72 73.67,113.96 75.45,114.89 87.44,114.89 87.69,115.14 87.69,115.36 v2(87.9,115.56)
  BOTTOM w0.102: v2(87.9,115.56) 87.43,115.1 U18.AY2
  BOTTOM w0.114: v1(27.86,23.08) 27.6,22.81 27.6,22.66 27.71,22.55 28.94,22.55 29.72,21.77 30.7,21.77 32.76,19.72 32.76,19.71 36.22,10.95 36.22,10.57 C742.2
SATA_TXP1_C: length 2.5
  BOTTOM w0.114: CN12.19 35.92,8.05 35.78,8.19 35.78,8.59 36.02,8.83 36.02,9.1 C742.1
SATALED#: length 235.7
  TOP w0.114: v1(95.77,22.59) 96.2,23.02 98.7,23.02 100.47,21.25 v1(103.34,21.25) 105.33,21.25 108.44,18.14 110.43,18.14 111.06,17.51 112.84,17.51 113.19,17.86 113.19,18.2 114.05,19.06 126.13,19.06 128.38,21.3 130.97,21.3 132.39,19.89 157.87,19.89 159.2,18.56 179.96,18.56 184.8,13.72 188.96,13.72 195.24,7.45 v1(196.1,7.45) ; Q16.5 199.68,17.81 199.85,17.98 200.2,17.98 200.33,17.85 Q16.6 200.33,15.5 R239.1 R238.2 198.75,15.48 v1(198.13,16.11)
  BOTTOM w0.102: U18.BB15 88.92,105 89.22,104.7 89.48,104.7 89.68,104.9 93.9,104.9 94.33,105.32 97.67,105.32 98.93,104.07 99.3,104.07
  BOTTOM w0.114: v1(95.77,22.59) 95.77,33.54 103.98,41.75 106.09,41.75 107.11,42.77 107.11,42.77 107.3,42.96 107.3,46.8 109.23,48.73 109.23,50.85 107.46,52.62 107.46,57.61 108.47,58.62 108.47,73.1 105.76,75.81 105.76,91.18 108.38,93.8 108.38,98.85 103.46,103.77 102.93,103.77 102.93,103.77 102.57,103.77 102.2,103.4 100.59,103.4 99.93,104.07 99.3,104.07 ; v1(198.13,16.11) 196.92,14.9 196.92,11.78 196.89,11.74 196.89,8.24 v1(196.1,7.45)
SCL: length 15
  TOP w0.114: R688.1 120.78,106.59 121.23,106.59 122.13,105.68 v1(122.47,105.68) 124.61,105.68 128.16,102.14 131.86,102.14 v2(132.29,101.71)
  BOTTOM w0.127: U22.AC35 132.75,101.26 v2(132.29,101.71)
SD_CD#: length 20.4
  BOTTOM w0.114: JCARD1.4 v1(258.83,23.94) 257.21,23.94 256.01,22.74 254.62,22.74 254.5,22.61 254.5,22.37 254.62,22.24 256.01,22.24 256.13,22.13 256.13,21.86 256.01,21.75 254.87,21.75 254.75,21.62 254.75,21.38 254.87,21.25 256.01,21.25 256.13,21.14 256.13,20.87 256.01,20.76 254.85,20.76 254.72,20.63 254.72,20.39 254.85,20.26 256.01,20.26 256.13,20.15 256.13,19.88 256.01,19.77 255.36,19.77 255.25,19.65 255.25,19.39 255.36,19.27 256.01,19.27 256.13,19.16 256.13,17.29 256.07,17.23 U28.13
SD_CLK: length 16.5
  IN4 w0.089: v1(258.79,16.17) 257.91,16.17 257.69,16.39 257.69,16.61 257.78,16.7 258.5,16.7 258.63,16.83 258.63,17.04 258.5,17.17 257.78,17.17 257.69,17.26 257.69,17.55 257.78,17.64 258.35,17.64 258.48,17.77 258.48,17.98 258.35,18.11 257.78,18.11 257.69,18.2 257.69,18.49 257.78,18.58 258.31,18.58 258.4,18.67 258.4,18.96 258.31,19.05 257.78,19.05 257.69,19.14 257.69,20.81 257.81,20.93 258.71,20.93 258.83,20.81 258.83,19.21 259.73,18.32 JCARD1.7
  BOTTOM w0.114: R1036.1 C1236.2 258.59,16.1 258.72,16.1 v1(258.79,16.17)
SD_CLK_R: length 3.1
  BOTTOM w0.114: R1036.2 257.97,17.34 257.67,17.05 257.67,16.91 256.99,16.23 U28.15
SD_CMD: length 20.4
  IN1 w0.089: v1(256.51,14.73) 256.12,15.12 256.12,22.92 256.74,23.54 256.74,23.67 256.14,24.26 256.14,24.39 256.35,24.6 256.47,24.6 257.07,24 257.19,24 257.4,24.21 257.4,24.33 256.81,24.93 256.81,25.05 257.01,25.26 257.14,25.26 257.73,24.66 257.86,24.66 258.07,24.87 258.07,25 257.47,25.59 257.47,25.72 257.68,25.93 257.8,25.93 258.4,25.33 258.52,25.33 259.01,25.82 JCARD1.3
  BOTTOM w0.114: U28.18 v1(256.51,14.73)
SD_D0: length 21
  IN4 w0.089: JCARD1.9 257.1,13.4 255.86,14.64 255.86,17.62 254.77,18.71 254.77,18.84 255.14,19.21 255.14,19.39 254.99,19.54 254.81,19.54 254.44,19.17 254.31,19.17 254.11,19.38 254.11,19.5 254.49,19.88 254.49,20.06 254.33,20.21 254.15,20.21 253.77,19.84 253.65,19.84 253.44,20.04 253.44,20.17 253.85,20.58 253.85,20.76 253.7,20.91 253.52,20.91 253.11,20.5 252.98,20.5 252.79,20.7 v1(252.16,20.7)
  BOTTOM w0.114: v1(252.16,20.7) 253.22,20.7 254.18,19.74 U28.11
SD_D1: length 21.4
  IN4 w0.089: JCARD1.10 259.17,11.65 259.01,11.81 259.01,12.76 258.92,12.85 258.62,12.85 258.54,12.76 258.54,11.46 258.41,11.33 258.19,11.33 258.07,11.46 258.07,12.76 257.98,12.85 257.68,12.85 257.6,12.76 257.6,12.04 257.5,11.95 257.24,11.95 255.47,13.73 255.47,17.38 252.91,19.94 v1(252.19,19.94)
  BOTTOM w0.114: v1(252.19,19.94) 253.15,19.94 253.68,19.41 U28.10
SD_D2: length 21.5
  IN1 w0.089: JCARD1.1 255.23,25.59 255.23,14.44 v1(253.77,12.98)
  BOTTOM w0.114: v1(253.77,12.98) 253.68,13.07 U28.21
SD_D3: length 20.3
  IN1 w0.089: JCARD1.2 258.51,28.32 255.62,25.43 255.62,13.88 v1(254.57,12.83)
  BOTTOM w0.114: v1(254.57,12.83) 254.18,13.22 U28.20
SD_D4: length 2.1
  BOTTOM w0.114: U28.19 254.68,13.34 TP267.1
SD_D5: length 1.3
  BOTTOM w0.114: TP266.1 256.85,15.73 U28.16
SD_D6: length 2.3
  BOTTOM w0.114: TP265.1 256.56,17.37 256.56,17.13 256.17,16.73 U28.14
SD_D7: length 1.3
  BOTTOM w0.114: U28.12 254.68,19.01 254.7,19.03 TP264.1
SD_WP: length 21.4
  IN4 w0.089: v1(252.2,19.2) 252.73,19.2 254.82,17.1 254.82,13.8 256.3,12.32 256.3,12.19 255.81,11.7 255.81,11.57 256.01,11.36 256.14,11.36 256.63,11.86 256.76,11.86 256.97,11.65 256.97,11.53 256.47,11.03 256.47,10.91 256.68,10.7 256.8,10.7 257.3,11.19 257.42,11.19 257.63,10.99 257.63,10.86 257.14,10.37 257.14,10.24 257.34,10.03 257.47,10.03 257.96,10.53 258.09,10.53 258.3,10.32 258.3,10.2 257.8,9.7 257.8,9.58 258.01,9.37 258.13,9.37 258.35,9.59 JCARD1.11
  BOTTOM w0.114: U28.8 252.68,18.72 v1(252.2,19.2)
SDA: length 15.2
  TOP w0.114: v2(133.03,101.67) 132.62,101.26 128.62,101.26 125.74,104.14 125.33,104.55 120.8,104.55 R690.1
  BOTTOM w0.127: v2(133.03,101.67) 133.55,101.15 U22.AC34
SDREG: length 4.3
  BOTTOM w0.305: U28.6 251.01,17.23 250.61,17.63
  BOTTOM w0.508: C1135.2 v1(250.51,19.89) 250.91,19.49 250.91,18.14 250.61,17.84 250.61,17.63
SEN_A0: length 1.6
  TOP w0.152: R780.1 130.84,133.74 130.79,133.79 v1(130.35,133.79)
  BOTTOM w0.152: VRAM1.J10 129.98,133.42 v1(130.35,133.79)
SEN_A1: length 1.9
  TOP w0.152: R781.1 150.96,133.89 151.64,133.21 v1(151.82,133.21)
  BOTTOM w0.152: v1(151.82,133.21) 152.13,133.21 152.37,133.44 VRAM2.J10
SEN_B0: length 3.9
  TOP w0.152: v1(171.84,113.29) 171.84,112.72 R782.1
  BOTTOM w0.152: v1(171.84,113.29) 171.35,112.79 170.7,112.79 170.49,113 170.49,113.51 VRAM3.J10
SEN_B1: length 5.6
  TOP w0.152: R783.1 173.27,92.87 v1(172.9,92.5) 172.9,92.17 v1(172.05,91.32)
  BOTTOM w0.152: v1(172.05,91.32) 172.31,91.06 172.31,90.01 172.06,89.75 171.75,89.75 171.36,90.15 VRAM4.J10
SENSOR_HUB_INT1#: length 4
  TOP w0.114: R1011.2 v1(86.96,103.25) 86.47,103.25 86.02,103.7 v2(86.02,104.03)
  BOTTOM w0.114: v2(86.02,104.03) 86.02,104.47 U18.AW15
SERIRQ: length 216.2
  TOP w0.114: v1(219.32,22.64) 219.34,22.61 U34.5
  IN1 w0.089: v1(94.28,107.24) 94.69,106.83 95.19,106.83 95.4,106.62 95.4,104.22 96.17,103.45 96.46,103.45 98.17,101.74 98.17,101.05 98.95,100.27 98.95,97.01 104.97,90.99 104.97,88.22 109.15,84.03 109.15,68.15 109.39,67.92 109.39,37.72 108.5,36.83 v1(108.5,29.6)
  IN4 w0.089: v1(108.5,29.6) 109.2,28.89 109.2,26.65 112.69,23.16 117.75,23.16 119.42,21.49 133.01,21.49 133.56,20.94 139.23,20.94 139.83,21.54 147.77,21.54 148.9,22.67 166.27,22.67 166.88,22.05 174.79,22.05 180.92,15.91 190.11,15.91 194.07,19.87 194.07,21.16 197.21,24.31 215.48,24.31 216.69,23.09 218.86,23.09 v1(219.32,22.64)
  BOTTOM w0.102: U18.BC14 88.99,105.84 92.1,105.84 92.37,106.11
  BOTTOM w0.114: v1(94.28,107.24) 93.5,107.24 92.37,106.11
SI_SS_SEL: length 2.6
  BOTTOM w0.114: R765.1 R766.2 120,82.41 119.99,82.4 U27.5
SI_VDD: length 3.3
  BOTTOM w0.114: U27.1 118.18,82 118.42,81.76 118.42,81.56 118.34,81.49 117.74,81.49 117.62,81.37 v1(117.62,80.88) 117.62,80.88 R763.1
SI_XTALIN: length 8.6
  BOTTOM w0.114: U27.2 117.03,82.4 116.78,82.15 116.78,81.52 C978.1 R762.1 v1(115.13,82.01) 114.36,82.78 113.34,82.78 Y6.1
SI_XTALOUT: length 5.8
  BOTTOM w0.114: U27.3 117.13,82.8 C977.1 R762.2 115.36,82.79 v1(114.89,83.26) 114.75,83.41 114.18,83.41 Y6.3
SIO_A20GATE: length 210
  TOP w0.114: D46.2 215.24,28.8 v1(211.18,24.74)
  IN1 w0.089: v1(211.18,24.74) 210.2,23.76 186.17,23.76 185.05,24.89 174.22,24.89 173.21,25.9 169.57,25.9 168.22,27.25 151.2,27.25 149.57,25.62 147.48,25.62 146.44,24.59 140.58,24.59 140.13,25.04 137.91,25.04 137.29,24.41 130.25,24.41 129.16,25.51 125.03,25.51 124.6,25.94 119.16,25.94 118.79,26.31 118.79,28.35 118.45,28.7 113.13,28.7 113.07,28.63 111.72,28.63 109.97,26.88 106.72,26.88 105.54,28.06 105.54,36.95 108.99,40.41 108.99,67.76 108.76,67.99 108.76,83.87 104.57,88.06 104.57,90.82 98.55,96.84 98.55,100.11 97.57,101.09 v1(97.57,101.62)
  BOTTOM w0.102: U18.BC19 89.83,102.28 90.55,102.28 90.78,102.52 93.2,102.52 93.6,102.11 93.84,102.11 94.53,101.43 95.23,101.43 R965.1 95.56,100.83 95.87,100.51 97.04,100.51 97.3,100.77 v1(97.3,101.07) 97.3,101.34 v1(97.57,101.62)
SIO_A20GATE_R: length 7.5
  TOP w0.114: D46.1 219.59,28.8 220.17,28.22 v1(220.17,27.44) 220.17,26.93 222.17,24.93 223.05,24.93 223.17,25.05 U34.126
SIO_EXT_SCI#: length 246.3
  TOP w0.114: D29.2 v1(214.41,14.89)
  IN1 w0.089: v1(214.41,14.89) 219.29,14.89 219.67,15.27 219.67,20.4 215.96,24.11 213.6,24.11 212.3,25.41 210.91,25.41 209.71,24.22 186.36,24.22 185.24,25.34 174.41,25.34 173.4,26.36 169.76,26.36 168.41,27.71 151.01,27.71 149.38,26.08 147.29,26.08 146.25,25.04 140.77,25.04 140.32,25.49 137.72,25.49 137.1,24.87 130.44,24.87 129.35,25.96 128.19,25.96 125.4,28.75 121.64,28.75 120.35,30.04 117.57,30.04 116.69,29.15 113.71,29.15 111.67,31.19 111.67,32.57 113.1,34 113.1,44.58 112.15,45.53 112.15,69.06 111.91,69.3 111.91,77.64 114.9,80.62 114.9,84.49 111.82,87.56 111.82,88.09 108.5,91.42 108.5,95.19 104.72,98.97 104.72,102.21 102.9,104.03 100.87,104.03 99.99,104.91 99.99,107.24 99.7,107.52 99.07,107.52 98.5,107.52 95.84,110.18 91.88,110.18 91.28,109.58 90.43,109.58 89,108.15 87.24,108.15 86.93,107.84 86.93,107.29 86.58,106.94 82.33,106.94 81.93,107.35 81.93,107.8 81.73,108 80.02,108 79.56,107.54 77.72,107.54 77.36,107.9 77.36,108.29 76.8,108.85 75.97,108.85 74.61,110.2 74.61,110.52 v2(74.02,111.12)
  BOTTOM w0.114: v2(74.02,111.12) 73.65,111.49 U18.AD7
SIO_SLP_S3#: length 445.9
  TOP w0.114: v1(224.04,24.56) 223.97,24.63 U34.124
  IN1 w0.089: v1(29.73,74.45) 29.73,73.98 28.62,72.87 28.62,67.81 26.61,65.8 26.61,50.24 26.19,49.82 26.19,48.09 v1(26.72,47.57) 26.19,47.04 26.19,42.29 29.07,39.41 29.07,33.7 31.93,30.84 31.93,29.1 36.44,24.59 37.56,24.59 38.27,23.89 38.27,20.25 40,18.52 41.85,18.52 43.02,17.35 48.96,17.35 54.64,23.02 97.55,23.02 102.48,18.1 106.43,18.1 109.48,15.05 112.56,15.05 114,13.61 116.58,13.61 v1(117.03,13.16) ; v1(224.04,24.56) 223.49,24.01 218.41,24.01 217.94,24.48 213.55,24.48 212.39,25.64 210.81,25.64 209.85,24.67 186.23,24.67 185.33,25.57 174.51,25.57 173.29,26.79 v1(171.36,26.79) 169.97,26.79 168.58,28.18 151.16,28.18 150.01,27.03 149.29,26.31 147.19,26.31 146.16,25.27 141.27,25.27 139.99,26.55 v1(139.37,26.55) 138.46,26.55 137.01,25.1 130.56,25.1 126.68,28.98 121.73,28.98 120.45,30.27 117.39,30.27 116.71,29.59 v1(114.49,29.59) 114.07,30.01 114.07,31.67 113.56,32.19 113.56,46.96 112.83,47.69 112.83,69.35 113.44,69.96 113.44,78.18 115.58,80.32 115.58,84.77 112.51,87.84 112.51,88.42 109.19,91.75 109.19,95.47 105.4,99.25 105.4,102.5 103.19,104.71 101.16,104.71 100.67,105.2 100.67,107.52 99.99,108.21 98.79,108.21 96.13,110.87 92.26,110.87 91.84,111.29 89.91,111.29 88.6,109.98 87.3,109.98 86.66,109.34 83.15,109.34 82.72,108.92 79.65,108.92 79.26,109.3 79.26,111.58 v2(78.87,111.97)
  BOTTOM w0.102: v2(78.87,111.97) 78.45,111.55 U18.AK7
  BOTTOM w0.114: PR480.1 21.88,48.02 v1(22.05,48.19) 22.34,48.48 25.81,48.48 v1(26.72,47.57) ; R1049.2 223.6,25 v1(224.04,24.56) ; v1(139.37,26.55) 138.9,27.02 138.9,31.66 138.5,32.06 136.91,32.06 136.5,31.65 PR505.2 ; PR499.2 170.43,22.62 170.66,22.39 172.02,22.39 172.28,22.65 172.28,24.45 171.36,25.37 v1(171.36,26.79) ; v1(29.73,74.45) 29.17,75.01 29.17,76.21 PR503.2 ; v1(114.49,29.59) 114.49,27.12 114.88,26.73 114.88,24.71 114.63,24.46 113.34,24.46 112.24,23.36 112.24,20.79 115.01,18.02 115.01,16.3 115.99,15.31 115.99,14.2 v1(117.03,13.16) 117.03,14.97 118.3,16.24 120.66,16.24 121.13,16.72 121.13,18.09 125.01,21.97 127.07,21.97 PR500.2
SIO_SLP_S5#: length 367.4
  TOP w0.114: U34.118 v1(226.37,24.67)
  IN1 w0.089: v1(113.14,30.64) 112.28,31.49 112.28,32.86 113.33,33.9 113.33,44.67 112.38,45.62 112.38,69.15 112.14,69.39 112.14,77.53 115.13,80.52 115.13,84.58 112.05,87.65 112.05,88.19 108.73,91.52 108.73,95.28 104.95,99.06 104.95,102.31 103,104.26 100.97,104.26 100.22,105.01 100.22,107.33 99.8,107.75 98.98,107.75 98.6,107.75 95.94,110.41 92.07,110.41 91.65,110.83 91.02,110.83 90.77,110.57 90.76,110.57 88.79,108.6 85.47,108.6 85.05,108.18 83.33,108.18 83.06,108.46 77.98,108.46 77.18,109.26 77.18,112.47 77.69,112.98 v2(77.93,112.98)
  IN4 w0.089: v1(226.37,24.67) 224.92,26.11 219.91,26.11 219.05,25.25 212.68,25.25 212.35,25.58 210.3,25.58 209.81,25.09 200.94,25.09 200.35,25.69 193.87,25.69 193.27,25.09 186.05,25.09 183.8,22.84 173.03,22.84 171.82,24.05 159.64,24.05 159.17,23.58 148.7,23.58 147.44,22.32 139.5,22.32 138.91,21.73 133.88,21.73 133.34,22.27 126.76,22.27 126.19,22.85 125.31,22.85 123.79,24.37 122.16,24.37 121.2,25.33 118.58,25.33 117.84,24.59 117.11,24.59 116.73,24.97 116.73,26.14 115.74,27.13 114.78,27.13 113.12,28.8 113.12,30.62 v1(113.14,30.64) 111.65,30.64 109.98,32.3 103.19,32.3 99.39,28.49 51.05,28.49 49.03,26.47 42.3,26.47 41.58,27.19 35.71,27.19 26.28,36.62 26.28,47.92 v1(26.63,48.28)
  BOTTOM w0.102: U18.AH5 77.48,113.1 77.6,112.98 v2(77.93,112.98)
  BOTTOM w0.114: PR481.1 15.57,50.89 15.57,50.07 16.92,48.72 26.19,48.72 26.63,48.28 v1(26.63,48.28) 27.75,48.28 29.05,46.98 v1(29.05,46) 29.05,44.84 29.39,44.5 D52.1
SL_CLK_100M: length 4
  BOTTOM w0.114: R764.2 122.2,83.04 120.16,83.04 119.92,82.8 U27.4
SMB_ALW_CLK: length 6.2
  TOP w0.114: R532.2 74.25,116.09 74.77,115.57 75.22,115.57 v1(75.53,115.27) 76.13,114.67 76.13,113.6 76.84,112.89 v2(76.84,112.71)
  BOTTOM w0.114: U18.AG5 76.45,113.1 v2(76.84,112.71)
SMB_ALW_DAT: length 4
  TOP w0.102: v1(76.55,114.13) 76.55,113.8 76.72,113.63
  TOP w0.114: v1(76.55,114.13) 76.55,114.93 75.68,115.79 75.24,115.79 R533.2 ; v2(76.79,113.56) 76.72,113.63
  BOTTOM w0.102: v2(76.79,113.56) 76.45,113.9 U18.AG4
SMB_RUN_CLK: length 73.8
  IN1 w0.089: v1(104.55,55.43) 105.26,56.14 105.26,56.38 108.21,59.33 108.21,62.68 v1(107.15,63.73) 107.97,64.56 107.97,83.54 103.79,87.73 103.79,90.5 97.77,96.52 97.77,99.78 94.27,103.27 v1(94.27,104.07)
  BOTTOM w0.102: v1(94.27,104.07) 94.27,104.2 v1(94.76,104.68) 95.36,104.68 R524.2 95.32,105.12 94.41,105.12 93.98,104.69 89.76,104.69 89.56,104.49 89.14,104.49 88.99,104.64 88.47,104.64 88.12,105 U18.BA15
  BOTTOM w0.114: CN16.253 104.23,54.2 104.78,54.75 104.78,55.21 v1(104.55,55.43) ; v1(107.15,63.73) 104.81,63.73 104.23,64.32 CN17.253
SMB_RUN_DAT: length 81.1
  TOP w0.114: v1(104.84,46.54) 104.16,47.21 104.16,51.94 104.03,52.08 104.03,54.71 v1(104.2,54.88)
  IN1 w0.089: v1(104.2,54.88) 104.63,54.88 105.65,55.91 105.65,56.22 108.6,59.17 108.6,67.59 108.37,67.83 108.37,83.71 104.18,87.89 104.18,90.66 98.16,96.68 98.16,99.94 94.93,103.17 v1(94.93,104.07)
  BOTTOM w0.102: 90.02,103.79 89.71,103.79 89.6,103.91 89.09,103.91 89.06,103.88 88.76,103.88 88.45,104.18 88.45,104.33 88.25,104.53 88.02,104.53 87.85,104.35 87.85,103.94 87.3,103.4 U18.AY17 ; R525.2 95.13,103.87 v1(94.93,104.07)
  BOTTOM w0.114: v1(104.2,54.88) 103.93,55.15 103.93,56.08 104.48,56.62 CN17.254 ; v1(104.84,46.54) 104.84,46.18 104.48,45.82 CN16.254 ; 90.02,103.79 90.21,103.99 93.77,103.99 94.1,103.65 95.35,103.65 R525.2
SMBCLK0: length 203.2
  TOP w0.114: U34.110 229.57,27.42 230.56,28.42 R863.2 230.51,28.86 230.51,29.45 v1(231.12,30.06)
  IN4 w0.089: v1(64.79,17.56) 66.21,18.98 77.53,18.98 78.07,18.44 98.13,18.44 99.4,19.71 107.93,19.71 109.12,18.51 111.22,18.51 v1(111.76,17.98) 112.23,17.51 112.85,17.51 113.19,17.85 113.19,18.17 113.69,18.67 123.62,18.67 124.17,18.12 140.4,18.12 141,18.72 154.95,18.72 155.46,19.23 173.62,19.23 179.76,13.09 191.28,13.09 196.89,18.7 196.89,19.99 198.27,21.37 202.25,21.37 204.41,19.21 210.36,19.21 212.15,21 217.08,21 218.97,19.11 219.97,19.11 222.23,21.37 226.72,21.37 229.78,24.43 229.78,27.47 230.85,28.54 230.85,29.79 v1(231.12,30.06)
  BOTTOM w0.114: v1(111.76,17.98) 112.83,16.9 112.83,14.22 113.59,13.46 ESD1.6 113.59,11.31 PR223.2 ; PR200.1 65.64,14.36 65.64,15.44 65.29,15.79 v1(65.29,16.21) 65.29,17.06 v1(64.79,17.56)
SMBCLK0_B: length 3.5
  BOTTOM w0.114: JBAT1.8 113.1,8.74 113.14,8.78 v1(113.14,9.15) PR223.1
SMBCLK0_P: length 3
  BOTTOM w0.114: PR200.2 66.42,14.36 67.2,13.57 67.2,12.52 67.48,12.24 PU15.12
SMBCLK1: length 277.4
  TOP w0.114: Q33.3 40.97,101.77 41.75,101 42.53,101 42.71,100.82 42.71,99.32 42.28,98.89 42.28,97.26 42.48,97.06 42.48,71.71 36.42,65.66 36.42,59.06 37.26,58.22 37.26,51.9 36.47,51.11 36.47,47.83 42.19,42.11 55.72,42.11 61.38,36.45 68.03,36.45 68.84,35.64 90.95,35.64 v1(91.39,35.21) ; U34.115 227.57,26.86 v1(227.2,27.22) 226.76,27.67 R865.2 226.51,28.42 226.09,28.84 226.09,29.63 225.54,30.18 v1(225.54,30.46)
  IN4 w0.089: v1(225.54,30.46) 225.54,28.23 224.27,26.96 216.03,26.96 212.37,30.62 197.48,30.62 192.58,25.72 185.27,25.72 183.02,23.46 173.53,23.46 172.23,24.76 155.9,24.76 155.69,24.98 153.31,24.98 152.53,24.2 148.44,24.2 147.18,22.95 139.24,22.95 138.65,22.35 134.14,22.35 133.55,22.94 126.98,22.94 126.4,23.52 125.52,23.52 124.05,24.99 122.95,24.99 122.14,25.81 122.14,26.75 120.72,28.17 120.72,29.04 120.02,29.74 117.91,29.74 116.94,30.71 116.94,31.92 110.91,37.95 95.26,37.95 92.52,35.21 v1(91.39,35.21)
SMBCLK3: length 368.9
  TOP w0.114: U34.94 237.19,23.41 237.37,23.23 238.25,23.23 R867.2 238.56,23.95 238.77,24.16 240.3,24.16 240.81,24.67 240.81,30.47 236.44,34.84 199.66,34.84 v1(197.59,36.91) ; v1(116.12,31.96) 116.81,32.66 117.64,32.66 119.77,34.79 119.77,38.26 123.12,41.6 123.12,47.4 v1(123.1,47.42) 122.77,47.75 122.77,49.17 123.53,49.93 123.53,52.57 122.84,53.26 122.84,55.73 121.3,57.27 121.3,70.99 123.89,73.58 123.89,84.24 124.46,84.81 v1(125.34,84.81)
  IN1 w0.089: v1(123.1,47.42) 123.1,44.2 124.7,42.6 128.1,42.6 130.71,39.98 144.22,39.98 148.08,36.12 149.88,36.12 151.78,38.03 160.59,38.03 164.97,42.41 177.03,42.41 180.79,38.64 186.13,38.64 188.68,36.09 196.76,36.09 v1(197.59,36.91)
  IN3 w0.127: v1(42.23,105.2) 41.87,105.2 40.68,104.01 40.68,97.88 40.04,97.24 40.04,93.23 36.37,89.56 35.81,89.56 32.92,86.67 32.92,78.31 31.87,77.26 31.87,74.07 32.76,73.18 32.76,70.9 v1(33.2,70.46)
  IN4 w0.089: v1(33.2,70.46) 32.77,70.03 32.77,69.39 32.91,69.25 32.91,42.56 33.23,42.24 33.83,42.24 34.05,42.45 35.4,42.45 36.33,41.52 36.33,37.63 38.73,35.23 62.08,35.23 65.05,32.26 94.37,32.26 98.57,36.46 104.18,36.46 105.95,34.69 112.92,34.69 115.65,31.96 v1(116.12,31.96)
  BOTTOM w0.114: Q40.6 125.74,85.21 v1(125.34,84.81) ; U9.8 v1(42.52,105.95) 42.52,105.5 v1(42.23,105.2)
SMBDAT0: length 204.6
  TOP w0.114: U34.111 229.17,27.78 R864.2 230.26,28.88 230.26,29.83 v1(230.47,30.03)
  IN4 w0.089: v1(64.11,17.59) 66.47,19.94 108.02,19.94 109.22,18.74 111.8,18.74 v1(112.58,17.96) 113.51,18.9 123.72,18.9 124.26,18.35 140.31,18.35 140.9,18.94 154.85,18.94 155.37,19.46 173.71,19.46 179.85,13.32 191.19,13.32 196.66,18.79 196.66,20.09 198.18,21.6 202.7,21.6 204.87,19.44 210.26,19.44 212.06,21.23 217.17,21.23 219.07,19.34 219.87,19.34 222.13,21.6 226.63,21.6 229.55,24.53 229.55,27.57 230.62,28.64 230.62,29.89 v1(230.47,30.03)
  BOTTOM w0.114: v1(64.11,17.59) v1(64.11,16.77) 64.11,16.61 65.17,15.55 65.17,13.76 65.56,13.37 PR211.1 ; PR224.2 115.49,11.71 ESD1.4 115.49,13.06 114.97,13.58 113.84,13.58 113.07,14.35 113.07,17.47 v1(112.58,17.96)
SMBDAT0_B: length 3.5
  BOTTOM w0.114: JBAT1.7 114.6,8.73 114.64,8.78 v1(114.64,9.17) PR224.1
SMBDAT0_P: length 2.5
  BOTTOM w0.114: PR211.2 66.42,13.36 66.92,12.86 66.92,12.33 67.41,11.84 PU15.11
SMBDAT1: length 274.9
  TOP w0.114: U34.116 227.17,26.67 226.73,27.11 226.37,27.11 v1(225.81,27.66) 225.06,28.42 R866.2 225.43,28.42 225.67,28.66 225.67,29.45 v1(224.97,30.15) ; v1(90.73,35.21) 68.68,35.21 67.88,36.01 61.23,36.01 55.56,41.68 42.03,41.68 36.06,47.66 36.06,51.29 36.84,52.08 36.84,58.04 36.01,58.88 36.01,65.83 42.06,71.88 42.06,96.89 41.85,97.1 41.85,99.09 42.27,99.51 Q33.6
  IN4 w0.089: v1(90.73,35.21) 91.17,35.64 92.4,35.64 95.1,38.35 111.07,38.35 117.85,31.57 117.85,30.43 118.15,30.13 120.18,30.13 121.11,29.2 121.11,28.33 122.53,26.91 122.53,25.97 122.64,25.87 124.59,25.87 125.26,25.2 125.26,24.34 125.69,23.91 126.57,23.91 127.14,23.33 133.71,23.33 134.3,22.74 138.48,22.74 139.08,23.34 147.02,23.34 148.28,24.6 152.37,24.6 153.15,25.37 155.85,25.37 156.07,25.16 172.4,25.16 173.69,23.87 182.87,23.87 185.11,26.11 192.41,26.11 197.32,31.02 212.53,31.02 216.19,27.35 224.11,27.35 225.15,28.4 225.15,29.98 v1(224.97,30.15)
SMBDAT3: length 370.9
  TOP w0.114: v1(196.94,36.9) 199.41,34.42 236.27,34.42 240.39,30.3 240.39,24.85 240.12,24.58 238.96,24.58 238.56,24.98 R868.2 238.53,25.2 v1(237.79,24.46) 237.15,23.81 U34.95 ; v1(115.74,31.43) 116.21,31.43 117.01,32.24 117.82,32.24 120.19,34.61 120.19,38.08 123.54,41.43 123.54,47.98 v1(123.33,48.19) 123.95,48.81 123.95,52.74 123.26,53.43 123.26,55.91 121.72,57.45 121.72,70.82 124.31,73.41 124.31,84.04 v1(124.45,84.17)
  IN1 w0.089: v1(123.33,48.19) 123.54,47.98 123.54,44.32 124.87,42.99 128.26,42.99 130.88,40.38 144.38,40.38 148.25,36.51 149.71,36.51 151.62,38.42 160.42,38.42 164.81,42.8 177.19,42.8 180.96,39.04 186.29,39.04 188.84,36.49 196.53,36.49 v1(196.94,36.9)
  IN3 w0.127: v1(42.25,104.55) 41.83,104.55 41.11,103.83 41.11,97.7 40.47,97.06 40.47,93.05 36.55,89.13 35.99,89.13 33.35,86.49 33.35,78.13 32.3,77.08 32.3,74.25 33.22,73.33 v1(33.22,71.23)
  IN4 w0.089: v1(115.74,31.43) 115.6,31.43 113.48,33.55 112.74,34.3 105.79,34.3 104.02,36.06 98.76,36.06 94.56,31.86 64.89,31.86 61.92,34.83 38.57,34.83 35.94,37.47 35.94,41.36 35.24,42.06 34.21,42.06 34,41.85 33.07,41.85 32.52,42.4 32.52,69.08 32.38,69.23 32.38,70.39 v1(33.22,71.23)
  BOTTOM w0.114: v1(42.25,104.55) 43.17,105.47 U9.7 ; Q40.3 127.49,83.91 127.07,83.49 125.12,83.49 v1(124.45,84.17)
SMC_EXT_SMI#: length 234.4
  TOP w0.114: v2(79.11,113.13) 79.11,113.86 79.26,114.02 79.26,115.11 R1107.2 ; D28.2 v1(214.29,19.16)
  IN1 w0.089: v2(79.11,113.13) 79.74,112.49 79.74,109.53 79.9,109.37 81.03,109.37 82.11,110.45 83.86,110.45 83.86,110.44 85.27,110.44 85.47,110.64 86.57,110.64 86.77,110.44 88.32,110.44 89.63,111.74 92.37,111.74 92.79,111.33 96.32,111.33 96.66,110.98 97.6,110.04 99.12,110.04 101.8,107.36 v1(101.8,106.71) ; v1(112.41,29.07) 112.77,29.07 112.92,28.93 116.78,28.93 117.67,29.81 120.26,29.81 121.54,28.52 125.31,28.52 128.09,25.74 129.26,25.74 130.35,24.64 137.19,24.64 137.82,25.27 140.22,25.27 140.67,24.81 146.35,24.81 147.38,25.85 149.48,25.85 151.11,27.48 168.31,27.48 169.66,26.13 173.31,26.13 174.32,25.12 185.14,25.12 186.27,23.99 209.81,23.99 211,25.18 212.21,25.18 213.53,23.86 214.1,23.86 215.08,22.88 215.08,19.94 v1(214.29,19.16)
  BOTTOM w0.102: v2(79.11,113.13) 78.8,113.13 78.78,113.1 U18.AK5
  BOTTOM w0.114: v1(112.41,29.07) 111.95,29.53 111.95,41.24 v1(111.65,41.54) 110.38,42.81 110.38,47 113.08,49.7 113.08,52.95 112.76,53.27 112.76,55.28 109.93,58.11 109.93,73.06 106.73,76.26 106.73,90.78 109.35,93.4 109.35,99.65 102.29,106.71 v1(101.8,106.71)
SSD_LED#: length 17.6
  TOP w0.114: v1(192.26,27.37) 192.26,27.36 192.26,21.07 198.05,15.28 v1(198.34,15.28) 198.62,15.28 R238.1
  BOTTOM w0.114: v1(192.26,27.37) 192.26,27.68 192.01,27.92 CON1.10
SUB_MUTE#: length 226.9
  TOP w0.114: CN5.26 22.97,11.8 v1(23.12,11.65) ; U34.108 v1(230.37,24.69)
  IN4 w0.089: v1(23.12,11.65) 23.66,12.19 24.89,12.19 25.98,13.28 27.28,13.28 27.62,13.62 30.93,13.62 32.21,14.9 49.82,14.9 51.98,17.06 75.78,17.06 76.7,17.98 98.32,17.98 99.59,19.25 107.74,19.25 108.93,18.06 110.39,18.06 110.6,17.85 110.93,17.85 111.73,17.05 113.85,17.05 114.08,17.28 114.08,18.14 114.38,18.44 123.53,18.44 124.07,17.89 140.5,17.89 141.09,18.49 155.04,18.49 155.56,19 173.52,19 179.66,12.87 191.38,12.87 197.12,18.6 197.12,19.9 198.36,21.14 201.61,21.14 203.78,18.98 210.45,18.98 212.25,20.78 216.98,20.78 218.88,18.88 220.06,18.88 222.32,21.14 226.82,21.14 v1(230.37,24.69)
SUS_ON: length 463.7
  TOP w0.114: v1(29.91,72.52) 29.91,73.51 v1(29.93,73.54) 30.39,73.99 30.39,75.13 32.66,77.41 32.66,84.8 29.65,87.81 29.65,96.1 30.12,96.57 30.12,108.39 32.91,111.18 v1(34.04,111.18) ; U34.100 233.57,26.9 235.07,28.41 v1(235.07,32.08) ; PR511.2 141.62,41.03 131.47,41.03 130.1,42.4 125.92,42.4 125.25,43.07 125.25,45.55 v1(125.58,45.89) ; v1(128.56,24.43) 129.46,25.33 137.23,25.33 139.31,23.24 159.6,23.24 159.8,23.04 166.42,23.04 167.08,22.38 169.79,22.38 170.75,23.33 171.34,23.33 v1(171.84,22.83) 179.69,22.83 184.54,17.98 189.03,17.98 195.57,11.43 197.18,11.43 v1(197.33,11.58)
  IN3 w0.127: v1(29.91,72.52) 30.28,72.14 30.28,68.71 29.76,68.19 28.83,68.19 27.69,67.05 27.69,42 28.17,41.52 28.17,31.46 24.28,27.58 16.4,27.58 11.81,22.99 10.61,22.99 8.78,21.16 8.78,10.68 9.51,9.95 10.91,9.95 11.74,10.78 12.4,10.78 12.78,10.41 12.78,7.22 13.64,6.36 24.86,6.36 26.18,7.68 38.49,7.68 52.12,21.3 52.12,22.39 54.05,24.33 54.05,27.73 56.89,30.57 60.64,30.57 61.37,31.29 93.89,31.29 96.21,33.61 110.55,33.61 115.72,38.79 115.72,52.37 116.31,52.95 117.17,52.95 119.94,50.18 123.37,50.18 125.58,47.97 v1(125.58,45.89) 124.5,44.8 124.5,39.16 v1(124.32,38.98)
  BOTTOM w0.114: R1064.1 127.51,45.97 126.57,45.97 126.21,45.61 PR368.1 125.85,45.61 v1(125.58,45.89) ; v1(171.84,22.83) 171.84,24.02 PR463.1 ; v1(235.07,32.08) 218.87,32.08 216.11,29.31 212.5,29.31 203.41,20.22 203.41,15.3 199.97,11.86 197.61,11.86 v1(197.33,11.58) ; v1(124.32,38.98) 124.21,38.98 123.58,38.35 123.58,36.76 126.08,34.26 126.08,30.3 125.76,29.98 125.76,27.8 126.33,27.23 127.07,26.49 PR465.1 127.07,26.04 128.56,24.55 v1(128.56,24.43) ; PR353.1 34,111.22 v1(34.04,111.18)
SVC: length 13.2
  BOTTOM w0.114: U18.D17 57.64,103.71 56,103.71 55.79,103.92 54.74,103.92 54.59,104.08
  BOTTOM w0.254: R477.1 47.16,105.26 48.49,105.26 R493.2 49.45,105.26 50.64,105.26 50.64,105.27 50.98,105.27 51.17,105.46 51.17,105.66 R484.1 51.98,105.75 53.53,104.2 54.46,104.2 54.59,104.08
SVD: length 21.8
  TOP w0.254: v1(44.46,94.52) v1(43.86,95.13) R479.1 43.96,96.09 44.73,96.87 R492.2 R486.1
  IN1 w0.254: v1(57.29,102.46) 52.77,102.46 50.31,100.01 49.44,100.01 45.63,96.19 45.33,96.19 44.4,95.27 44.4,94.58 v1(44.46,94.52)
  BOTTOM w0.305: U18.D19 v1(57.29,102.46)
SYS_PWR_SW#: length 14.1
  TOP w0.114: v1(230.26,21.39) 230.04,21.62 224.55,21.62 223.57,22.6 U34.125
  BOTTOM w0.114: D15.1 229.34,19.32 v1(229.63,19.61) 229.65,19.64 C712.1 R436.1 230.43,21.22 v1(230.26,21.39)
SYS_PWRGD: length 58.2
  IN4 w0.089: v1(109.7,122.47) 109.7,122.4 113.06,119.04 113.48,119.04 v1(113.98,119.55)
  BOTTOM w0.102: 91.25,110.85 90.89,110.49 90.89,110.48 90.21,109.8 U18.BC9
  BOTTOM w0.114: v1(109.7,122.47) 108.8,121.57 97.17,121.57 92.39,126.34 89.25,126.34 R562.2 ; v1(113.98,119.55) 113.98,119.49 v1(107.44,112.94) 95.76,112.94 93.67,110.85 91.25,110.85
SYS_RST#: length 14.7
  BOTTOM w0.114: U18.AF2 75.65,115.36 76.07,115.78 76.07,117.22 76.01,117.28 76.01,118.88 77.16,120.03 77.61,120.03 78.02,120.45 78.02,121.67 78.14,121.79 78.14,122.22 v1(78.59,122.67) 78.74,122.82 78.74,123.44 79.4,124.1 R608.2 R531.2 R598.2 82.74,124.1 83,124.35 D22.1
SYS_SHDN#: length 12.4
  TOP w0.114: v1(43.82,109.64) 43.38,109.2 R264.2 42.48,108.43 41.6,108.43 41.42,108.24 41.42,106.68 41.56,106.53 Q17.1
  BOTTOM w0.114: U9.4 44.47,113.45 44.69,113.67 v1(44.87,113.67) 45.1,113.67 45.3,113.47 45.3,110.6 44.35,109.64 v1(43.82,109.64)
SYSTEM_SUS_PG: length 9.5
  TOP w0.114: R1044.1 213.8,16.36 213.8,17.07 214.19,17.46 219.28,17.46 219.73,17.01 U34.19
T_DDR: length 189.2
  TOP w0.114: U34.66 238.52,12.21 R397.1 238.64,10.62 233.08,5.06 190.59,5.06 178.83,16.82 158.42,16.82 156.62,18.61 131.17,18.61 130.2,19.58 128.82,19.58 124.57,15.33 109.52,15.33 107.76,13.57 v1(107.64,13.57)
  BOTTOM w0.114: v1(107.64,13.57) v1(106.95,13.57) 106.7,13.57 106.37,13.9 106.37,17.66 105.41,18.62 105.38,18.62 102.16,21.83 102.16,27.03 108.34,33.21 108.34,36.49 109.2,37.36 109.2,47.41 111.19,49.39 111.19,49.9 RT1.2
T_SSD: length 4.3
  TOP w0.114: U34.73 v1(237.73,15.01) 238.03,15.01 R446.1 v1(237.99,14.43)
  BOTTOM w0.114: RT2.2 237.69,14.13 v1(237.99,14.43)
TEST_PG: length 7.4
  BOTTOM w0.114: C971.2 146.52,85.66 146.52,86.7 R705.1 145.19,88.04 145.19,90.87 144.75,91.3 U22.AY13
TEST_PG_BACO: length 5.8
  BOTTOM w0.102: 144.34,87.99 144.34,89.14 144.84,89.65
  BOTTOM w0.114: U22.BA13 144.84,90.76 144.84,89.65 ; 144.34,87.24 C973.2 144.34,87.93 ; 144.34,87.24 R709.1 ; 144.34,87.24 144.34,87.93 ; 144.34,87.99 144.34,87.93
THERM_ALERT#: length 3.9
  BOTTOM w0.254: R262.2 v1(45.76,107.9) 45.58,107.9 44.99,108.5 44.07,108.5 43.82,108.25 U9.6
THERM_STP#: length 286.7
  TOP w0.114: v1(44.01,106.3) 44.16,106.46 Q17.3
  IN4 w0.089: v1(44.01,106.3) 42.87,105.17 42.87,104.32 41.87,103.32 41.87,102.79 40.5,101.43 39.98,101.43 39.55,101 39.55,100.1 39.28,99.82 39.28,97.49 37.78,95.99 37.78,94.66 37.02,93.91 37.02,90.94 35.4,89.32 35.4,87.32 36.93,85.8 36.93,68.35 33.88,65.3 33.88,61.44 34.36,60.96 34.36,59.08 35.25,58.19 35.25,48.24 37.3,46.19 37.3,38.03 39.04,36.29 63.29,36.29 66.58,32.99 93.32,32.99 v1(93.83,33.51) ; v1(102.9,18.82) 107.85,18.82 108.86,17.81 110.32,17.81 110.5,17.62 110.79,17.62 111.59,16.82 114.62,16.82 115.71,17.91 123.41,17.91 123.88,17.44 140.69,17.44 141.28,18.03 155.23,18.03 155.72,18.52 173.36,18.52 180.37,11.51 185.15,11.51 189.65,7.01 208.17,7.01 213.73,12.57 v1(213.73,14.89)
  BOTTOM w0.114: Q41.2 R226.1 219.91,14.07 v1(216.78,14.07) 214.55,14.07 v1(213.73,14.89) ; v1(93.83,33.51) 95.26,32.08 95.26,21.92 95.82,21.36 100.35,21.36 v1(102.9,18.82)
TP_I2C_CLK: length 8.9
  TOP w0.114: Q9.3 169.72,39.87 168.82,38.97 v1(168.47,38.97) 168.01,38.51 168.01,37.77 R159.1 R172.2 169.08,35.44 169.08,34.62 169.5,34.2 CN4.6
TP_I2C_DAT: length 6.8
  TOP w0.114: CN4.7 170.5,34.16 169.63,35.02 169.63,35.57 R173.2 170.12,36.38 v1(169.63,36.86) 169.63,36.96 169.99,37.32 R163.1 170.49,37.46 171.02,37.99 Q9.6
TP_INTR#: length 115.4
  TOP w0.114: v1(168.95,41.43) 168.77,41.25 R460.1 167.71,38.19 D6.1 166.82,36.51 R171.1 167.73,35.6 167.73,34.35 167.5,34.11 CN4.4 ; U34.69 237.14,13.41 237.7,12.85 241.82,12.85 243.75,14.79 243.75,18.2 245.12,19.57 245.12,27.1 243.23,28.99 243.23,32.2 239.4,36.03 200.97,36.03 v1(200.28,36.72)
  BOTTOM w0.114: v1(200.28,36.72) 199.75,36.72 196.49,39.98 196.03,39.98 v1(196.03,39.98) 195.29,40.72 178.01,40.72 177.1,41.63 169.15,41.63 v1(168.95,41.43)
TP_PWR_EN:
  vias: v1(176.87,35.11)
TP_PWR_EN#: length 69.8
  TOP w0.203: U34.16 219.89,18.21
  TOP w0.254: 219.89,18.21 219.45,18.65 214.55,18.65 213.04,17.15 213.04,16.13 212.89,15.98 211.67,15.98 210.11,17.54 203.7,17.54 201.46,15.29 201.46,14.52 201.13,14.19 198.7,14.19 191.75,21.14 191.75,28.14 192.48,28.87 192.48,36.94 v1(192.47,36.95)
  BOTTOM w0.254: v1(192.47,36.95) 191.99,36.46 191.01,36.46 v1(188.98,38.5) 188.47,39.01 179.42,39.01 179.24,38.83 Q25.5 Q25.2
TPCLK: length 99.3
  TOP w0.114: U34.89 237.28,21.41 237.5,21.2 240.1,21.2 240.64,21.74 240.64,23.55 241.47,24.38 241.47,30.75 236.71,35.5 200.32,35.5 v1(198.89,36.93) ; v1(163.51,38.49) 164.01,38.99 R150.1 R161.2
  BOTTOM w0.114: v1(163.51,38.49) 164.04,38.49 166.54,40.99 169.13,40.99 169.52,41.39 177,41.39 177.91,40.48 194.07,40.48 v1(194.52,40.03) 195.2,39.35 196.47,39.35 v1(198.89,36.93)
TPCLK-1: length 4.8
  TOP w0.114: v1(163.05,37.1) 163.05,37.11 R161.1 EC24.2 164.5,35.6 CN4.1
TPDATA: length 97.3
  TOP w0.114: U34.90 237.26,21.81 237.64,21.44 239.82,21.44 240.4,22.02 240.4,23.65 241.23,24.48 241.23,30.65 236.61,35.26 199.9,35.26 v1(198.23,36.93) ; R162.2 R151.1 164.67,38.46 v1(164.63,38.46)
  BOTTOM w0.114: v1(198.23,36.93) 196.51,38.64 v1(194.61,38.64) 193.01,40.24 177.81,40.24 176.9,41.15 169.62,41.15 169.23,40.75 166.92,40.75 v1(164.63,38.46)
TPDATA-1: length 9.1
  TOP w0.114: v1(164.78,40.89) 164.96,40.7 165.66,40.7 165.87,40.5 165.87,37.39 165.58,37.11 R162.1 EC25.2 165.67,35.57 165.67,34.37 165.5,34.2 CN4.2
TPS51225_FB1: length 22.8
  TOP w0.254: v1(147.84,14.86) v1(147.84,15.93) 147.84,16.78 146.7,17.92 130.21,17.92 v1(129.05,19.08)
  BOTTOM w0.254: PR209.1 v1(147.84,14.86) ; SJ11.2 v1(129.05,19.08)
TPS51225_FB2: length 16.1
  IN4 w0.254: v1(156.81,15.15) 156.71,15.05 155.25,15.05 154.58,14.38 152.69,14.38 v1(152.18,14.88)
  BOTTOM w0.254: v1(156.81,15.15) 156.81,16.61 158.28,18.08 v1(161.63,18.08) 164.13,18.08 SJ13.2 ; PR207.2 v1(152.18,14.88)
TPS51225_VFB1: length 2.6
  BOTTOM w0.203: PU2.2 149.27,12.47 148.98,12.76
  BOTTOM w0.254: PR209.2 PR210.2 148.88,12.86 148.98,12.76
TPS51225_VFB2: length 3
  BOTTOM w0.203: PU2.4 150.07,12.46 150.48,12.87
  BOTTOM w0.254: 150.48,12.87 150.66,13.05 150.66,13.05 PR206.1 PR207.1
TPS51225_VO1: length 29.6
  TOP w0.254: v1(149.14,8.18) 149.14,9.33 148.44,10.03 v1(148.44,13.21) 148.44,16.76 146.9,18.3 130.84,18.3 v1(130.06,19.08)
  BOTTOM w0.203: PU2.14 149.27,8.31 v1(149.14,8.18)
  BOTTOM w0.254: SJ12.2 v1(130.06,19.08)
TRA_V_DAC:
  vias: v1(268.95,105.14) v1(269.59,105.14) v1(269.64,96.55) v1(270.02,97.08) v1(270.32,96.52)
UART0_CTS: length 2.2
  TOP w0.102: v2(87.36,111.08) 87.06,111.38 TP313.1
  BOTTOM w0.102: v2(87.36,111.08) 87.36,110.42 87.24,110.3 87.24,110.08 86.96,109.8 U18.AY9
UART0_RTS: length 1.5
  TOP w0.102: TP315.1 84.95,113.47 v2(84.95,113.29)
  BOTTOM w0.102: v2(84.95,113.29) 85.46,113.29 U18.AV5
UART0_RXD: length 2
  TOP w0.102: v2(86.45,111.28) 85.87,110.7 TP314.1
  BOTTOM w0.102: U18.AW8 86.15,110.98 v2(86.45,111.28)
UART0_TXD: length 1.6
  TOP w0.102: v2(85.79,111.28) 85.81,111.31 TP316.1
  BOTTOM w0.102: U18.AV8 85.79,111.04 v2(85.79,111.28)
UART1_CTS: length 1.7
  TOP w0.102: TP317.1 85.75,107.27 v2(85.75,107.39)
  BOTTOM w0.102: v2(85.75,107.39) 85.35,107.79 U18.AV11
UART1_RTS: length 1.7
  TOP w0.102: v2(84.28,107.46) 84.58,107.16 TP320.1
  BOTTOM w0.102: U18.AT11 84.28,107.67 v2(84.28,107.46)
UART1_RXD: length 2.3
  TOP w0.102: TP318.1 83.98,110.03 v2(84.03,110.03)
  BOTTOM w0.102: U18.AU7 84.45,111.24 84.03,110.82 v2(84.03,110.03)
UART1_TXD: length 1.7
  TOP w0.102: v2(83.35,107.46) 83.35,107.17 TP319.1
  BOTTOM w0.102: v2(83.35,107.46) 82.95,107.86 U18.AR11
UGATE_1: length 36.3
  IN3 w0.889: v3(82.36,145.78) 83.12,146.53 101.13,146.53 102.05,145.61 104.16,145.61 105.47,144.31 105.47,142.33 107.51,140.29 109.16,140.29 109.71,140.85 v3(109.71,141.84)
  BOTTOM w0.203: PU16.22 110.13,142.26 v3(109.71,141.84)
  BOTTOM w0.889: v3(82.36,145.78) 82.84,145.3 v1(82.84,144.61) PQ47.1
UGATE_2: length 42.1
  IN3 w0.889: v3(108.72,146.65) 106.73,148.64 76.34,148.64 73.98,146.28 v3(73.98,145.65)
  BOTTOM w0.203: PU16.29 110.13,145.06 109.73,145.46 109.73,145.65
  BOTTOM w0.508: 109.73,145.65 v3(108.72,146.65)
  BOTTOM w0.889: v3(73.98,145.65) v1(73.98,144.51) PQ46.1
UGATE_CI: length 25.8
  IN3 w0.762: v3(156.81,66.82) 156.68,66.7 156.68,58.83 155.61,57.76 154.24,57.76 152.29,55.81 147.97,55.81 144.26,52.1 v3(144.26,51.54)
  BOTTOM w0.203: PU24.32 143.76,51.16 144.13,51.54 v3(144.26,51.54)
  BOTTOM w0.381: PQ57.4 v3(156.81,66.82)
UGATE_GFX1: length 31.7
  IN3 w0.889: v3(37.36,125.45) 37.36,125.93 39.88,128.45 43.79,128.45 54.34,139 v3(54.34,143.44)
  BOTTOM w0.203: v3(37.36,125.45) 37.43,125.45 38,124.89 PU17.22
  BOTTOM w0.61: PQ49.1 56.38,143.44
  BOTTOM w0.762: 56.38,143.44 v1(55.56,143.44) v3(54.34,143.44)
UGATE_GFX2: length 40.1
  IN3 w0.889: v3(42.51,125.74) 42.51,126.19 43.26,126.94 43.73,126.94 55.54,138.75 55.54,142.49 56.38,143.34 65.95,143.34 67.09,144.48 v3(67.83,144.48)
  BOTTOM w0.203: PU17.29 40.8,124.87 41.3,125.37 42.14,125.37 v3(42.51,125.74)
  BOTTOM w0.889: v3(67.83,144.48) 67.17,144.48 v1(66.94,144.25) 66.49,143.8 PQ48.1
UGATE_GPU1: length 15.5
  IN3 w0.889: v3(129.86,58.32) 130.45,58.91 134.98,58.91 v3(135.57,58.32) 138.65,55.25 v3(138.65,53.14)
  BOTTOM w0.203: v3(138.65,53.14) 138.98,53.14 139.38,52.74 PU24.22
  BOTTOM w0.762: PQ62.1 v3(129.86,58.32) ; PQ61.1 v3(135.57,58.32)
UGATE_GPU2: length 16.2
  IN3 w0.889: v3(150.86,58.15) 150.86,58.4 150.43,58.83 146.02,58.83 v3(145.23,58.03) 143.83,56.63 143.83,53.37 v3(143.19,52.74)
  BOTTOM w0.203: v3(143.19,52.74) 142.99,52.94 142.38,52.94 142.18,52.74 PU24.29
  BOTTOM w0.762: PQ60.1 150.94,58.22 v3(150.86,58.15) ; PQ59.1 v3(145.23,58.03)
UGATE_NB: length 15.6
  TOP w0.762: v3(110.87,147.17) 109.89,147.17 108.64,148.42 102.53,148.42 v1(101.49,147.38) v3(99.75,145.64)
  BOTTOM w0.203: v3(110.87,147.17) 111.16,147.17 111.7,146.63 PU16.32
  BOTTOM w0.889: PQ45.1 v3(99.75,145.64)
USB2_N1_L: length 11
  TOP w0.102: v1(272.38,49.02) 272.31,48.95 272.07,48.95 271.92,49.1 271.92,49.46 271.62,49.76 270.72,49.76 270.38,49.42 270.26,49.42 270.19,49.49 270.19,49.64 270.15,49.68 EL3.2
  BOTTOM w0.102: CN8.2 276.87,51.9 276.67,51.9 276.15,51.38 273.67,51.38 271.92,49.63 271.92,49.1 272.05,48.98 272.33,48.98 v1(272.38,49.02)
USB2_N1_R: length 3.9
  TOP w0.102: EL3.1 268.09,49.68 268.04,49.64 267.75,49.64 267.28,49.17 267.28,48.4 266.95,48.07 266.66,47.78 266.66,47.48 266.63,47.45 U7.11
USB2_P1_L: length 11
  TOP w0.102: EL3.3 270.12,49.13 270.19,49.2 270.47,49.2 270.81,49.54 271.53,49.54 271.7,49.37 271.7,49.23 v1(271.49,49.02)
  BOTTOM w0.102: v1(271.49,49.02) 271.7,49.23 271.7,49.72 273.58,51.59 276.06,51.59 277.22,52.75 CN8.3
USB2_P1_R: length 3.9
  TOP w0.102: EL3.4 268.11,49.13 268.02,49.21 268.02,49.37 267.97,49.42 267.84,49.42 267.5,49.08 267.5,48.32 267.11,47.92 266.88,47.69 266.88,47.62 266.94,47.55 267.07,47.55 267.13,47.49 U7.10
USB2N0: length 8.5
  BOTTOM w0.102: TP308.1 86.41,121.14 86.62,120.93 86.62,120.03 85.61,119.02 84.03,119.02 83.59,118.58 83.59,117.14 83.15,116.7 83.15,116.12 83.02,115.98 82.92,115.98 82.81,116.1 82.81,116.26 U18.AR1
USB2N1_BT: length 223.9
  IN3 w0.102: v2(82.12,117.89) 82.33,118.09 82.33,118.31 82.65,118.64 83.89,118.64 84.13,118.88 87.14,118.88 87.93,118.09 90.6,118.09 93.23,115.45 96.37,115.45 97.32,114.51 102.73,114.51 106.92,110.32 106.92,103.32 107.91,102.32 107.91,86.4 109.59,84.72 109.59,71.29 112.12,68.76 112.12,46.64 111.7,46.23 111.7,42.82 109.72,40.84 100.54,40.84 99.61,39.91 89.62,39.91 85.89,36.17 55.35,36.17 38.14,18.96 30.2,18.96 28.04,21.12 24.27,21.12 22.08,18.93 22.08,13.46 20.63,12.01 17.52,12.01 14.72,9.21 14.72,7.71 v1(14.95,7.47)
  BOTTOM w0.102: R453.2 12.98,8.54 13.27,8.54 13.49,8.32 14.38,8.32 14.73,7.97 14.73,7.69 v1(14.95,7.47) ; U18.AR4 82.75,114 82.58,114 82.34,114.24 82.34,114.97 82.42,115.05 82.42,115.2 82.26,115.36 82.26,115.65 82.4,115.79 82.4,115.91 82.4,115.99 82.33,116.06 82.33,117.68 v2(82.12,117.89)
USB2N1_BT_R: length 7.5
  BOTTOM w0.102: CN10.5 9.6,3.68 9.74,3.54 9.83,3.54 9.98,3.68 9.98,7.3 11.02,8.34 11.59,8.34 R453.1
USB2N2_CAM: length 188.6
  IN4 w0.102: v2(81.17,117.21) 81.32,117.06 81.32,116.7 81.58,116.44 86.21,116.44 86.73,116.96 89.38,116.96 91.22,115.12 95.94,115.12 96.99,114.06 102.89,114.06 108.09,108.86 108.09,104.09 110.02,102.16 110.02,91.93 116.37,85.58 116.37,84.73 116.07,84.42 116.07,79.53 113.7,77.17 113.7,47.28 114.39,46.59 114.39,42.87 118.3,38.96 119.78,38.96 121.7,37.04 121.7,35.39 127.42,29.67 129.07,29.67 129.82,28.92 139.72,28.92 139.92,29.12 149.68,29.12 151.8,31.25 159.16,31.25 159.68,30.73 159.68,30.18 159.6,30.1 v1(159.4,30.1)
  BOTTOM w0.102: v1(159.4,30.1) 159.65,30.1 159.73,30.18 159.73,31.55 162.92,34.74 162.92,37 162.13,37.78 162.13,48.5 164.85,51.22 164.85,54.07 166.46,55.68 167.27,55.68 167.5,55.45 167.5,55.19 167.6,55.09 167.6,54.71 167.83,54.47 R359.1 ; v2(81.17,117.21) 81.37,117.01 81.37,116.42 U18.AN1
USB2N2_CAM_R: length 4.3
  BOTTOM w0.102: CN9.2 168.1,50.5 167.96,50.64 167.96,51.01 167.49,51.47 167.49,52.92 167.6,53.03 167.6,53.46 167.83,53.69 R359.2
USB2N3_CR: length 261.8
  IN4 w0.102: v1(246.91,14.36) 246.66,14.36 246.52,14.51 246.52,15.16 246.08,15.6 245.12,15.6 243.74,16.98 243.74,28.47 239.21,33 219.55,33 218.32,31.77 194.69,31.77 191.36,28.43 185.14,28.43 184.2,27.49 184.2,26.83 182.41,25.04 175.76,25.04 174.49,26.31 169.86,26.31 169.33,26.84 166.77,26.84 166.24,26.31 157.75,26.31 156.89,27.17 151.64,27.17 150.22,25.75 147.8,25.75 146.54,24.49 130.21,24.49 129.01,25.69 126.4,25.69 125.45,26.64 125.45,27.62 110.1,42.97 110.1,48.15 110.9,48.95 110.9,67.21 109.74,68.36 109.74,83.41 106.6,86.55 106.6,101.47 105.32,102.75 105.32,104.01 103.61,105.72 103.61,105.95 99.19,110.37 96.06,110.37 95.14,111.29 90.49,111.29 90.32,111.47 89.89,111.47 89.35,112.02 84.6,112.02 84.11,112.5 82.39,112.5 82.28,112.6 82.28,113.32 81.79,113.81 81.59,113.81 81.45,113.96 81.45,114.14 v2(81.58,114.28)
  BOTTOM w0.102: U18.AN4 81.25,113.95 v2(81.58,114.28) ; R910.2 248.09,14.71 247.85,14.94 247.4,14.94 247.3,15.05 246.68,15.05 246.57,14.94 246.57,14.48 246.69,14.36 v1(246.91,14.36)
USB2N3_CR_R: length 2.9
  BOTTOM w0.102: R910.1 248.87,14.71 249.1,14.94 249.47,14.94 249.6,15.08 249.81,15.08 250.1,15.37 250.57,15.37 250.71,15.23 U28.2
USB2P0: length 8.6
  BOTTOM w0.102: TP309.1 87.09,121.14 86.83,120.88 86.83,119.94 86.73,119.84 86.72,119.84 85.69,118.82 84.11,118.82 83.79,118.5 83.79,117.06 83.36,116.62 83.36,116.03 83.1,115.78 82.94,115.78 82.85,115.68 U18.AR2
USB2P1_BT: length 223.9
  IN3 w0.102: v1(14.19,7.47) 14.42,7.47 14.52,7.57 14.52,9.3 17.43,12.22 20.55,12.22 21.88,13.54 21.88,19.02 24.19,21.33 28.13,21.33 30.29,19.17 38.05,19.17 55.26,36.38 85.8,36.38 89.54,40.11 99.52,40.11 100.45,41.04 109.63,41.04 111.5,42.91 111.5,46.31 111.91,46.72 111.91,68.68 109.39,71.21 109.39,84.64 107.71,86.31 107.71,102.24 106.71,103.23 106.71,110.24 102.64,114.31 97.24,114.31 96.29,115.25 93.15,115.25 90.52,117.88 87.85,117.88 87.06,118.67 84.21,118.67 83.97,118.43 82.74,118.43 82.53,118.22 82.53,118.06 82.71,117.89 v2(82.77,117.89)
  BOTTOM w0.102: v2(82.77,117.89) 82.61,117.89 82.53,117.81 82.53,116.15 82.6,116.08 82.6,115.82 82.6,115.71 82.46,115.57 82.46,115.44 82.62,115.29 82.62,114.96 82.55,114.89 82.55,114.32 82.67,114.2 82.77,114.2 82.85,114.29 U18.AR3 ; R452.2 12.77,8.24 12.84,8.31 13.2,8.31 13.4,8.11 14.29,8.11 14.52,7.88 14.52,7.57 14.42,7.47 v1(14.19,7.47)
USB2P1_BT_R: length 7.5
  BOTTOM w0.102: R452.1 11.59,8.13 11.11,8.13 10.19,7.21 10.19,3.59 9.92,3.32 9.75,3.32 9.61,3.18 CN10.3
USB2P2_CAM: length 188.6
  IN4 w0.102: v1(160.26,30.1) 160.04,30.1 159.96,30.18 159.96,30.85 159.28,31.53 151.69,31.53 149.56,29.4 139.8,29.4 139.6,29.2 129.94,29.2 129.18,29.95 127.54,29.95 121.98,35.51 121.98,37.15 119.9,39.24 118.42,39.24 114.67,42.98 114.67,46.71 113.98,47.4 113.98,77.05 116.35,79.42 116.35,84.31 116.65,84.61 116.65,85.69 110.3,92.04 110.3,102.28 108.37,104.21 108.37,108.98 103,114.34 97.11,114.34 96.05,115.4 91.34,115.4 89.49,117.24 86.62,117.24 86.09,116.72 81.7,116.72 81.6,116.82 81.6,117.04 v2(81.77,117.21)
  BOTTOM w0.102: v2(81.77,117.21) 81.57,117.01 81.57,116.19 81.25,115.87 U18.AN2 ; v1(160.26,30.1) 159.94,30.42 159.94,31.46 163.13,34.65 163.13,37.09 162.34,37.87 162.34,48.41 165.06,51.13 165.06,53.98 166.55,55.46 167.18,55.46 167.28,55.36 167.28,55.25 167.05,55.01 167.05,54.71 166.82,54.47 R358.1
USB2P2_CAM_R: length 4.2
  BOTTOM w0.102: R358.2 166.82,53.69 167.05,53.46 167.05,53.02 167.28,52.79 167.28,51.38 167.74,50.92 167.74,50.75 167.6,50.61 CN9.1
USB2P3_CR: length 261.8
  IN4 w0.102: v1(246.05,14.36) 246.24,14.56 246.24,15.04 245.96,15.32 245.01,15.32 243.46,16.87 243.46,28.36 239.09,32.72 219.66,32.72 218.43,31.49 194.81,31.49 191.47,28.15 185.26,28.15 184.48,27.38 184.48,26.71 182.53,24.76 175.64,24.76 174.37,26.03 169.74,26.03 169.21,26.56 166.89,26.56 166.35,26.03 157.63,26.03 156.77,26.89 151.76,26.89 150.33,25.47 147.92,25.47 146.66,24.21 130.1,24.21 128.89,25.41 126.28,25.41 125.17,26.52 125.17,27.5 109.82,42.85 109.82,48.27 110.62,49.07 110.62,67.09 109.46,68.25 109.46,83.29 106.32,86.43 106.32,101.35 105.04,102.63 105.04,103.9 103.33,105.61 103.33,105.84 99.08,110.09 95.94,110.09 95.02,111.01 90.38,111.01 90.2,111.19 89.78,111.19 89.23,111.74 84.48,111.74 84,112.22 82.27,112.22 82,112.49 82,113.21 81.68,113.53 81.48,113.53 81.17,113.85 81.17,114.06 v2(80.93,114.3)
  BOTTOM w0.102: R909.2 248.08,15.73 247.85,15.49 247.52,15.49 247.28,15.26 246.59,15.26 246.36,15.03 246.36,14.67 v1(246.05,14.36) ; U18.AN3 81.25,114.61 v2(80.93,114.3)
