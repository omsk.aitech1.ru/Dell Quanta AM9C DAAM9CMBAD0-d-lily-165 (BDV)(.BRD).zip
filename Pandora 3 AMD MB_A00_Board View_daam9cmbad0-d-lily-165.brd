# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_ALW on BOTTOM (solid shape): outline of 102 points within 165.02,11.25 179.17,29.67
+3.3V_ALW on BOTTOM (solid shape): outline of 1260 points within 221.5,17.28 249.62,36.57
+3.3V_ALW on IN1 (solid shape): outline of 853 points within 203.56,25.3 237.48,30.47
+3.3V_ALW on IN2 (solid shape): outline of 291 points within 175.66,9.58 216.7,16.34
+3.3V_ALW on IN3 (solid shape): 274.84,80.76 274.84,78.91 274.65,78.72 273.78,78.72 273.08,79.42 273.08,80.25 273.24,80.42 273.24,81.72 273.41,81.89 273.7,81.89
+3.3V_ALW on IN3 (solid shape): outline of 501 points within 214.9,9.63 223.66,18.67
+3.3V_EC on TOP (solid shape): 223.58,28.52 223.58,28.02 223.99,27.61 223.99,26.93 223.84,26.78 222.72,26.78 222.57,26.93 222.57,28.55 222.77,28.76 223.35,28.76
+3.3V_EC on TOP (solid shape): 219.83,14.31 219.83,13.9 219.77,13.85 219.34,13.85 219.27,13.78 219.26,13.77 219.11,13.68 219.02,13.53 219.01,13.52 218.83,13.34 218.83,10.31 218.43,9.9 217.62,9.9 217.59,9.94 217.59,11.56 217.89,11.87 217.89,11.88 217.91,11.9 217.91,13.61 218,13.7 218.11,13.7 218.84,14.43 219.7,14.43
+3.3V_RUN on TOP (solid shape): 107.46,54.39 107.46,53.27 107.44,53.23 107.4,53.22 104.51,53.22 104.39,53.34 104.39,54.24 104.57,54.42 107.42,54.42
+3.3V_RUN on TOP (solid shape): 170.93,51.18 170.93,50.13 170.45,49.65 170.45,48.49 170.19,48.24 168.62,48.24 168.52,48.34 168.52,49.74 168.66,49.88 169.04,49.88 169.18,50.02 169.18,51.22 169.37,51.41 170.7,51.41
+3.3V_RUN on TOP (solid shape): 268.31,66.13 269.19,66.13 269.23,66.1 269.23,66.02 269.16,65.95 268.38,65.95 268.38,65.94 267.96,65.94 267.83,65.81 267.71,65.81 267.7,65.82 267.36,65.87 267.13,65.6 267.12,65.57 267.08,65.56 266.64,65.56 266.56,65.64 266.56,66.12 266.91,66.47 267.98,66.47
+3.3V_RUN on TOP (solid shape): 277.84,65.81 277.84,64.67 278.63,63.88 278.63,63.39 278.54,63.3 276.48,63.3 276.23,63.05 273.92,63.05 273.52,63.45 273.52,64.18 273.48,64.35 273.38,64.5 273.37,64.53 273.37,64.9 273.42,64.95 274.18,64.95 274.22,64.92 274.22,64.85 274.27,64.79 274.27,64.7 274.33,64.04 274.99,64 275.83,64 276.04,64.21 276.76,64.21 276.98,64.43 276.98,65.76 277.14,65.92 277.73,65.92
+3.3V_RUN on TOP (solid shape): outline of 249 points within 1.8,2.77 6.49,24.31
+3.3V_RUN on BOTTOM (solid shape): 246.52,19.39 246.52,17.99 246.39,17.86 244.44,17.86 244.31,17.99 244.31,19.31 244.51,19.51 246.39,19.51
+3.3V_RUN on BOTTOM (solid shape): 278.57,64.88 278.57,63.29 278,62.72 276.68,62.72 276.39,63.01 276.39,65.82 276.54,65.97 277.48,65.97
+3.3V_RUN on BOTTOM (solid shape): 4.53,3.43 4.53,2.88 4.48,2.82 4.31,2.82 4.31,2.83 4.03,2.85 3.76,2.79 1.7,2.79 1.64,2.85 1.64,3.03 1.69,3.08 3.19,3.08 3.24,3.13 3.24,3.23 3.19,3.28 1.69,3.28 1.64,3.33 1.64,3.54 1.66,3.56 4.41,3.56
+3.3V_RUN on BOTTOM (solid shape): 198.41,17.84 198.41,16.49 198.37,16.45 198.34,16.44 198.31,16.44 198.06,16.48 197.84,16.36 197.82,16.34 197.8,16.34 195.19,16.34 195.06,16.46 195.06,17.86 195.24,18.04 198.21,18.04
+3.3V_RUN on BOTTOM (solid shape): 163.28,23.03 163.28,23 164.02,23 164.06,22.99 164.07,22.95 164.07,22.85 164.06,22.82 164.02,22.8 163.28,22.8 163.28,22.6 164.02,22.6 164.06,22.59 164.07,22.55 164.07,21.95 164.38,21.65 164.38,20.43 164.2,20.25 161.29,20.25 161.01,20.53 161,20.55 160.99,20.65 160.95,20.73 160.95,22.59 161.17,22.81 162.25,22.81 162.97,22.81 163.17,23.02 163.21,23.05 163.23,23.06 163.25,23.06
+3.3V_RUN on BOTTOM (solid shape): outline of 107 points within 1.64,19.56 7.05,25.02
+3.3V_RUN on IN2 (solid shape): outline of 8401 points within 1.69,2.54 246.42,26.34
+3.3V_RUN on IN3 (solid shape): 246.47,19.61 246.47,18.55 245.96,18.04 244.39,18.04 244.01,18.42 244.01,20.02 244.18,20.2 245.89,20.2
+3.3V_RUN on IN3 (solid shape): 278.06,63.96 278.56,63.96 278.71,63.81 278.71,62.97 278.38,62.64 275.58,62.64 275.58,61.46 275.42,61.3 274.4,61.3 274.05,61.65 274.03,61.69 274.05,61.72 274.76,62.44 275.18,62.85 275.32,62.85 276.44,63.97 278.05,63.97
+3.3V_RUN on IN3 (solid shape): outline of 872 points within 161.5,20.2 170.68,56.52
+3.3V_SSD on BOTTOM (solid shape): 194.45,31.86 194.45,29.52 194.65,29.32 194.65,25.96 194.5,25.81 194.5,23.93 195.54,22.89 195.54,18.93 194.72,18.1 194.72,15.13 194.58,14.99 194.58,11.84 194.58,11.84 194.58,10.49 194.24,10.15 191.89,10.15 190.51,11.54 190.44,11.54 190.16,11.82 190.16,12.03 190.17,12.06 190.21,12.08 191.7,12.08 191.7,12.27 190.21,12.27 190.17,12.29 190.16,12.32 190.16,12.53 190.17,12.56 190.21,12.58 191.7,12.58 191.7,12.77 190.21,12.77 190.17,12.79 190.16,12.82 190.16,13.04 190.2,13.08 191.7,13.08 191.9,13.08 192.14,13.31 192.14,17.25 192.14,17.25 192.14,18.88 193.82,20.55 193.82,22.38 193.12,23.08 193.11,23.09 193.11,23.11 193.11,27.02 193.12,27.04 193.13,27.05 193.3,27.4 193.06,27.72 193.04,27.74 193.03,27.77 193.03,27.94 191.7,29.27 191.7,29.27 190.13,29.27 190.08,29.3 190.08,29.34 190.08,29.35 190.08,29.55 190.11,29.57 191.68,29.57 191.7,29.58 191.7,29.59 191.73,29.62 191.73,29.75 191.71,29.77 190.16,29.77 190.13,29.8 190.13,30.08 192.12,32.07 194.25,32.07
+3.3V_SUS on TOP (solid shape): 112.51,38 112.51,37.28 110.13,34.9 109.35,34.9 109.3,34.95 109.3,35.93 110.36,36.99 110.36,37.14 111.33,38.11 112.4,38.11
+3.3V_SUS on TOP (solid shape): outline of 341 points within 86.55,103.55 97.92,108.66
+3.3V_SUS on BOTTOM (solid shape): 159.58,34.78 159.58,32.01 159.3,31.73 159.3,31.26 158.37,30.33 158.37,30.31 158.36,30.3 158.3,30.09 158.37,29.88 158.37,29.63 158.5,29.5 163,29.5 163.97,28.53 163.97,26.22 164.07,26.12 164.07,24.85 164.06,24.82 164.02,24.8 163.28,24.8 163.28,24.6 164.02,24.6 164.06,24.59 164.07,24.55 164.07,24.44 164.05,24.41 163.23,24.41 163.19,24.44 163.18,24.46 163.09,24.56 162.95,24.59 162.47,24.59 162.43,24.61 162.42,24.62 162.35,24.69 162.26,24.71 162.25,24.72 161.84,25.13 161.84,27.16 161.56,27.44 158,27.44 157.39,26.83 154.89,26.83 154.85,26.84 154.83,26.87 154.83,27.62 154.63,27.62 154.63,26.87 154.62,26.84 154.58,26.83 154.47,26.83 154.43,26.86 154.43,27.62 154.42,27.62 154.42,27.77 154.62,27.97 155.08,27.97 155.38,28.27 155.43,28.27 155.74,28.58 155.74,28.88 155.76,28.92 155.79,28.94 156.35,28.94 156.6,29.19 156.6,34.47 157.23,35.09 159.26,35.09
+3.3V_SUS on IN2 (solid shape): 160.11,35.18 160.11,33.98 159.82,33.69 157.66,33.69 157.21,34.14 157.21,35.34 157.62,35.74 159.55,35.74
+3.3V_SUS on IN2 (solid shape): 124.07,41.39 124.07,39.98 123.75,39.66 123.72,39.65 123.67,39.67 123.61,39.7 123.54,39.71 123.48,39.72 123.41,39.72 123.35,39.71 123.28,39.69 123.22,39.66 123.17,39.63 123.12,39.59 123.09,39.57 122.21,38.68 115.62,38.68 111.8,34.87 109.46,34.87 109.43,34.88 109.42,34.89 109.41,34.92 109.41,38.19 112.36,41.14 121.1,41.14 121.1,41.08 121.11,41.03 121.13,40.97 121.15,40.92 121.18,40.87 121.22,40.83 121.26,40.79 121.31,40.76 121.36,40.74 121.41,40.72 121.47,40.72 121.53,40.72 121.58,40.72 121.64,40.74 121.69,40.76 121.73,40.79 121.78,40.83 121.81,40.87 121.84,40.92 121.87,40.97 121.88,41.03 121.89,41.08 121.89,41.14 121.88,41.19 121.87,41.25 121.84,41.3 121.81,41.35 121.78,41.39 121.73,41.43 121.69,41.46 121.64,41.48 121.58,41.5 121.53,41.5 121.47,41.5 121.41,41.5 121.36,41.48 121.31,41.46 121.26,41.43 121.22,41.39 121.18,41.35 121.15,41.3 121.13,41.25 121.11,41.19 121.1,41.14 112.36,41.14 112.96,41.74 123.72,41.74
+3.3V_SUS on IN4 (solid shape): outline of 95 points within 154.55,34.59 159.78,38.59
+3.3V_SUS on IN4 (solid shape): 125.94,41.8 125.95,41.76 125.94,41.73 125.96,41.12 126.57,41.1 126.61,41.11 126.64,41.1 126.66,41.08 126.66,39.3 126.25,38.89 124.82,38.89 124.75,38.92 124.72,38.99 124.48,39.34 124.06,39.27 123.96,39.25 123.89,39.32 123.5,39.64 123.06,39.38 122.98,39.33 122.89,39.36 122.59,39.65 122.59,40.57 123.86,41.84 125.9,41.84
+3.3V_TP on TOP (solid shape): 173.29,35.16 173.29,33.51 172.58,32.8 171.27,32.8 171.23,32.85 171.23,33.98 170.93,34.28 170.7,34.28 169.86,35.12 169.86,35.44 169.92,35.5 172.94,35.5
+3.3V_TP on BOTTOM (solid shape): 171.61,36.35 171.76,36.32 171.92,36.35 171.92,36.35 172.27,36.35 172.28,36.35 172.44,36.32 172.59,36.35 172.6,36.35 173.39,36.35 173.42,36.33 173.42,34.95 173.73,34.64 179.65,34.64 180.1,34.62 180.25,35.04 180.25,35.07 180.26,35.09 180.43,35.26 180.43,36.17 180.59,36.33 181.59,36.33 181.8,36.11 181.8,33.86 181.42,33.48 171.87,33.48 171.67,33.69 171.67,34.45 171.54,34.57 171.52,34.58 171.46,34.61 171.39,34.62 171.25,34.63 171.11,34.62 171.04,34.61 170.98,34.58 170.97,34.57 170.32,34.57 169.99,34.24 166.03,34.24 165.8,34.47 165.8,35.74 166.41,36.35 171.6,36.35
+3V_GFX on TOP (solid shape): 119.88,106.46 119.88,105.9 120,105.77 121.35,105.77 121.55,105.57 121.55,104.88 121.43,104.75 120.94,104.75 120.79,104.91 120.79,105.26 120.66,105.39 120.03,105.39 119.86,105.22 119.86,104.54 119.83,104.5 119.44,104.5 119.24,104.7 119.24,106.41 119.39,106.56 119.77,106.56
+3V_GFX on TOP (solid shape): outline of 292 points within 116.44,80.08 132.47,89.35
+3V_GFX on BOTTOM (solid shape): 121.98,104.09 121.98,103.43 121.9,103.35 121.3,103.35 121.29,103.33 120.97,103.33 120.79,103.15 120.79,102.65 120.58,102.44 120.13,102.44 120.05,102.52 120.05,104.1 120.1,104.14 121.94,104.14
+3V_GFX on BOTTOM (solid shape): 122.11,106.33 122.11,104.75 122.11,104.75 120.09,104.75 120.03,104.81 120.03,105.26 120.21,105.44 121.25,105.44 121.43,105.62 121.43,106.33 121.52,106.42 122.02,106.42
+3V_GFX on BOTTOM (solid shape): 133.32,87.88 133.32,86.72 134.01,86.04 134.01,83.95 133.76,83.71 131.94,83.71 131.67,83.98 131.67,85.28 131.49,85.46 131,85.46 130.8,85.66 130.8,86.12 130.98,86.29 130.98,86.33 131.23,86.58 131.23,88.01 131.34,88.12 133.09,88.12
+3V_GFX on BOTTOM (solid shape): 154.58,25.49 154.62,25.47 154.63,25.43 154.63,24.66 154.83,24.66 154.83,25.43 154.85,25.47 154.89,25.49 156.41,25.49 157.48,24.42 157.48,21.57 157.34,21.43 156.24,21.43 156.07,21.59 156.07,22.9 155.71,23.26 155.2,23.26 154.52,23.95 154.52,24.52 154.43,24.61 154.43,25.44 154.48,25.49
+3V_GFX on IN3 (solid shape): 157.43,22.04 157.43,20.94 157.3,20.81 154.61,20.81 154.48,20.94 154.48,22 154.63,22.16 157.31,22.16
+3V_GFX on IN3 (solid shape): 118.05,81.35 118.05,79.49 117.09,78.54 116.54,78.54 116.52,78.54 116.51,78.55 116.04,79.01 116.04,79.27 116.65,79.88 116.65,81.29 116.86,81.5 117.89,81.5
+3V_GFX on IN3 (solid shape): outline of 1873 points within 115.9,86.7 129.73,114.41
+3VLANVCC on TOP (solid shape): 275.83,92.03 275.83,91.34 275.58,91.09 275.17,91.09 275.04,90.96 275.04,90.33 274.99,90.28 274.42,90.28 273.84,89.69 273.67,89.69 273.67,89.69 272.76,89.69 272.68,89.77 272.68,90 273.52,90.84 273.52,91.98 273.67,92.13 275.73,92.13
+3VLANVCC on TOP (solid shape): 273.11,84.74 273.11,83.49 273.04,83.42 271.82,83.42 271.65,83.25 271.36,83.25 271.24,83.37 271.24,83.94 271.61,84.31 271.76,84.37 271.87,84.49 271.89,84.51 271.9,84.54 271.93,84.69 271.9,84.84 271.89,84.85 271.89,85.21 271.95,85.39 271.9,85.57 271.89,85.58 271.89,85.63 271.92,85.65 272.2,85.65
+3VLANVCC on BOTTOM (solid shape): 268.8,90.02 268.79,89.79 268.79,89.49 268.8,89.46 268.8,87.89 268.54,87.64 267.78,87.64 267.58,87.84 267.58,88.63 267.58,88.65 267.6,88.67 267.75,88.98 267.6,89.29 267.58,89.31 267.58,89.33 267.58,89.92 267.88,90.23 268.59,90.23
+3VLANVCC on BOTTOM (solid shape): outline of 151 points within 271.93,82.35 277.17,92.14
+3VLANVCC on IN1 (solid shape): outline of 191 points within 267.6,83.95 274.87,92.25
+5V_ALW on TOP (solid shape): 56.61,27.43 56.61,26.32 56.46,26.17 54.8,26.17 54.55,26.41 54.55,27.47 54.8,27.71 56.32,27.71
+5V_ALW on TOP (solid shape): 203.05,31.23 203.05,30.35 203.06,30.35 203.06,29.8 202.91,29.65 201.77,29.65 201.59,29.82 201.59,31.12 201.79,31.32 202.96,31.32
+5V_ALW on TOP (solid shape): 250.43,27.67 250.43,24.31 250.28,24.16 249.57,24.16 249.49,24.24 249.49,27.77 249.51,27.8 249.54,27.82 250.28,27.82
+5V_ALW on TOP (solid shape): 13.83,33.41 14.36,33.41 14.36,33.4 14.88,32.88 14.88,29.58 14.7,29.4 11.88,29.4 11.32,29.97 11.32,32.36 11.39,32.44 13.45,32.44 13.55,32.54 13.55,32.77 13.42,32.9 11.37,32.9 11.32,32.95 11.32,33.61 11.39,33.69 11.6,33.69 11.62,33.71 13.53,33.71
+5V_ALW on TOP (solid shape): 266.28,44.2 266.28,43.99 266.22,43.87 266.2,43.73 266.2,43.05 266.15,43.01 265.54,43.01 265.41,42.87 265.41,42.69 265.4,42.68 265.37,42.52 265.4,42.37 265.41,42.36 265.41,41.55 265.16,41.31 263.34,41.31 263.06,41.58 263.06,43.52 263.17,43.63 263.83,43.63 264.45,44.25 266.23,44.25
+5V_ALW on BOTTOM (solid shape): 133.59,17.87 133.59,9.58 133.48,9.47 126.1,9.47 125.98,9.58 125.98,11.47 124.98,12.48 121.3,12.48 121.09,12.68 121.09,15.1 122.24,16.24 122.24,17.51 122.89,18.17 133.29,18.17
+5V_ALW on BOTTOM (solid shape): 154.17,28.83 154.17,28.27 154.09,28.19 154.05,28.15 154.02,28.08 153.91,27.97 153.91,27.89 153.84,27.82 153.84,27.62 153.83,27.62 153.83,26.85 153.81,26.83 153.66,26.83 153.63,26.85 153.63,27.62 153.63,27.62 153.63,27.82 153.2,28.25 153.2,28.76 153.3,28.86 154.14,28.86
+5V_ALW on BOTTOM (solid shape): 19.85,56.9 19.89,56.89 19.9,56.85 19.9,55.21 19.99,55.12 19.99,54.61 19.96,54.59 18.24,54.59 18.17,54.66 18.17,55.31 18.33,55.47 18.33,55.61 18.34,55.62 18.43,55.78 18.47,55.96 18.47,56.68 18.69,56.9
+5V_ALW on BOTTOM (solid shape): 124.12,23.53 124.12,23.51 124.19,23.36 124.35,23.3 124.52,23.3 124.78,23.04 124.78,22.15 124.5,21.87 122.14,21.87 122.03,21.98 122.03,23.67 122.05,23.71 122.09,23.72 122.8,23.72 122.8,23.92 122.09,23.92 122.05,23.94 122.03,23.97 122.03,24.06 122.09,24.11 123.54,24.11
+5V_ALW on BOTTOM (solid shape): 124.78,27.64 124.78,26.51 124.61,26.34 124.35,26.34 124.22,26.3 124.14,26.2 124.13,26.18 124.11,26.17 123.99,26.17 123.97,26.15 123.88,26.15 123.26,25.53 122.09,25.53 122.06,25.56 122.06,25.68 122.09,25.71 122.8,25.71 122.82,25.74 122.82,25.91 122.8,25.94 122.06,25.94 122.01,25.99 122.01,26.22 122.09,26.29 122.09,27.03 122.89,27.83 124.59,27.83
+5V_ALW on BOTTOM (solid shape): 32.28,113.89 32.3,113.89 32.43,113.81 32.56,113.78 32.58,113.78 32.71,113.65 32.71,112.86 32.72,112.86 32.72,112.66 32.55,112.49 32.52,112.48 32.51,112.49 32.19,112.47 32,112.22 31.99,112.21 31.81,112.03 31.81,111.51 31.77,111.44 31.75,111.36 31.75,111.07 31.77,110.98 31.83,110.9 31.87,110.83 31.83,110.75 31.77,110.67 31.75,110.58 31.75,110.3 31.18,109.72 31.18,108.87 30.93,108.62 29.84,108.62 29.49,108.98 29.49,113.58 29.8,113.89
+5V_ALW on IN2 (solid shape): outline of 11781 points within 3.02,19.77 265.62,113.78
+5V_ALW on IN3 (solid shape): outline of 2646 points within 54.52,7.28 125.79,30.52
+5V_HDMIF1 on TOP (solid shape): 277.15,71.31 277.15,70.67 276.73,70.26 276.4,70.26 276.02,70.63 276.02,71.23 276.19,71.4 277.06,71.4
+5V_HDMIF1 on BOTTOM (solid shape): outline of 221 points within 275.76,65.26 280.78,71.63
+5V_HDMIF1 on IN2 (solid shape): 279.79,73.15 279.91,73.14 280.04,73.15 280.07,73.15 280.09,73.14 280.16,73.07 280.16,70.72 279.71,70.27 279.64,70.27 279.5,70.26 279.36,70.22 278.94,70.22 278.86,70.25 278.83,70.33 278.44,70.74 278.05,70.33 278.02,70.25 277.95,70.22 277.55,70.22 277.52,70.23 277.5,70.25 277.16,70.45 276.82,70.25 276.8,70.23 276.77,70.22 276.4,70.22 275.86,70.77 275.86,71.15 275.87,71.17 275.88,71.18 275.96,71.23 276.03,71.31 276.07,71.39 276.09,71.48 276.11,71.51 276.14,71.52 277.75,71.52 277.98,71.43 278.21,71.49 278.38,71.69 278.38,71.96 278.38,71.99 278.39,72.01 279.55,73.17 279.72,73.17
+5V_HDMIF1 on IN3 (solid shape): 280.11,73.13 280.14,73.12 280.16,73.08 280.16,71.65 279.34,70.83 278.3,70.83 277.75,70.28 277.51,70.28 277.47,70.29 277.47,70.3 277.16,70.45 276.86,70.3 276.85,70.29 276.81,70.28 276.13,70.28 275.93,70.47 275.93,71.18 275.95,71.22 275.99,71.26 276.03,71.31 276.42,71.69 277.6,71.69 277.65,71.66 277.65,71.65 278.07,71.43 278.4,71.76 278.4,71.88 278.37,71.98 278.36,72 278.37,72.03 279.47,73.13
+5V_RUN on TOP (solid shape): 201.74,39.54 201.74,38.67 201.48,38.42 201.46,38.4 201.44,38.4 198.41,38.4 198.04,38.77 198.04,39.87 198.3,40.12 201.16,40.12
+5V_RUN on TOP (solid shape): 38.47,92.3 38.47,92.26 38.47,92.26 38.47,89.01 38.16,88.7 36.41,88.7 36,89.11 35.73,89.11 35.6,89.24 35.6,91.34 35.64,91.38 35.67,91.4 35.71,91.38 36.09,91.23 36.39,91.51 36.39,91.53 37.28,92.41 38.37,92.41
+5V_RUN on TOP (solid shape): 25.01,5.76 25.01,5.17 25.01,5.16 25.09,4.75 25.35,4.42 25.35,4.42 25.85,3.92 25.85,3.36 25.79,3.31 23.36,3.31 22.95,3.71 22.95,4.6 22.87,4.68 21.6,4.68 21.58,4.7 21.58,4.88 21.6,4.91 22.7,4.91 22.72,4.93 22.72,5.16 22.7,5.19 21.63,5.19 21.58,5.24 21.58,5.36 21.63,5.42 22.7,5.42 22.72,5.44 22.72,5.64 22.67,5.69 21.6,5.69 21.58,5.72 21.58,5.87 21.63,5.92 22.7,5.92 22.72,5.95 22.72,6.15 22.7,6.18 21.63,6.18 21.58,6.23 21.58,6.33 21.63,6.38 24.4,6.38
+5V_RUN on TOP (solid shape): 175.58,81.38 175.58,79.56 175.55,79.49 175.49,79.45 175.14,79.07 175.49,78.69 175.55,78.66 175.58,78.59 175.58,76.06 175.32,75.8 174.01,75.8 174,75.82 174,77.85 173.4,78.45 172.86,78.45 172.62,78.7 172.62,79.8 172.8,79.98 173.38,79.98 173.5,80.1 173.5,81.16 173.68,81.34 173.7,81.34 173.91,81.43 174.03,81.63 174.03,81.64 174.06,81.66 175.29,81.66
+5V_RUN on TOP (solid shape): 30.01,66.6 30.01,65.71 30.01,65.7 29.63,65.41 29.75,64.96 29.75,64.91 29.72,64.87 29.53,64.67 28.28,64.67 27.98,64.98 27.98,66.88 28.05,66.96 28.09,66.97 28.12,66.96 28.14,66.94 28.14,66.91 28.14,66.78 28.19,66.65 28.48,66.48 28.8,66.6 28.89,66.81 28.85,67.04 28.85,67.14 28.94,67.19 29.43,67.19
+5V_RUN on BOTTOM (solid shape): 280.86,64.84 280.86,62.84 280.68,62.67 279.07,62.67 278.79,62.95 278.79,64.86 279,65.07 280.63,65.07
+5V_RUN on BOTTOM (solid shape): 29.12,65.87 29.12,64.93 29.11,64.89 29.07,64.88 28.87,64.88 28.87,64.34 28.85,64.32 28.81,64.31 28.78,64.32 28.77,64.33 28.41,64.53 28.08,64.3 28.08,64.28 28.05,64.27 27.17,64.27 26.89,64.55 26.89,65.84 27.09,66.05 28.94,66.05
+5V_RUN on BOTTOM (solid shape): 120.61,24.08 120.61,23.96 120.59,23.93 119.8,23.93 119.77,23.91 119.77,23.75 119.83,23.7 120.59,23.7 120.64,23.65 120.64,23.34 120.63,23.33 120.6,23.17 120.63,23.01 120.64,23 120.64,22.23 121.9,20.97 121.9,19.12 120.95,18.17 120.95,17.17 120.69,16.91 115.92,16.91 115.74,17.1 115.74,20.99 116.14,21.39 117.67,21.39 118.4,22.12 118.4,22.92 118.4,22.93 118.4,23.37 118.53,23.5 118.96,23.5 119.46,24 119.55,24 119.65,24.11 120.59,24.11
+5V_RUN on BOTTOM (solid shape): 32.84,13.09 32.84,12.16 32.7,12.02 32.03,12.02 32.02,12.02 31.88,12.05 31.74,12.02 31.73,12.02 31.65,12.02 31.62,12.03 31.6,12.07 31.6,12.1 31.46,12.1 31.36,12.2 30.58,12.2 30.58,12.19 30.14,11.75 30.14,10.27 29.91,10.04 29.91,8.95 30.04,8.82 30.04,6.89 30.01,6.86 29.83,6.86 29.81,6.89 29.81,8.03 29.76,8.08 29.58,8.08 29.53,8.03 29.53,6.89 29.5,6.86 29.35,6.86 29.3,6.91 29.3,8.03 29.25,8.08 29.1,8.08 29.05,8.03 29.05,6.91 28.99,6.86 28.87,6.86 28.82,6.91 28.82,8.06 28.67,8.2 28.67,8.28 28.09,8.86 27.41,8.86 27.37,8.88 27.36,8.92 27.36,11.99 27.46,12.1 28.23,12.1 28.49,12.35 28.49,12.35 29.66,13.53 30.01,13.53 30.57,13.53 30.93,13.88 32.05,13.88
+5V_RUN on IN1 (solid shape): 44.92,19.84 44.92,17.63 44.82,17.53 43.73,17.53 42.33,18.93 42.33,20.3 42.97,20.94 43.82,20.94
+5V_RUN on IN1 (solid shape): 29.38,65.74 29.38,64.16 28.63,63.41 28.63,63.35 28.62,63.32 28.6,63.3 28.58,63.28 28.55,63.27 28.52,63.26 28.49,63.27 28.46,63.29 28.4,63.3 28.34,63.31 28.29,63.32 28.23,63.31 28.18,63.29 28.12,63.27 28.08,63.24 28.03,63.2 27.99,63.16 27.96,63.11 27.94,63.06 27.91,63.01 27.88,63 27.01,63 26.79,63.22 26.79,64.18 28.04,64.18 28.04,64.12 28.05,64.06 28.06,64.01 28.09,63.96 28.12,63.91 28.15,63.87 28.2,63.83 28.24,63.8 28.3,63.78 28.35,63.76 28.41,63.75 28.46,63.75 28.52,63.76 28.57,63.78 28.62,63.8 28.67,63.83 28.71,63.87 28.75,63.91 28.78,63.96 28.8,64.01 28.82,64.06 28.83,64.12 28.83,64.18 28.82,64.23 28.8,64.29 28.78,64.34 28.75,64.39 28.71,64.43 28.67,64.46 28.62,64.49 28.57,64.52 28.52,64.53 28.46,64.54 28.41,64.54 28.35,64.53 28.3,64.52 28.24,64.49 28.2,64.46 28.15,64.43 28.12,64.39 28.09,64.34 28.06,64.29 28.05,64.23 28.04,64.18 26.79,64.18 26.79,65.73 27.08,66.02 29.1,66.02
+5V_RUN on IN2 (solid shape): outline of 4857 points within 22.28,1.52 193.79,21.49
+5V_RUN on IN3 (solid shape): 204.53,37.19 204.53,36.68 201.23,36.68 199.33,38.59 199.33,39.22 199.52,39.41 202.31,39.41
+5V_RUN on IN3 (solid shape): 189.75,18.5 189.75,17.12 189.34,16.72 187.87,16.72 187.69,16.9 187.69,18.34 188.2,18.85 189.4,18.85
+5V_RUN on IN3 (solid shape): 280.3,65.28 280.3,64.29 280.15,64.14 278.19,64.14 278.12,64.22 278.12,65.26 278.32,65.46 280.12,65.46
+5V_SUS on BOTTOM (solid shape): 118.82,27.79 118.89,27.77 118.92,27.7 119.3,27.35 119.68,27.7 119.71,27.77 119.78,27.79 120.56,27.79 120.64,27.72 120.64,25.99 120.59,25.94 119.83,25.94 119.8,25.91 119.8,25.74 119.83,25.71 120.59,25.71 120.61,25.68 120.61,25.58 120.56,25.53 119.01,25.53 118.4,26.14 118.4,27.74 118.42,27.78 118.45,27.79
+5V_SUS on BOTTOM (solid shape): 115.72,60.7 115.72,60.58 115.74,60.44 115.81,60.33 115.82,60.31 115.82,60.19 115.81,60.18 115.86,59.63 116.4,59.7 116.42,59.72 116.45,59.72 119.03,59.72 119.32,59.43 119.32,58.36 119.07,58.12 118.33,58.12 118.05,58.4 117.91,58.54 117.71,58.6 116.35,58.6 116.29,58.54 116.26,58.54 115.8,58.08 114.82,58.08 114.65,58.25 114.65,58.65 114.92,58.93 114.92,60.84 115,60.91 115.5,60.91
+5V_SUS on IN3 (solid shape): 121.63,28.13 121.63,27.47 121.07,26.92 121.02,26.87 121,26.87 120.72,26.69 120.66,26.36 120.67,26.33 120.65,26.31 120.54,26.19 119.11,26.19 118.96,26.34 118.96,27.31 119.04,27.38 119.06,27.4 119.1,27.39 119.58,27.45 119.64,27.93 119.64,27.97 119.65,28 119.67,28.02 120.16,28.02 120.2,28.06 120.21,28.06 120.41,28.17 120.52,28.37 120.52,28.38 120.72,28.58 121.18,28.58
+5388VCC on BOTTOM (solid shape): 25.95,45.04 25.95,43.21 25.9,43.16 24.02,43.16 23.86,43.31 23.86,44.76 23.97,44.86 24.42,44.86 24.68,45.12 25.87,45.12
+VDDCI on TOP (solid shape): 151.08,80.15 152.8,80.15 153.03,79.92 153.03,78.16 153.12,78.07 154.85,78.07 154.95,77.97 154.95,77.53 155.51,76.97 155.51,76.56 155.79,76.28 156.35,76.28 156.45,76.18 156.45,74.5 155.58,73.63 149.76,73.63 149.47,73.33 148.66,73.33 148.27,73.73 148.27,80.28 148.34,80.35 150.89,80.35
+VDDCI on TOP (solid shape): outline of 190 points within 133.07,95.1 135.41,102.9
+VDDCI on BOTTOM (solid shape): 148.12,80.33 148.55,79.9 154.2,79.9 155.26,78.85 155.26,73.89 154.48,73.12 149.13,73.12 148.83,73.41 148.83,77.95 148.26,78.52 153.91,78.52 153.91,78.46 153.93,78.41 153.95,78.35 153.97,78.31 154.01,78.26 154.05,78.22 154.09,78.19 154.14,78.16 154.2,78.15 154.25,78.14 154.31,78.13 154.36,78.14 154.42,78.15 154.47,78.18 154.51,78.21 154.56,78.24 154.59,78.28 154.63,78.33 154.65,78.38 154.67,78.43 154.67,78.49 154.67,78.54 154.67,78.6 154.65,78.65 154.63,78.7 154.59,78.75 154.56,78.79 154.51,78.83 154.47,78.86 154.42,78.88 154.36,78.89 154.31,78.9 154.25,78.9 154.2,78.89 154.14,78.87 154.09,78.84 154.05,78.81 154.01,78.77 153.97,78.73 153.95,78.68 153.93,78.63 153.91,78.57 153.91,78.52 148.26,78.52 147.17,79.61 147.17,80.28 147.22,80.33 148.1,80.33
+VDDCI on IN1 (solid shape): outline of 4960 points within 137.05,72.99 156.6,108.34
+VDDCI on IN2 (solid shape): outline of 232 points within 131.91,96.86 135.34,102.96
+VDDCI on IN2 (solid shape): outline of 5440 points within 143.72,72.83 159.5,108.89
+VDDCI on IN3 (solid shape): outline of 1601 points within 128.46,96.17 145.1,107.91
+VDDCI on IN4 (solid shape): outline of 7205 points within 129.35,96.37 151.78,115.24
+VDDCR_CPU on TOP (solid shape): 73.93,98.9 73.93,98.88 74.24,98.63 74.61,98.79 74.61,98.79 75.07,99.25 75.6,99.25 75.72,99.13 75.72,98.87 75.64,98.79 75.27,98.79 75.23,98.75 75.21,98.73 75.21,97.92 75.06,97.77 74.53,97.77 74.52,97.78 73.95,97.78 73.91,97.73 73.68,97.73 73.46,97.81 73.23,97.73 73,97.73 72.86,97.8 72.7,97.8 72.68,97.8 72.66,97.81 72.58,97.89 72.58,99.11 72.75,99.28 73.54,99.28
+VDDCR_CPU on TOP (solid shape): 89.67,131.4 89.4,130.18 89.5,128.93 89.5,128.93 89.5,128.69 88.98,128.17 87.11,128.17 86.8,127.86 86.8,127.17 86.73,127.1 86.02,127.1 85.37,127.75 82.28,127.75 82.26,127.76 82.25,127.77 81.97,127.89 81.68,127.76 81.66,127.75 81.62,127.75 81.6,127.77 81.32,127.88 81.05,127.77 81.03,127.76 81.01,127.75 78.46,127.75 77.74,128.48 71.48,128.48 71.1,128.86 71.1,131.49 71.42,131.82 80,131.82 80.3,131.51 81.89,131.51 82.27,131.89 86.16,131.89 86.84,132.57 88.5,132.57
+VDDCR_CPU on TOP (solid shape): outline of 943 points within 69.16,97.81 77.63,113.09
+VDDCR_CPU on BOTTOM (solid shape): 89.34,132.72 89.34,132.08 89.51,131.92 89.51,129.81 89.07,129.37 89.07,128.63 88.68,128.25 77.56,128.25 77.41,128.1 77.41,127.08 77,126.67 76.06,126.67 75.81,126.93 70.45,126.93 70.27,127.11 70.27,127.96 71.09,128.78 71.09,131.6 71.36,131.87 75.36,131.87 75.61,131.62 75.61,131.38 75.6,131.38 75.6,129.65 76.16,129.65 76.16,131.38 76.14,131.4 76.14,131.62 76.19,131.68 79.23,131.68 79.99,132.44 80.95,132.44 81.04,132.42 81.78,131.68 83.95,131.68 84.45,131.19 84.45,130.22 84.46,130.21 84.46,129.65 85.02,129.65 85.02,130.18 85.03,130.19 85.03,131.56 85.42,131.95 86.2,131.95 87.1,132.85 89.22,132.85
+VDDCR_CPU on BOTTOM (solid shape): 76.46,112.72 76.5,112.71 76.62,112.46 76.85,112.38 76.92,112.35 76.95,112.28 77.16,112.01 77.49,112.11 77.51,112.13 77.53,112.13 77.63,112.13 77.63,112.14 77.67,112.15 77.7,112.14 78.12,112.12 78.22,112.53 78.23,112.63 78.31,112.68 78.54,112.68 78.72,112.5 78.73,112.48 78.74,112.46 78.74,112.39 78.76,112.33 78.75,112.29 78.73,112.27 78.58,112.11 78.55,111.9 78.56,111.88 78.55,111.86 78.5,111.81 78.46,111.8 78.21,111.69 78.16,111.41 78.14,111.32 78.05,111.29 77.85,111.26 77.71,111.14 77.69,111.12 77.67,111.11 77.45,111.11 77.35,111.01 77.33,111 77.3,111 77.19,111 77.09,110.95 77.01,110.94 76.95,110.98 76.92,111.02 76.9,111.09 76.93,111.16 76.95,111.67 76.44,111.68 76.36,111.65 76.29,111.69 75.98,111.79 75.75,111.56 75.71,111.5 75.63,111.49 75.58,111.49 75.52,111.49 75.44,111.52 75.41,111.6 75.41,111.63 75.42,111.65 75.44,111.67 75.59,111.95 75.44,112.23 75.4,112.3 75.43,112.38 75.52,112.47 75.53,112.48 75.68,112.55 75.77,112.69 75.79,112.71 75.82,112.72
+VDDCR_CPU on BOTTOM (solid shape): outline of 2695 points within 68.64,98.29 81.16,112.58
+VDDCR_CPU on SVCC (solid shape): outline of 777 points within 68.39,98.15 90.39,134.07
+VDDCR_CPU on IN2 (solid shape): outline of 6508 points within 65.12,98.4 90.08,132.54
+VDDCR_CPU on IN3 (solid shape): outline of 1660 points within 69.05,98.59 81.07,112.94
+VDDCR_CPU on IN4 (solid shape): outline of 1347 points within 69.18,98.51 78.39,118.05
+VDDCR_FCH_S5 on BOTTOM (solid shape): 123.36,55.17 123.36,54.07 123.31,54.03 123.31,53.94 123.1,53.73 120.82,53.73 120.43,53.35 120.43,52.3 120.38,52.25 119.75,52.25 119.7,52.2 119.56,52.2 119.3,51.94 119.3,51.8 118.94,51.44 118.56,51.44 118.45,51.54 118.45,54.67 117.74,54.67 117.74,55.68 118.55,55.68 118.65,55.78 122.75,55.78
+VDDCR_GFX on TOP (solid shape): 62.56,132.05 62.56,132.03 62.55,131.98 62.55,131.96 62.55,131.66 62.62,131.49 62.78,131.43 63.06,131.43 63.16,131.45 63.23,131.51 63.31,131.54 63.39,131.51 63.46,131.45 63.56,131.43 63.84,131.43 63.95,131.46 64.03,131.53 64.04,131.54 64.06,131.55 64.32,131.55 64.35,131.55 64.45,131.46 64.55,131.44 64.85,131.44 65.01,131.5 65.08,131.67 65.08,131.75 65.09,131.79 65.13,131.81 70.04,131.81 70.61,131.24 70.61,128.41 70.27,128.07 66,128.07 65.49,127.56 56.98,127.56 56.88,127.66 56.88,131.98 57.19,132.29 62.32,132.29
+VDDCR_GFX on TOP (solid shape): outline of 3087 points within 55.26,99.94 69.16,119.23
+VDDCR_GFX on BOTTOM (solid shape): 62.7,132.24 62.73,132.23 62.93,132.18 63.13,132.24 65.24,132.24 65.48,132.15 65.72,132.24 67.35,132.24 67.81,131.78 67.81,131.4 67.78,131.38 67.78,129.65 68.34,129.65 68.34,131.56 68.63,131.84 70.16,131.84 70.59,131.42 70.59,128.74 69.56,127.72 60.59,127.72 60.55,127.73 60.54,127.77 60.54,127.95 59.52,127.95 59.52,127.77 59.51,127.73 59.47,127.72 59.37,127.72 58.76,127.11 56.83,127.11 56.71,127.23 56.71,131.83 57.01,132.14 59.4,132.14 59.82,131.72 59.82,131.4 59.79,131.38 59.79,129.65 60.35,129.65 60.35,131.38 60.34,131.39 60.34,131.6 61.25,132.52 62.42,132.52
+VDDCR_GFX on BOTTOM (solid shape): outline of 135 points within 58.79,103.64 60.54,107.19
+VDDCR_GFX on BOTTOM (solid shape): outline of 1499 points within 61.4,97.94 69.24,111.05
+VDDCR_GFX on SVCC (solid shape): outline of 146 points within 49.24,96.88 70.6,133.79
+VDDCR_GFX on IN2 (solid shape): outline of 6432 points within 47.49,97.96 70.6,132.47
+VDDCR_GFX on IN3 (solid shape): outline of 946 points within 57.36,98.68 68.91,105.24
+VDDCR_GFX on IN4 (solid shape): outline of 911 points within 61.57,98.52 68.95,110.77
+VDDCR_NB on TOP (solid shape): 107.73,131.19 107.73,128.76 107.94,128.55 108.22,128.55 108.37,128.55 108.47,128.45 108.47,126.52 108.25,126.3 104.69,126.3 104.36,126.63 98.36,126.63 98.13,126.85 98.13,129.06 98.29,129.21 99.84,129.21 100.01,129.39 100.01,131.66 100.05,131.7 107.22,131.7
+VDDCR_NB on TOP (solid shape): 79.75,98.95 80.3,98.95 80.47,98.78 80.53,98.78 80.57,98.74 81.26,98.74 81.37,98.63 81.37,97.74 81.36,97.71 81.34,97.7 81.24,97.64 81.16,97.56 81.14,97.54 81.12,97.53 80.41,97.53 80.38,97.55 80.36,97.59 80.36,97.76 80.27,97.85 80.26,97.87 80.26,97.89 79.92,98.35 79.5,97.97 79.5,97.94 79.37,97.81 79.36,97.81 79.26,97.77 79.18,97.71 78.75,97.71 78.64,97.82 78.64,98.63 78.64,99.13 78.83,99.32 79.38,99.32
+VDDCR_NB on TOP (solid shape): outline of 159 points within 78.22,100.3 82.5,109.17
+VDDCR_NB on BOTTOM (solid shape): 101.48,131.91 101.48,131.89 101.48,130.54 102.04,130.54 102.04,131.89 102.06,131.92 102.09,131.93 105.26,131.93 107.11,130.08 107.11,126.19 105.99,125.07 97.22,125.07 96.84,125.46 96.84,131.48 97.5,132.15 101.25,132.15
+VDDCR_NB on BOTTOM (solid shape): outline of 408 points within 78.88,98.24 81.87,107.88
+VDDCR_NB on SVCC (solid shape): 113.63,131.62 113.63,126.2 113.65,126.1 113.7,126.01 114.69,125.02 114.69,109.64 110.8,105.75 109.52,105.75 109.42,105.73 109.33,105.67 108.98,105.32 108.92,105.23 108.9,105.13 108.9,99.12 105.11,95.33 97.99,95.33 96.23,97.09 96.15,97.14 96.05,97.16 94.07,97.16 92.5,98.74 92.41,98.79 92.31,98.81 81.55,98.81 81.45,98.79 81.37,98.74 80.91,98.28 79.19,98.28 79.03,98.44 79.03,107.01 80.81,108.79 82.87,108.79 82.92,108.8 82.96,108.83 83.51,109.39 83.54,109.43 83.55,109.48 83.55,110.16 86.5,113.11 87.12,113.11 87.21,113.02 87.34,112.98 88.55,112.98 88.65,113 88.74,113.06 89.5,113.82 89.56,113.91 89.57,114.01 89.57,119.18 90.82,120.42 90.88,120.51 90.89,120.61 90.89,133.25 98.13,133.25 98.39,133.32 98.57,133.51 111.74,133.51
+VDDCR_NB on IN2 (solid shape): outline of 6570 points within 79.03,92.65 120,129.33
+VDDCR_NB on IN3 (solid shape): outline of 334 points within 78.17,98.19 82.02,107.96
+VDDCR_NB on IN4 (solid shape): outline of 686 points within 77.68,98.2 82.76,107.85
+VDDP_GFX on TOP (solid shape): outline of 102 points within 102.07,100.84 104.74,103.59
+VDDP_GFX on IN4 (solid shape): outline of 1972 points within 75.19,101.15 103.54,114.66
+VDDP_S5 on TOP (solid shape): 82.67,110.24 82.68,110.23 82.68,110.21 82.67,110.17 82.64,109.78 83.01,109.64 83.1,109.63 83.15,109.54 83.15,109.29 83.13,109.26 83.09,109.24 82.73,109.24 82.73,107.98 82.48,107.73 82.47,107.73 82.34,107.64 82.27,107.5 82.26,107.48 82.06,107.29 81.23,107.29 80.75,107.76 80.75,108.44 80.75,108.44 80.75,108.51 80.87,108.63 81.38,108.63 81.57,108.82 81.57,109.43 81.84,109.7 81.84,109.81 81.84,110.11 81.84,110.25 81.89,110.3 82.61,110.3
GND on TOP (solid shape): 7.71,4.45 7.71,2.7 7.58,2.57 6.11,2.57 6.06,2.62 6.06,4.42 6.19,4.55 7.61,4.55
GND on TOP (solid shape): 12.97,43.22 12.97,42.36 12.07,41.45 11.86,41.45 11.71,41.6 11.71,43.83 11.84,43.95 12.24,43.95
GND on TOP (solid shape): 14.41,29.08 14.41,28.22 14.1,27.91 12.97,27.91 12.71,28.16 12.71,29.06 12.85,29.2 14.29,29.2
GND on TOP (solid shape): 27.93,37.55 27.93,35.49 27.72,35.29 25.36,35.29 25.3,35.35 25.3,37.08 26.18,37.97 27.51,37.97
GND on TOP (solid shape): 41.24,123.51 41.24,120.29 41.03,120.08 37.7,120.08 37.48,120.31 37.48,123.55 37.76,123.83 40.92,123.83
GND on TOP (solid shape): 69.53,137.14 69.53,135.16 69.22,134.85 64.97,134.85 64.71,135.11 64.71,137.01 64.96,137.27 69.41,137.27
GND on TOP (solid shape): 115.53,145.42 115.53,142.04 114.69,141.2 111.52,141.2 111.09,141.64 111.09,145.37 111.52,145.8 115.15,145.8
GND on TOP (solid shape): 130.57,41.04 130.57,39.73 130.34,39.5 125.83,39.5 125.65,39.69 125.65,41.35 126.06,41.76 129.85,41.76
GND on TOP (solid shape): 150.94,63.1 150.94,60.43 150.56,60.05 141.67,60.05 140.65,61.07 140.65,63.61 141.42,64.37 149.67,64.37
GND on TOP (solid shape): 163.31,32.67 163.31,29.95 163.26,29.9 161.48,29.9 161.38,30 161.38,32.69 161.56,32.87 163.11,32.87
GND on TOP (solid shape): 168.44,73.49 168.44,70.19 168.42,70.16 165.72,70.16 165.62,70.26 165.62,73.41 165.72,73.51 168.42,73.51
GND on TOP (solid shape): 174.59,32.42 174.59,30 174.46,29.88 172.53,29.88 172.43,29.98 172.43,32.36 172.61,32.54 174.46,32.54
GND on TOP (solid shape): 176.26,123.78 176.26,122.13 175.96,121.82 171.01,121.82 170.8,122.03 170.8,123.6 171.29,124.08 175.96,124.08
GND on TOP (solid shape): 177.89,73.39 177.89,70.19 177.84,70.13 176.01,70.13 175.91,70.24 175.91,73.39 176.01,73.49 177.79,73.49
GND on TOP (solid shape): 184.81,52.58 184.81,51.8 184.63,51.62 182.51,51.62 182.3,51.83 182.3,52.83 182.56,53.09 184.3,53.09
GND on TOP (solid shape): 202.88,28.9 202.88,26.95 202.5,26.57 200.24,26.57 200.01,26.8 200.01,28.99 200.16,29.15 202.63,29.15
GND on TOP (solid shape): 245.02,31.25 245.02,28.81 244.89,28.68 243.8,28.68 243.6,28.88 243.6,31.4 243.7,31.5 244.77,31.5
GND on TOP (solid shape): 253.18,31.3 253.18,28.58 252.92,28.33 251.88,28.33 251.73,28.48 251.73,31.37 251.85,31.5 252.97,31.5
GND on TOP (solid shape): 262.73,47.24 262.73,46.51 262.67,46.45 260.48,46.45 260.35,46.57 260.35,47.44 260.95,48.04 261.93,48.04
GND on TOP (solid shape): 262.9,43.52 262.9,41.54 262.77,41.4 261,41.4 260.67,41.73 260.67,43.34 260.95,43.62 262.8,43.62
GND on TOP (solid shape): 267.73,46.08 267.73,44.56 267.65,44.48 266.18,44.48 266.05,44.61 266.05,46.08 266.18,46.21 267.6,46.21
GND on TOP (solid shape): 272.38,89.62 272.38,87.13 272.3,87.05 269.81,87.05 269.69,87.18 269.69,89.72 269.71,89.74 272.25,89.74
GND on TOP (solid shape): 272.94,82.91 272.94,81.28 272.56,80.9 272.07,80.9 271.18,81.79 271.18,82.98 271.31,83.11 272.74,83.11
GND on TOP (solid shape): 273.06,68.25 273.06,64.98 272.94,64.85 269.53,64.85 269.46,64.93 269.46,68.28 269.61,68.43 272.89,68.43
GND on TOP (solid shape): 277.74,92.03 277.74,91.24 277.56,91.06 276.34,91.06 276.24,91.17 276.24,92 276.37,92.13 277.64,92.13
GND on TOP (solid shape): 277.76,67.49 277.76,66.38 277.64,66.25 276.69,66.25 276.53,66.41 276.53,67.73 276.61,67.81 277.44,67.81
GND on TOP (solid shape): 28.06,64.45 28.55,64.45 28.72,64.28 28.72,63.49 28.31,63.08 25.48,63.08 25.31,63.25 25.31,65.05 25.39,65.13 27.38,65.13
GND on TOP (solid shape): 40.22,105.29 40.22,104.09 37.62,101.49 37.62,100.9 37.31,100.59 35.38,100.59 35.14,100.83 35.14,104.83 35.95,105.64 39.88,105.64
GND on TOP (solid shape): 50.12,13.29 50.12,11.19 49.93,11.01 49.93,8.32 49.72,8.11 41.22,8.11 40.84,8.48 40.84,13.32 40.97,13.45 49.96,13.45
GND on TOP (solid shape): 63.53,137.22 63.53,135 63.36,134.82 58.69,134.82 58.48,135.02 58.48,137.39 58.61,137.52 63.23,137.52
GND on TOP (solid shape): 71.57,56.74 71.57,55.49 71.32,55.25 68.89,55.25 68.6,55.54 68.6,56.94 68.71,57.05 71.26,57.05
GND on TOP (solid shape): 87.21,137.23 87.21,134.88 87.08,134.74 84.79,134.74 84.79,134.74 81.57,134.74 81.39,134.92 81.39,137.01 81.8,137.42 87.03,137.42
GND on TOP (solid shape): 99.67,132.23 99.67,129.56 99.63,129.52 97.97,129.52 95.18,126.74 92.09,126.74 90.14,128.69 90.14,131.9 91.78,133.53 98.37,133.53
GND on TOP (solid shape): 111.48,14.67 111.87,14.67 112.04,14.5 112.04,13.08 111.74,12.79 108.45,12.79 108.27,12.97 108.27,13.82 109.12,14.67 111.47,14.67
GND on TOP (solid shape): 142.56,50.96 142.56,47.73 142.4,47.57 139.02,47.57 138.92,47.67 138.92,50.98 139.31,51.37 142.15,51.37
GND on TOP (solid shape): 143.19,7.98 143.19,6.28 142.94,6.02 139.33,6.02 138.67,5.36 137.78,5.36 137.5,5.64 137.5,7.8 137.81,8.11 143.07,8.11
GND on TOP (solid shape): 209.53,28.81 209.53,26.69 209.38,26.54 207.11,26.54 206.98,26.67 206.98,28.81 207.07,28.9 209.44,28.9
GND on TOP (solid shape): 273.53,46.67 273.53,44.93 273.18,44.58 271.31,44.58 270.62,45.27 270.62,46.69 270.75,46.82 273.38,46.82
GND on TOP (solid shape): 265.79,64.3 265.79,62.96 265.7,62.87 265.14,62.87 265.14,62.87 264.87,62.87 264.68,63.06 264.68,63.86 265.19,64.37 265.72,64.37
GND on TOP (solid shape): 20.13,28.2 20.17,28.18 20.18,28.15 20.18,26.04 20.16,26.01 18.3,26.01 18.2,26.12 18.2,28.12 18.28,28.2
GND on TOP (solid shape): 35.45,121.39 35.45,119.98 34.96,119.5 34.61,119.5 34.09,118.98 32.67,118.98 32.47,119.18 32.47,121.51 32.85,121.88 34.95,121.88
GND on TOP (solid shape): 74.79,54.21 74.79,53.27 74.69,53.17 71.04,53.17 70.96,53.25 70.96,53.72 71.06,53.82 71.54,53.82 72.4,54.69 74.31,54.69
GND on TOP (solid shape): 104.66,98.53 104.66,97.05 103.52,95.91 99.36,95.91 98.75,96.52 98.75,98.61 98.76,98.64 98.8,98.66 104.53,98.66
GND on TOP (solid shape): 108.08,59.97 108.08,57.62 107.85,57.39 106.58,57.39 106.49,57.47 106.49,59.91 106.49,59.95 106.49,60.22 106.85,60.58 107.47,60.58
GND on TOP (solid shape): 136.77,63.53 136.77,60.23 136.46,59.92 127.79,59.92 126.1,59.92 125.87,60.15 125.87,63.56 126.05,63.73 136.56,63.73
GND on TOP (solid shape): 166.26,83.09 166.26,80.52 166.38,80.4 166.38,79.43 167.15,78.67 167.15,76.84 162.68,72.37 159.58,72.37 158,73.94 158,78.87 162.29,83.16 166.18,83.16
GND on TOP (solid shape): 179.37,92.07 179.37,89.64 179.35,89.6 179.32,89.59 178.68,89.59 178.58,89.69 178.58,92.31 178.75,92.48 178.96,92.48
GND on TOP (solid shape): 217.78,13.63 217.78,11.95 217.72,11.89 217.28,11.89 216.62,12.55 215.56,12.55 215.49,12.62 215.49,13.5 215.7,13.7 217.71,13.7
GND on TOP (solid shape): 269.02,71.8 269.02,70.95 268.9,70.84 268.1,70.84 267.94,71 267.34,71 267.25,71.1 267.25,71.72 267.44,71.91 268.91,71.91
GND on TOP (solid shape): 77.65,137.25 77.65,134.96 77.46,134.77 75.25,134.77 74.69,134.22 72.4,134.22 72.33,134.29 72.33,136.87 72.85,137.39 77.51,137.39
GND on TOP (solid shape): 138.88,67.54 138.88,66.15 138.49,65.77 137.1,65.77 136.84,66.02 134.68,66.02 134.18,65.51 133.03,65.51 132.78,65.77 132.78,67.42 133.41,68.05 138.37,68.05
GND on TOP (solid shape): 170.42,67.21 170.42,65.91 170.15,65.64 167.21,65.64 166.54,64.96 166.54,64.27 166.51,64.24 165.09,64.24 164.83,64.5 164.83,66.59 166.07,67.83 169.8,67.83
GND on TOP (solid shape): 153.84,81.77 153.84,80.66 153.54,80.36 153.39,80.36 153.37,80.33 151.14,80.33 150.96,80.52 148.13,80.52 147.52,81.13 147.44,81.13 147.44,81.13 146.42,81.13 146.22,81.33 146.22,82.13 146.4,82.31 153.3,82.31
GND on TOP (solid shape): 157.97,65.18 157.97,60.11 156.26,58.4 153.86,58.4 153.48,58.78 153.48,61.57 153.99,62.08 154.75,62.08 154.88,62.21 154.88,64.6 155.56,65.28 157.88,65.28
GND on TOP (solid shape): 69.99,109.09 69.99,108.44 70.26,108.18 70.62,108.18 70.76,108.04 70.76,107.83 70.63,107.69 70.49,107.69 70.49,107.56 70.43,107.49 70.43,107.06 70.01,106.64 69.12,106.64 69.05,106.71 69.05,109.02 69.17,109.13 69.96,109.13
GND on TOP (solid shape): 110.08,47.36 110.08,46.01 110.08,46.01 110.08,44.13 110.02,44.07 109.49,44.07 109.42,44.15 109.42,45.82 109.35,45.88 108.55,45.88 108.19,45.52 107.84,45.52 107.51,45.85 107.51,47.05 108.04,47.58 109.87,47.58
GND on TOP (solid shape): 141.29,35.58 141.29,33.16 141.9,32.55 142.55,32.55 142.69,32.42 142.69,31.04 142.33,30.69 139.82,30.69 139.21,31.3 139.21,31.3 139.01,31.5 139.01,33.29 139.9,34.18 139.9,35.47 140.12,35.69 141.19,35.69
GND on TOP (solid shape): 173.24,55.02 173.24,53.88 173.22,53.85 171.69,53.85 170.93,54.61 170.03,54.61 169.89,54.47 169.89,52.76 169.85,52.72 169.22,52.72 169.18,52.76 169.18,54.62 168.82,54.97 168.82,55.5 168.87,55.55 172.71,55.55
GND on TOP (solid shape): 108.74,54.56 108.74,51.71 108.48,51.45 107.02,51.45 106.99,51.42 106.92,51.42 106.87,51.47 106.87,52.16 106.63,52.4 106.63,52.98 106.74,53.09 107.5,53.09 107.68,53.27 107.68,54.3 108.02,54.64 108.6,54.64 108.61,54.65 108.65,54.65
GND on TOP (solid shape): 153.07,139.65 153.07,139.2 153,139.12 151.83,139.12 151.55,138.84 151.55,138.16 151.68,138.03 152.97,138.03 153.05,137.95 153.05,137.65 152.87,137.47 152.67,137.47 152.57,137.37 150.64,137.37 149.72,138.28 149.72,139.58 149.92,139.78 152.95,139.78
GND on TOP (solid shape): 155.8,73.48 156.54,73.48 156.77,73.25 156.77,72.38 156.36,71.97 154.33,71.97 154.33,71.97 154.1,71.97 151.83,69.7 144.08,69.7 143.7,70.08 143.7,72.75 144.34,73.39 147.64,73.39 147.89,73.14 149.6,73.14 149.95,73.48 155.79,73.48
GND on TOP (solid shape): 131.74,73.2 134.82,73.2 135.32,73.69 139.59,73.69 140.12,73.16 140.12,69.04 139.76,68.69 135.32,68.69 134.4,69.6 127.52,69.6 127.39,69.73 127.39,73.51 128.24,74.35 130.58,74.35
GND on TOP (solid shape): 269.89,101.43 269.89,100.11 269.75,99.97 269.17,99.97 268.9,99.71 267.19,99.71 267.12,99.78 267.12,101.34 267.19,101.42 268.93,101.42 269.23,101.71 269.6,101.71
GND on TOP (solid shape): 101.89,103.21 101.89,101 101.69,100.79 98.8,100.79 98.76,100.81 98.75,100.84 98.75,102.09 98.68,102.16 98.67,102.19 98.68,102.23 98.96,102.51 99.97,102.51 100.95,103.48 101.61,103.48
GND on TOP (solid shape): 36.08,88.57 37.97,88.57 38.09,88.54 38.21,88.52 38.49,88.52 39.89,87.13 39.89,82.89 39.48,82.48 38.04,82.48 37.61,82.91 37.61,86.26 37.07,86.8 36.76,86.8 36.68,86.88 36.19,86.88 35.57,87.49 35.57,88.19 35.98,88.6 36.05,88.6
GND on TOP (solid shape): 37.69,116.88 37.69,116.31 37.58,116.2 37.58,116.04 37.26,115.73 35.14,115.73 34.62,116.25 34.62,116.68 34.77,116.83 34.8,116.84 34.97,116.87 35.13,116.99 35.15,117 37.57,117
GND on TOP (solid shape): 172.86,36.76 172.86,35.72 172.84,35.7 171.26,35.7 171.16,35.8 171.16,36.84 171.26,36.94 171.41,36.94 171.45,36.94 171.49,36.96 171.85,36.96 171.86,36.95 171.98,36.94 172.11,36.96 172.12,36.96 172.66,36.96
GND on TOP (solid shape): 124.14,136.94 124.14,135.06 124.12,135.02 124.09,135.01 123.98,135.04 123.89,135.05 122.87,135.05 122.82,135.05 122.76,135.03 122.73,135.04 122.61,135.16 122.61,136.74 123.01,137.13 123.95,137.13
GND on TOP (solid shape): 269.17,97.03 269.17,96.4 269.46,96.12 270.55,96.12 270.64,96.03 270.64,95.52 270.47,95.35 269.66,95.35 269.59,95.35 269.51,95.35 269.18,95.35 269.16,95.35 269.14,95.36 268.86,95.65 267.2,95.65 267.06,95.79 267.06,97.28 267.13,97.34 268.86,97.34
GND on TOP (solid shape): 81.5,102.82 82.19,102.82 82.22,102.78 82.24,102.76 82.24,102.73 82.22,102.61 82.25,102.5 82.25,102.49 82.25,102.33 82.24,102.3 82.2,102.28 81.36,102.28 80.97,101.89 80.7,101.89 80.59,102 80.59,102.3 81.14,102.84 81.48,102.84
GND on TOP (solid shape): 71.41,62.41 71.95,62.41 72.35,62.82 73.27,62.82 73.32,62.77 73.32,61.59 73.67,61.23 74.47,61.23 74.99,61.75 76.47,61.75 76.57,61.65 76.57,60.08 76.44,59.95 74.05,59.95 73.27,60.74 70.19,60.74 70.09,60.63 69.51,60.63 69.33,60.81 69.33,62.29 69.43,62.39 69.86,62.39 70.14,62.67 70.14,62.97 70.24,63.07 70.75,63.07
GND on TOP (solid shape): 103.85,142.76 103.85,142.74 103.99,142.46 104.28,142.35 104.41,142.37 104.53,142.42 104.54,142.43 104.58,142.43 105.02,141.98 105.02,139.91 104.67,139.55 100.37,139.55 99.73,140.19 99.73,142.07 100.57,142.91 103.7,142.91
GND on TOP (solid shape): 176.21,86.59 176.21,86.21 177.48,84.94 177.48,82.91 176.98,82.4 173.57,82.4 173.09,81.92 172.02,81.92 171.77,82.17 171.77,84.41 172.43,85.07 173.85,85.07 174.11,85.32 174.11,85.5 174.26,85.65 174.46,85.65 174.69,85.43 174.69,84.31 174.94,84.05 175.96,84.05 176.21,84.31 176.21,85.32 175.58,85.96 175.58,86.59 175.71,86.72 176.09,86.72
GND on TOP (solid shape): 72.91,142.47 72.95,142.46 72.96,142.42 72.96,139.3 72.63,138.97 72.63,137.85 72.4,137.62 67.63,137.62 65.91,139.34 65.42,139.34 65.24,139.16 65.24,138.08 65.11,137.94 57.71,137.94 56.34,139.3 56.34,140.8 57.26,141.72 58.84,141.72 58.85,141.73 61.92,141.73 62.06,141.6 62.06,141.14 62.28,140.91 64.89,140.91 64.89,140.92 65.76,140.92 67.32,142.47
GND on TOP (solid shape): 132.06,82.87 132.06,82.14 131.97,81.9 132.05,81.66 132.06,81.64 132.06,81.56 131.94,81.45 129.38,81.45 129.27,81.34 128.17,81.34 128.06,81.44 128.06,82.5 128.07,82.51 128.08,82.63 128.07,82.74 128.06,82.75 128.06,83.06 128.36,83.35 131.58,83.35
GND on TOP (solid shape): 77.58,92.46 77.58,92.44 77.72,92.15 78.01,92.01 78.03,92.01 78.12,91.92 78.12,90.37 77.94,90.19 77.79,90.19 77.78,90.19 77.63,90.22 77.48,90.19 77.47,90.19 77.34,90.19 77.08,89.93 77.08,89.47 76.91,89.29 76.34,89.29 75.99,89.64 75.99,92.66 76.09,92.76 77.29,92.76
GND on TOP (solid shape): 72.01,110.82 72.05,110.82 72.81,110.82 72.87,110.76 72.87,110.36 72.87,110.34 72.86,110.32 72.81,110.27 72.77,110.21 72.64,110.07 72.64,109.13 72.08,108.57 71.68,108.57 71.62,108.63 71.62,109.14 71.15,109.61 70.85,109.61 70.78,109.69 70.78,110.35 70.79,110.37 70.81,110.39 70.94,110.5 71.02,110.66 71.02,110.68 71.16,110.82 71.98,110.82
GND on TOP (solid shape): 37.2,28.66 37.2,24.59 37.18,24.55 37.15,24.54 36.95,24.48 36.81,24.33 36.81,24.33 36.49,24 36.49,22.18 36.47,22.14 36.44,22.13 35.52,22.13 35.49,22.16 35.48,22.16 35.38,22.26 29.82,22.26 29.36,22.73 29.36,22.97 28.19,24.14 23.99,24.14 23.81,24.31 23.81,26.95 23.93,27.07 28.35,27.07 28.51,27.23 28.51,28.12 29.53,29.14 36.72,29.14
GND on TOP (solid shape): 60.44,119.08 60.44,114.66 60.06,114.28 59.66,114.28 59.63,114.31 59.62,114.32 59.35,114.65 58.95,114.51 58.87,114.48 58.78,114.51 58.66,114.62 58.5,114.66 58.48,114.66 58.18,114.97 58.18,119.03 58.38,119.23 60.29,119.23
GND on TOP (solid shape): 103.99,107.85 104.01,107.85 104.12,107.71 104.25,107.67 104.37,107.67 104.41,107.63 104.41,107.12 104.31,107.02 104.31,106.3 104.22,106.05 104.31,105.8 104.31,105.63 104.22,105.39 104.3,105.14 104.31,105.13 104.31,104.99 104.16,104.84 102.71,104.84 102.4,105.15 102.4,107.35 102.53,107.48 102.9,107.48 103.27,107.85
GND on TOP (solid shape): 17.21,38.38 17.21,35.83 16.89,35.51 16.33,35.51 16.16,35.33 16.16,34.32 16.21,34.27 16.3,34.27 17.29,34.27 17.35,34.33 20.07,34.33 20.35,34.04 20.35,30.61 20.18,30.43 19.55,30.43 19.34,30.64 19.34,32.3 18.48,33.16 18.48,33.25 18.23,33.51 17.72,33.51 17.29,33.08 15.05,33.08 14.55,33.57 13.87,33.57 13.27,34.17 11.39,34.17 11.29,34.27 11.29,34.83 11.39,34.93 13.37,34.93 13.42,34.98 13.42,35.36 13.37,35.41 11.34,35.41 11.32,35.44 11.32,36.15 11.34,36.17 13.27,36.17 13.47,35.97 15.28,35.97 15.79,36.47 15.79,37.87 15.79,37.87 15.79,38.63 15.84,38.68 16.91,38.68
GND on TOP (solid shape): 132.68,139.63 132.68,137.44 132.47,137.24 130.7,137.24 130.52,137.42 130.19,137.42 129.88,137.11 129.88,136.94 129.68,136.73 129.35,136.73 129.27,136.81 129.27,137.81 130.64,137.81 130.65,137.76 130.66,137.7 130.69,137.65 130.72,137.6 130.75,137.56 130.79,137.52 130.84,137.49 130.89,137.47 130.94,137.45 131,137.44 131.05,137.44 131.11,137.45 131.16,137.47 131.21,137.49 131.26,137.52 131.3,137.56 131.34,137.6 131.37,137.65 131.39,137.7 131.4,137.76 131.41,137.81 131.41,137.87 131.4,137.92 131.38,137.97 131.35,138.02 131.32,138.07 131.28,138.11 131.24,138.14 131.19,138.17 131.14,138.19 131.08,138.2 131.03,138.21 130.97,138.2 130.92,138.19 130.86,138.17 130.82,138.14 130.77,138.11 130.73,138.07 130.7,138.02 130.67,137.97 130.66,137.92 130.65,137.87 130.64,137.81 129.27,137.81 129.27,139.04 130.06,139.83 132.47,139.83
GND on TOP (solid shape): 277.61,46.69 277.61,44.49 280.83,44.49 281.33,44.99 290.38,44.99 290.56,44.64 290.82,44.35 290.86,44.28 290.83,44.2 290.62,43.88 290.54,43.5 290.54,39.3 290.68,38.8 291.04,38.43 291.04,37.75 261.14,37.75 261.14,32 261,31.86 260.26,31.86 260.13,31.99 260.13,38.77 289.6,38.77 289.54,39.03 289.53,39.3 289.53,43.5 289.54,43.74 289.58,43.98 281.75,43.98 281.25,43.48 276.6,43.48 274.64,45.43 274.64,46.46 275.17,47 277.31,47
GND on TOP (solid shape): 54.92,112.83 55.06,112.81 55.19,112.83 55.19,112.83 55.84,112.83 56.02,112.65 56.02,110.09 56.27,109.83 56.27,106.41 56.02,106.15 54.42,106.15 54.14,106.43 54.14,108.18 54.31,108.35 54.35,108.37 54.38,108.35 54.76,108.27 55.01,108.57 54.86,108.94 54.47,108.98 54.4,108.97 54.34,109.01 54.33,109.04 54.35,109.08 54.44,109.17 54.44,112.78 54.46,112.82 54.49,112.83 54.92,112.83
GND on TOP (solid shape): 269.17,106.53 269.4,106.43 269.65,106.45 269.68,106.45 269.7,106.44 269.73,106.41 269.73,106.1 269.29,105.66 267.83,105.66 267.83,104.45 267.98,104.3 270.11,104.3 270.29,104.12 270.29,103.64 270.14,103.49 268.93,103.49 268.79,103.63 268.56,103.63 268.55,103.63 268.42,103.65 268.28,103.63 268.27,103.63 267.54,103.63 267.54,103.63 267.41,103.65 267.29,103.64 267.26,103.64 267.24,103.65 266.95,103.94 266.95,106.17 267.08,106.3 267.2,106.3 267.21,106.29 267.4,106.25 267.59,106.29 267.6,106.3 268.22,106.3 268.23,106.29 268.42,106.25 268.6,106.29 268.61,106.3 268.74,106.3 268.97,106.53 269.15,106.53
GND on TOP (solid shape): 291.04,91.57 290.68,91.2 290.54,90.7 290.54,86.3 290.68,85.8 291.04,85.43 291.04,84.94 282.7,84.94 281.99,84.45 282.19,83.62 282.19,83.38 282.03,83.22 279.35,83.22 278.94,83.63 278.94,84.24 279.72,85.02 279.73,85.02 279.73,91.34 279.5,91.56 279.29,91.81 279.6,92.12 280.39,92.12 280.39,92.11 280.99,92.11 281.22,92.34 291.04,92.34
GND on TOP (solid shape): 282.19,69.98 282.19,69.74 281.99,68.91 282.7,68.42 291.04,68.42 291.04,60.9 290.64,60.56 290.38,60.11 281.33,60.11 280.83,60.61 277.61,60.61 277.61,58.6 277.24,58.23 275.08,58.23 274.69,58.61 274.69,59.33 275.59,60.23 275.59,62.12 276.64,63.16 277.09,63.16 277.78,62.48 279.14,62.48 279.49,62.13 282.36,62.13 283.86,63.64 283.86,66.56 283.53,66.9 282.7,66.9 281.59,67.19 280.76,67.98 280.07,67.98 278.95,69.11 278.95,69.84 279.25,70.13 282.04,70.13
