# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A2: length 53.5
  IN4 w0.127: v1(70.94,47.47) 70.72,47.25 70.45,47.25 70.28,47.41 70.28,47.76 70.6,48.08 70.6,48.32 70.27,48.65 70.27,49.6 69.48,50.39 69.48,57.18 68.25,58.42 68.25,61.15 68.75,61.65 68.75,65.33 70.03,66.62 70.03,83.32 70.53,83.81 70.53,86.43 70.76,86.66 70.76,89.1 70.66,89.2 70.66,91.83 70.22,92.27 70.22,92.61 70.47,92.86 v1(70.47,93.24)
  BOTTOM w0.178: v1(70.47,93.24) 70.79,93.24 U18.Y29 ; CN16.132 71.98,45.84 71.82,46 71.82,47.2 71.55,47.47 v1(70.94,47.47)
M_A_A3: length 54.6
  IN4 w0.127: v1(71.26,51.06) 70.78,51.54 70.78,57.86 70.01,58.63 70.01,60.26 70.38,60.62 70.38,65.01 71.33,65.96 71.33,82.9 72.04,83.61 72.04,86.95 71.52,87.48 71.52,93.72 71.45,93.79 71.45,95.56 72.55,96.66 72.55,96.84 72.35,97.04 72.17,97.04 71.96,96.84 71.74,96.84 71.41,97.16 71.23,97.16 71.08,97.01 71.08,96.83 71.46,96.46 71.46,96.18 70.95,95.67 70.85,95.67 v1(70.67,95.85)
  BOTTOM w0.178: v1(70.67,95.85) 71,95.85 U18.Y26 ; v1(71.26,51.06) 71.73,51.53 CN16.131
M_A_A4: length 53.1
  IN4 w0.127: v1(69.66,94.1) 70.05,93.71 70.05,93.14 69.99,93.09 69.99,92.17 70.31,91.86 70.31,89.31 69.49,88.48 69.49,88.14 69.2,87.86 69.2,87.51 69.44,87.28 69.44,86.06 70.13,85.36 70.13,84.31 69.6,83.77 69.6,66.8 68.5,65.7 68.5,61.88 67.97,61.35 67.97,58.13 69.05,57.05 69.05,50.13 69.91,49.27 69.91,47.2 v1(70.96,46.16)
  BOTTOM w0.178: v1(70.96,46.16) 70.98,46.14 CN16.128 ; v1(69.66,94.1) 70.05,94.49 U18.W28
M_A_A5: length 53.6
  IN4 w0.127: v1(70.65,93.87) 70.65,93.65 71.06,93.24 71.06,87.26 71.58,86.74 71.58,86.4 71.47,86.28 71.07,86.28 70.95,86.17 70.95,84.9 71.06,84.79 71.47,84.79 71.57,84.69 71.57,84.11 70.46,82.99 70.46,66.39 69.15,65.08 69.15,61.48 68.54,60.87 68.54,58.68 69.91,57.3 69.91,50.58 70.61,49.88 70.61,48.87 70.72,48.76 v1(70.93,48.76)
  BOTTOM w0.178: v1(70.93,48.76) 70.48,48.31 CN16.126 ; U18.W29 70.47,93.7 v1(70.65,93.87)
M_A_A6: length 54.4
  IN4 w0.127: v1(69.66,95.69) 69.46,95.69 69.19,95.43 69.19,93.18 69.76,92.61 69.76,92.08 70.08,91.76 70.08,89.4 69.26,88.58 69.26,88.24 68.97,87.95 68.97,87.42 69.16,87.23 69.16,85.88 69.91,85.13 69.91,84.49 69.17,83.75 69.17,66.98 67.32,65.13 67.32,61.79 67.71,61.4 67.71,57.7 68.52,56.9 68.52,50.04 v1(69.1,49.46)
  BOTTOM w0.178: CN16.127 70.73,51.09 v1(69.1,49.46) ; v1(69.66,95.69) 70.05,96.09 U18.W26
M_A_A7: length 54.8
  IN4 w0.127: v1(68.35,94.16) 68.73,93.78 68.73,92.99 68.7,92.96 68.7,92.04 69.56,91.18 69.56,89.53 68.96,88.93 68.38,88.93 67.91,88.46 67.91,87.57 68.3,87.17 68.3,67.34 65.26,64.3 65.26,58.98 67.65,56.59 67.65,49.73 68.95,48.43 v1(68.95,47.5)
  BOTTOM w0.178: v1(68.95,47.5) 69.1,47.5 69.48,47.12 CN16.122 ; v1(68.35,94.16) 68.81,93.7 U18.U29
M_A_A8: length 59.8
  IN4 w0.127: v1(69.45,96.6) 69.07,96.22 68.21,96.22 67.88,95.89 67.88,93.29 68.44,92.74 68.44,91.12 68.56,90.99 69.09,90.99 69.27,90.82 69.27,90.62 69.14,90.48 68.56,90.48 68.44,90.36 68.44,89.77 68.27,89.61 68.27,89.15 67.68,88.56 67.68,87.36 67.87,87.16 67.87,67.51 64.96,64.6 64.96,58.73 67.22,56.47 67.22,49.84 67.58,49.48 v1(67.58,48.57)
  BOTTOM w0.178: v1(69.45,96.6) 69.75,96.6 U18.W25 ; CN16.125 70.23,51.55 67.58,48.9 v1(67.58,48.57)
M_A_A9: length 57.3
  IN4 w0.127: v1(68.29,96.65) 67.85,96.65 67.65,96.46 67.65,93.2 68.21,92.64 68.21,92.05 68.08,91.93 67.78,91.93 67.66,91.8 67.66,91.55 67.78,91.42 68.08,91.42 68.21,91.29 68.21,89.87 68.04,89.7 68.04,89.24 67.45,88.65 67.45,86.97 67.58,86.84 67.58,86.24 67.44,86.11 67.44,67.69 64.66,64.92 64.66,58.54 66.79,56.41 66.79,49.39 v1(67.06,49.12)
  BOTTOM w0.178: U18.U26 68.84,96.1 v1(68.29,96.65) ; v1(67.06,49.12) 69.23,51.3 CN16.121
M_A_A10: length 52.8
  IN4 w0.127: v1(75.33,93.97) 75.78,93.53 75.79,93.53 75.79,92.91 75.37,92.49 75.37,91.07 74.82,90.52 74.82,85.48 75.95,84.35 75.95,66 74.67,64.73 74.67,61.66 74.48,61.47 74.48,58.73 75.35,57.86 75.35,48.29 v1(77.46,46.18)
  BOTTOM w0.178: U18.AG29 75.61,93.7 v1(75.33,93.97) ; v1(77.46,46.18) 77.48,46.16 CN16.146
M_A_A11: length 55.5
  IN4 w0.127: v1(68.98,46.18) 69.27,46.18 69.43,46.34 69.43,48.54 68.09,49.88 68.09,56.83 66.42,58.49 66.42,62.07 66.89,62.54 66.89,65.31 68.73,67.16 68.73,84.91 68.63,85.01 68.63,85.72 68.74,85.84 68.74,88.05 69.03,88.33 69.03,88.67 69.85,89.5 69.85,91.67 69.54,91.98 69.54,92.51 68.96,93.09 68.96,95.52 68.74,95.75 v2(68.36,95.75)
  BOTTOM w0.178: v2(68.36,95.75) 68.35,95.74 68.42,95.74 68.85,95.31 U18.U27 ; v1(68.98,46.18) CN16.120
M_A_A12: length 56.7
  IN4 w0.127: v1(65.45,48.53) 66.36,49.44 66.36,56.32 64.33,58.35 64.33,65.19 67.01,67.87 67.01,85.99 66.74,86.26 66.74,86.75 67.22,87.23 67.22,88.75 67.77,89.3 67.77,89.9 67.65,90.03 67.49,90.03 67.36,90.15 67.36,90.41 67.49,90.53 67.82,90.53 67.95,90.66 67.95,90.91 67.82,91.04 67.49,91.04 67.36,91.17 67.36,92.61 67.42,92.67 67.42,93.83 v1(67.05,94.2)
  BOTTOM w0.178: v1(67.05,94.2) 67.35,94.5 U18.T28 ; CN16.119 68.73,51.52 65.74,48.53 v1(65.45,48.53)
M_A_A13: length 57.5
  IN4 w0.127: v1(77.73,96.59) 77.1,95.96 77.1,93.79 76.62,93.31 76.62,92.77 76.24,92.39 76.24,85.96 77.39,84.8 77.39,65.52 76.7,64.82 76.7,56.71 76.99,56.42 76.99,53.97 77.2,53.75 77.2,49.1 v1(76.71,48.61)
  BOTTOM w0.178: v1(76.71,48.61) 77.22,48.1 79.51,48.1 80.48,47.12 80.48,46.54 CN16.158 ; U18.AK26 78.45,96.32 78.18,96.59 v1(77.73,96.59)
M_A_ALERT#: length 3.6
  TOP w0.114: v1(67.45,47.56) 67.27,47.38 R627.1
  BOTTOM w0.114: CN16.116 67.98,45.75 67.54,46.18 67.54,47.46 v1(67.45,47.56)
M_A_BS#0: length 55.1
  IN4 w0.127: v1(75.45,95.8) 75.45,95.49 76.01,94.92 76.01,92.82 75.67,92.48 75.67,90.72 75.12,90.17 75.12,85.7 76.45,84.37 76.45,65.91 75.05,64.5 75.05,62.11 75.81,61.35 75.81,56.57 75.86,56.52 75.86,48.58 76.88,47.55 v1(77.37,47.55)
  BOTTOM w0.178: CN16.150 78.48,46.52 77.45,47.55 v1(77.37,47.55) ; U18.AG26 75.75,96.1 v1(75.45,95.8)
M_A_BS#1: length 53.5
  IN4 w0.127: v1(76.69,96.56) 76.54,96.4 76,96.4 75.88,96.28 75.88,96.05 76,95.92 76.59,95.92 76.69,95.82 76.69,95.5 76.57,95.38 76.32,95.38 76.24,95.31 76.24,92.72 76.01,92.49 76.01,85.67 76.89,84.8 76.89,65.55 76.01,64.67 76.01,63.69 76.24,63.45 76.24,62.72 76.11,62.6 75.77,62.6 75.63,62.46 75.63,62.18 75.8,62.01 76.17,62.01 76.24,61.95 76.24,56.62 76.48,56.38 76.48,53.7 76.61,53.58 76.75,53.58 76.87,53.45 76.87,53.2 76.75,53.07 76.38,53.07 76.26,52.95 76.26,52.54 76.37,52.43 76.75,52.43 76.87,52.3 76.87,51.85 76.75,51.72 v1(76.48,51.72)
  BOTTOM w0.178: v1(76.69,96.56) 76.69,95.57 76.42,95.3 U18.AG27 ; v1(76.48,51.72) 76.82,51.72 77.23,52.13 CN16.145
M_A_CAS#: length 54.3
  IN4 w0.127: v1(78.98,47.58) 78.62,47.58 78.5,47.46 78.5,46.72 78.4,46.62 78.09,46.62 77.93,46.77 77.93,47.88 77.54,48.27 77.54,52.63 77.95,53.05 77.95,56.69 77.54,57.11 77.54,64.38 78.33,65.18 78.33,84.96 77.33,85.96 77.33,88.37 77.09,88.61 77.09,89.3 v1(77.63,89.84)
  BOTTOM w0.102: U18.AK29 78.45,92.73 78.21,92.49 77.96,92.49 77.7,92.24 77.7,90.93 77.54,90.77 77.54,89.93 v1(77.63,89.84)
  BOTTOM w0.178: CN16.156 79.98,46.89 79.29,47.58 v1(78.98,47.58)
M_A_CKE0: length 53.4
  IN4 w0.127: v1(65.85,94.93) 65.43,94.51 65.43,90.01 64.83,89.4 64.83,88.77 64.38,88.33 64.38,86.53 65.2,85.71 65.2,68.62 62.83,66.24 62.83,57.27 63.62,56.48 63.62,56.08 63.72,55.98 64.12,55.98 64.25,55.85 64.25,55.57 64.11,55.42 63.68,55.42 63.57,55.31 63.57,55.03 63.75,54.86 64.22,54.86 64.35,54.73 64.35,54.46 64.22,54.33 63.67,54.33 63.54,54.21 63.54,53.9 63.67,53.77 64.2,53.77 64.33,53.65 64.33,53.39 64.2,53.27 63.68,53.27 63.55,53.14 63.55,52.89 63.68,52.76 64.12,52.76 64.25,52.63 v1(64.25,51.75)
  BOTTOM w0.178: v1(65.85,94.93) 66.08,94.93 U18.P27 ; v1(64.25,51.75) 64.52,52.01 66.12,52.01 66.23,52.13 CN16.109
M_A_CKE1: length 54.2
  IN4 w0.127: v1(66.46,46.23) 66.85,46.63 66.85,47.83 66.62,48.06 65.23,48.06 64.78,48.51 64.78,49.79 64.66,49.91 64.2,49.91 64.07,50.04 64.07,50.29 64.2,50.42 64.66,50.42 64.78,50.55 64.78,55.93 63.26,57.45 63.26,66.06 65.64,68.44 65.64,86.24 65.48,86.39 65.48,88.12 65.69,88.33 65.69,88.95 65.85,89.11 65.85,89.78 65.66,89.97 65.66,93.18 v1(65.88,93.4)
  BOTTOM w0.178: v1(65.88,93.4) 66.18,93.7 U18.P29 ; CN16.110 66.48,46.21 v1(66.46,46.23)
M_A_CLK0: length 59.2
  IN4 w0.152: v1(72.76,51.08) 72.76,50.96 72.92,50.79 73.38,50.79 73.52,50.93 73.52,52.89 73.14,53.27 73.14,57.69 72.29,58.54 72.29,64.76 73.06,65.54 73.06,66.02 73.34,66.3 73.7,66.3 73.83,66.43 73.83,67.12 73.7,67.25 73.47,67.25 73.17,67.56 73.17,68.26 73.47,68.57 73.81,68.57 73.97,68.72 73.97,69.21 73.81,69.36 73.47,69.36 73.17,69.67 73.17,70.37 73.47,70.68 73.81,70.68 73.97,70.83 73.97,71.31 73.81,71.47 73.47,71.47 73.17,71.77 73.17,72.48 73.47,72.79 73.81,72.79 73.97,72.94 73.97,73.42 73.81,73.57 73.47,73.57 73.17,73.88 73.17,74.59 73.47,74.89 73.81,74.89 73.97,75.05 73.97,75.53 73.81,75.68 73.47,75.68 73.17,75.99 73.17,76.69 73.47,77 73.81,77 73.95,77.14 73.95,77.79 73.8,77.94 73.45,77.94 73.18,78.21 73.18,78.99 73.45,79.26 73.8,79.26 73.95,79.41 73.95,84.07 73,85.02 73,91.58 73.21,91.78 73.21,92.6 73.52,92.91 73.52,95.98 73.79,96.25 74.11,96.25 74.33,96.47 v1(74.33,96.6)
  BOTTOM w0.152: v1(74.33,96.6) 74.63,96.9 U18.AE25 ; v1(72.76,51.08) 72.76,50.86 72.84,50.78 73.06,50.78 73.48,51.2 73.48,51.79 73.23,52.04 CN16.137
M_A_CLK0#: length 59.1
  IN4 w0.152: v1(72.76,50.32) 72.97,50.53 73.49,50.53 73.79,50.82 73.79,53 73.41,53.38 73.41,57.8 72.56,58.65 72.56,64.65 73.33,65.43 73.33,65.91 73.45,66.03 73.81,66.03 74.09,66.32 74.09,67.23 73.81,67.52 73.58,67.52 73.43,67.67 73.43,68.15 73.58,68.3 73.92,68.3 74.23,68.61 74.23,69.32 73.92,69.62 73.58,69.62 73.43,69.78 73.43,70.26 73.58,70.41 73.92,70.41 74.23,70.72 74.23,71.42 73.92,71.73 73.58,71.73 73.43,71.89 73.43,72.37 73.58,72.52 73.92,72.52 74.23,72.83 74.23,73.53 73.92,73.84 73.58,73.84 73.43,73.99 73.43,74.48 73.58,74.63 73.92,74.63 74.23,74.94 74.23,75.64 73.92,75.95 73.58,75.95 73.43,76.1 73.43,76.58 73.58,76.74 73.92,76.74 74.22,77.03 74.22,77.9 73.91,78.21 73.56,78.21 73.44,78.32 73.44,78.88 73.56,78.99 73.91,78.99 74.22,79.3 74.22,84.18 73.27,85.13 73.27,91.47 73.47,91.67 73.47,92.49 73.79,92.8 73.79,95.87 73.9,95.98 74.08,95.98 v2(74.33,95.73)
  BOTTOM w0.152: CN16.139 73.73,51.09 73.16,50.53 72.97,50.53 v1(72.76,50.32) ; U18.AE26 74.48,95.73 v2(74.33,95.73)
M_A_CLK1: length 59.1
  IN4 w0.152: v1(73.26,47.11) 73.09,47.29 72.85,47.29 72.35,46.79 71.72,46.79 71.45,47.06 71.45,48.86 71.88,49.29 71.88,57.71 70.97,58.62 70.97,64.78 72.1,65.92 72.1,79.92 72.39,80.2 72.76,80.2 72.89,80.33 72.89,81.02 72.76,81.15 72.42,81.15 72.1,81.47 72.1,82.34 72.48,82.72 72.67,82.72 72.85,82.89 72.85,83.73 72.39,84.19 72.39,87.02 71.76,87.65 71.76,92.58 72.32,93.14 72.32,95.94 72.58,96.19 72.76,96.19 v1(73.04,96.47)
  BOTTOM w0.152: v1(73.04,96.47) 73.4,96.1 U18.AD26 ; v1(73.26,47.11) 73.44,47.29 73.73,47.29 73.81,47.21 73.81,46.54 73.6,46.33 73.6,46.04 73.48,45.92 CN16.138
M_A_CLK1#: length 59.1
  IN4 w0.152: v2(73.04,95.6) 73.04,95.8 72.9,95.93 72.69,95.93 72.59,95.83 72.59,93.03 72.03,92.47 72.03,87.76 72.65,87.14 72.65,84.31 73.11,83.85 73.11,82.78 72.78,82.45 72.6,82.45 72.37,82.22 72.37,81.58 72.53,81.41 72.87,81.41 73.15,81.13 73.15,80.22 72.87,79.94 72.5,79.94 72.37,79.8 72.37,65.81 71.23,64.67 71.23,58.73 72.15,57.82 72.15,49.18 71.72,48.75 71.72,47.17 71.83,47.06 72.24,47.06 72.74,47.55 73.18,47.55 73.26,47.63 v1(73.26,47.88)
  BOTTOM w0.152: CN16.140 73.98,45.92 73.86,46.04 73.86,46.22 74.07,46.44 74.07,47.31 73.83,47.55 73.4,47.55 73.26,47.69 v1(73.26,47.88) ; U18.AD27 73.34,95.3 v2(73.04,95.6)
M_A_CLK2: length 2.1
  TOP w0.114: v1(71.89,94.6) 72.39,94.1 TP104.1
  BOTTOM w0.178: U18.AB28 71.99,94.5 v1(71.89,94.6)
M_A_CLK3: length 1.4
  TOP w0.114: TP105.1 72.77,97.27 v1(72.77,97.42)
  BOTTOM w0.178: U18.AB25 72.77,97.22 v1(72.77,97.42)
M_A_DM0: length 84.8
  IN4 w0.102: 46.16,101.83 47.05,102.72
  IN4 w0.127: v1(41.99,46.2) 41.99,45.96 42.65,45.3 42.65,45.07 42.44,44.86 42.18,44.86 41.95,45.09 40.74,45.09 40.61,45.21 40.61,45.51 40.74,45.64 41.16,45.64 41.29,45.77 41.29,46.02 41.16,46.15 40.86,46.15 40.73,46.28 40.73,46.53 40.86,46.66 41.16,46.66 41.29,46.79 41.29,47.04 41.16,47.17 40.86,47.17 40.73,47.29 40.73,47.63 40.5,47.86 40.5,50.2 39.89,50.81 39.89,51.66 39.29,52.25 38.19,52.25 37.88,52.57 37.88,59.06 36.83,60.1 36.83,63.8 37.87,64.84 38.05,64.84 38.15,64.74 38.33,64.74 38.51,64.92 38.51,65.1 38.41,65.2 38.41,65.38 38.59,65.56 38.77,65.56 38.87,65.46 39.05,65.46 39.23,65.64 39.23,65.82 39.13,65.92 39.13,66.1 39.4,66.37 39.4,84.79 40.26,85.65 40.26,94.98 43.47,98.2 43.47,99.14 46.16,101.83 ; 47.05,102.72 48.22,102.72 49.36,103.87 51.21,103.87 51.97,103.1 57.61,103.1 57.91,102.8 v1(58.42,102.8)
  BOTTOM w0.178: CN16.12 41.98,46.18 v1(41.99,46.2) ; v1(58.42,102.8) 58.42,102.75 58.75,102.42 U18.E19
M_A_DM1: length 65.7
  IN4 w0.127: v1(54.8,99.08) 53.85,98.13 50.84,98.13 50.46,97.75 50.46,96.93 49.95,96.42 49.95,95.28 48.91,94.24 48.91,92.46 47.82,91.37 47.82,87.23 47.66,87.07 46.95,87.07 46.83,86.95 46.83,86.69 46.95,86.57 47.66,86.57 47.79,86.44 47.79,86.19 47.66,86.06 46.91,86.06 46.78,85.93 46.78,85.68 46.91,85.55 47.66,85.55 47.79,85.42 47.79,85.17 47.66,85.04 46.91,85.04 46.78,84.92 46.78,84.66 46.91,84.53 47.66,84.53 47.79,84.41 47.79,84.15 47.66,84.03 46.91,84.03 46.78,83.9 46.78,83.65 46.91,83.52 47.66,83.52 47.79,83.39 47.79,81.13 45.87,79.21 45.87,66.47 46.72,65.62 46.72,57.54 47.4,56.86 47.4,51.73 v1(47.31,51.64)
  BOTTOM w0.102: U18.D21 57.21,99.46 57.21,99.43 56.68,98.9 56.22,98.9 56.15,98.83 55.75,98.83 55.5,99.08 v1(54.8,99.08)
  BOTTOM w0.178: v1(47.31,51.64) 47.23,51.72 CN16.33
M_A_DM2: length 66.7
  IN4 w0.127: v1(52.48,46.2) 51.47,47.2 51.47,52.06 51.62,52.2 51.62,58.53 51.32,58.83 51.32,71.33 55.3,75.3 55.3,78.49 51.88,81.91 51.88,85.59 52.74,86.45 52.74,91.87 55.15,94.28 55.15,95.09 55.76,95.7 55.76,97.5 56.86,98.61 57.7,98.61 58.05,98.96 58.05,99.24 58.35,99.53 58.69,99.53 58.73,99.5 60.53,99.5 60.64,99.61 62.54,99.61 v1(62.78,99.85)
  BOTTOM w0.178: CN16.54 52.48,46.19 v1(52.48,46.2) ; U18.K21 62.85,99.92 v1(62.78,99.85)
M_A_DM3: length 57
  IN4 w0.127: v1(59.83,93.85) 59.57,93.6 59.57,93.09 59.93,92.73 60.62,92.73 60.83,92.52 60.83,92.05 60.7,91.92 60.49,91.92 60.36,91.79 60.36,91.57 60.52,91.41 60.7,91.41 60.83,91.28 60.83,89.43 60.43,89.03 60.43,85.16 60.56,85.03 60.56,82.99 61.78,81.78 61.78,72.62 58.87,69.71 58.87,58.07 58.74,57.94 58.51,57.94 58.38,57.81 58.38,57.56 58.51,57.43 58.74,57.43 58.87,57.3 58.87,57.05 58.74,56.92 58.51,56.92 58.38,56.8 58.38,56.54 58.51,56.42 58.74,56.42 58.87,56.29 58.87,56.03 58.74,55.91 58.51,55.91 58.38,55.78 58.38,55.53 58.51,55.4 58.74,55.4 58.87,55.27 58.87,55.02 58.74,54.89 58.51,54.89 58.38,54.76 58.38,54.51 58.51,54.38 58.74,54.38 58.87,54.26 58.87,54 58.74,53.88 58.5,53.88 58.38,53.75 58.38,53.49 58.5,53.37 58.74,53.37 58.87,53.24 58.87,52.99 58.74,52.86 58.56,52.86 58.43,52.73 58.43,52.48 58.56,52.35 58.74,52.35 58.87,52.22 58.87,51.54 59.23,51.18 59.23,50.8 58.81,50.38 58.55,50.38 58.44,50.48 58.44,51.04 v1(58.55,51.16)
  BOTTOM w0.178: v1(58.55,51.16) 58.34,50.95 58.34,50.54 58.23,50.43 57.84,50.43 57.73,50.53 CN16.75 ; U18.F29 59.4,93.85 v1(59.83,93.85)
M_A_DM4: length 52.9
  IN4 w0.127: v1(85.97,46.92) 85.31,46.92 85.08,47.15 85.08,48.66 84.16,49.58 84.16,53.78 83.78,54.16 83.78,64.54 83.71,64.61 83.71,72.03 83.12,72.62 83.12,85.59 83.5,85.97 83.5,88.64 83.22,88.92 83.22,90.35 82.46,91.11 82.46,92.36 82.17,92.66 82.17,93.49 81.49,94.17 v1(81.49,94.38)
  BOTTOM w0.178: v1(85.97,46.92) 85.48,46.43 CN16.178 ; U18.AP28 82.02,94.47 81.59,94.47 v1(81.49,94.38)
M_A_DM5: length 59.3
  IN4 w0.127: v1(91.24,51.12) 91.53,51.12 91.67,51.26 91.67,55.38 91.68,55.38 92.49,56.2 92.49,57.59 91.9,58.19 91.9,60.78 92.02,60.91 92.27,60.91 92.39,61.04 92.39,61.29 92.27,61.42 91.71,61.42 91.58,61.54 91.58,61.8 91.71,61.93 92.27,61.93 92.39,62.05 92.39,62.31 92.27,62.43 92.02,62.43 91.9,62.56 91.9,62.81 92.02,62.94 92.27,62.94 92.39,63.07 92.39,63.32 92.27,63.45 92.02,63.45 91.9,63.58 91.9,63.83 92.02,63.96 92.27,63.96 92.39,64.08 92.39,64.34 92.27,64.47 91.89,64.47 91.76,64.59 91.76,64.85 91.89,64.97 92.27,64.97 92.39,65.1 92.39,65.35 92.27,65.48 91.83,65.48 91.71,65.61 91.71,65.87 91.83,65.99 92.62,65.99 92.85,66.22 92.85,71.79 92.72,71.91 92.24,71.91 92.11,72.04 92.11,72.34 92.24,72.47 92.67,72.47 92.8,72.6 92.8,72.93 92.7,73.03 91.88,73.03 89.6,75.3 89.6,79.72 90.55,80.67 90.55,85.84 90.44,85.96 90.44,90.35 88.63,92.16 88.63,92.66 86.26,95.03 86.08,95.03 v1(85.62,95.5)
  BOTTOM w0.178: v1(85.62,95.5) 85.35,95.77 U18.AV26 ; v1(91.24,51.12) 90.73,51.63 CN16.199
M_A_DM6: length 70.9
  IN4 w0.127: v2(83.25,99.21) 83.74,99.7 88.28,99.7 89.64,98.35 92.17,98.35 97.42,93.09 97.42,91.22 96.86,90.66 96.86,89.82 96.49,89.44 96.49,83.58 100.33,79.74 100.33,74.06 98.61,72.34 98.61,65.18 98.84,64.95 98.84,54.41 97.22,52.79 97.22,49.2 97.65,48.77 97.65,46.87 96.97,46.19 v1(95.98,46.19)
  BOTTOM w0.178: U18.AR22 83.25,99.5 v2(83.25,99.21) ; v1(95.98,46.19) CN16.220
M_A_DM7: length 74.3
  IN4 w0.127: v1(93.32,99.99) 93.63,100.31 95.21,100.31 95.89,99.64 95.89,99.33 100.51,94.71 100.51,94.53 101.28,93.76 101.28,84.35 104.21,81.42 104.21,61.91 104.09,61.78 103.91,61.78 103.78,61.65 103.78,61.4 103.91,61.27 104.09,61.27 104.21,61.15 104.21,58.3 104.09,58.17 103.68,58.17 103.55,58.04 103.55,57.77 103.68,57.64 104.33,57.64 104.46,57.51 104.46,57.26 104.33,57.13 103.68,57.13 103.55,57.01 103.55,56.75 103.68,56.63 104,56.63 104.13,56.5 104.13,56.24 104,56.12 103.68,56.12 103.55,55.99 103.55,55.74 103.68,55.61 103.78,55.61 103.9,55.48 103.9,55.23 103.78,55.1 103.68,55.1 103.55,54.97 103.55,54.56 103.71,54.41 103.95,54.41 104.08,54.28 104.08,53.97 103.96,53.85 103.68,53.85 103.55,53.73 103.55,53.1 102.5,52.05 102.5,48.94 102.39,48.82 102.08,48.82 101.94,48.96 v1(101.94,50.93)
  BOTTOM w0.102: U18.BC22 89,99.35 92.67,99.35 v1(93.32,99.99)
  BOTTOM w0.178: v1(101.94,50.93) 101.94,49.99 101.82,49.87 101.36,49.87 101.23,49.99 CN16.241
M_A_DQ0: length 85.3
  IN4 w0.127: v1(39.99,47.5) 37.65,47.5 36.58,48.57 36.58,58.52 35.54,59.56 35.54,65.28 38.1,67.84 38.1,85.32 38.82,86.05 38.82,88.95 38.44,89.33 38.44,92.28 38.95,92.79 38.95,95.51 41.43,97.99 41.43,99.1 46.54,104.21 46.54,104.7 47.16,105.32 50.43,105.32 50.83,104.92 55.03,104.92 56.15,103.81 58.14,103.81 58.25,103.69 59.83,103.69 60.04,103.48 61.1,103.48 v1(61.64,102.94)
  BOTTOM w0.178: v1(39.99,47.5) 40.98,46.52 CN16.8 ; v1(61.64,102.94) 61.18,103.4 U18.H17
M_A_DQ1: length 85.8
  IN4 w0.127: v1(39.98,46.21) 38.33,46.21 36.15,48.39 36.15,58.34 35.11,59.38 35.11,65.46 37.67,68.02 37.67,85.5 38.39,86.23 38.39,88.77 38.01,89.15 38.01,92.51 38.52,93.02 38.52,95.69 41,98.17 41,99.28 45.89,104.16 45.89,104.93 47.24,106.29 50.4,106.29 51.19,105.5 55.13,105.5 56.08,104.55 61.08,104.55 v1(61.55,104.08)
  BOTTOM w0.178: v1(39.98,46.21) CN16.4 ; v1(61.55,104.08) 61.55,103.84 61.95,103.43 U18.J17
M_A_DQ2: length 84.9
  IN4 w0.127: v1(59.25,101.72) 59.11,101.72 58.62,101.23 57.69,101.23 57.34,100.87 56.65,100.87 55.76,101.76 51.77,101.76 51.1,101.09 49.4,101.09 48.57,100.27 47.93,100.27 45.71,98.04 45.71,97.2 42.42,93.91 42.42,84.76 41.55,83.89 41.55,64.84 41.31,64.59 41.31,58.45 40.71,57.85 40.71,53.94 42.74,51.92 42.74,49.38 42.94,49.18 43.93,49.18 44.23,48.87 44.23,46 44.54,45.7 47.38,45.7 47.5,45.57 47.5,45.22 47.38,45.09 43.7,45.09 43.08,45.71 43.08,46.47 v1(43.52,46.92)
  BOTTOM w0.178: U18.F20 59.55,101.35 59.25,101.65 v1(59.25,101.72) ; v1(43.52,46.92) 43.98,46.46 CN16.20
M_A_DQ3: length 85.2
  IN4 w0.127: v1(43.27,50.27) 43.55,49.99 43.73,49.99 43.88,50.14 43.88,52.02 43.3,52.61 43.3,53.4 43.17,53.53 42.36,53.53 42.23,53.65 42.23,53.91 42.36,54.03 43.17,54.03 43.3,54.16 43.3,54.42 43.17,54.54 42.36,54.54 42.23,54.67 42.23,54.92 42.36,55.05 43.17,55.05 43.3,55.18 43.3,55.43 43.17,55.56 42.36,55.56 42.23,55.69 42.23,55.94 42.36,56.07 43.17,56.07 43.3,56.19 43.3,56.52 43.13,56.68 42.36,56.68 42.23,56.81 42.23,57.08 42.38,57.23 42.58,57.23 42.69,57.33 42.69,57.74 42.58,57.84 42.28,57.84 42.13,57.99 42.13,58.25 42.25,58.37 42.58,58.37 42.69,58.48 42.69,60.75 42.56,60.87 42.3,60.87 42.18,61 42.18,61.25 42.3,61.38 42.56,61.38 42.69,61.51 42.69,64.68 42.42,64.95 42.42,83.53 43.28,84.4 43.28,88.32 44.38,89.41 44.38,92.82 45.41,93.85 45.41,95.37 46.65,96.61 46.65,97.76 48.22,99.33 48.66,99.33 49.83,100.5 51.34,100.5 51.86,101.02 54.39,101.02 54.78,100.62 55.81,100.62 56.03,100.4 57.55,100.4 57.9,100.76 58.85,100.76 59.15,101.06 61.52,101.06 61.79,100.79 62.79,100.79 63.25,100.33 63.69,100.33 63.86,100.51 63.86,101.06 63.57,101.35 61.95,101.35 v1(61.73,101.57)
  BOTTOM w0.178: v1(61.73,101.57) 61.16,101 U18.H20 ; v1(43.27,50.27) 44.23,51.23 CN16.21
M_A_DQ4: length 85.7
  IN4 w0.127: v1(59.07,102.82) 59.07,103.09 58.94,103.22 57.9,103.22 57.78,103.34 54.15,103.34 54.02,103.46 54.02,103.67 53.89,103.79 53.64,103.79 53.51,103.67 53.51,103.46 53.38,103.34 53.13,103.34 53,103.46 53,103.85 52.88,103.98 52.62,103.98 52.5,103.85 52.5,103.46 52.37,103.34 52.16,103.34 51.38,104.11 48.96,104.11 48.35,103.5 48.06,103.5 47.96,103.6 47.96,103.73 47.82,103.87 47.21,103.87 46.54,103.2 46.54,102.98 42.3,98.74 42.3,97.63 39.83,95.16 39.83,92.05 39.31,91.52 39.31,89.97 39.69,89.58 39.69,85.69 38.96,84.97 38.96,67.48 38.52,67.03 38.52,66.92 38.82,66.62 38.82,66.4 38.62,66.2 38.44,66.2 38.15,66.49 37.97,66.49 37.79,66.31 37.79,66.13 38.08,65.84 38.08,65.66 37.9,65.48 37.72,65.48 37.43,65.77 37.25,65.77 37.07,65.59 37.07,65.41 37.36,65.12 37.36,64.94 37.18,64.76 37.01,64.76 36.88,64.89 36.66,64.89 36.4,64.63 36.4,59.92 37.45,58.88 37.45,52.11 37.67,51.89 37.92,51.89 38.08,51.73 38.08,51.47 38,51.38 37.64,51.38 37.45,51.19 37.45,50.96 37.57,50.83 39.23,50.83 39.36,50.96 39.36,51.22 39.23,51.34 v1(38.67,51.34)
  BOTTOM w0.178: CN16.3 39.73,50.66 39.55,50.47 38.19,50.47 38.06,50.6 38.06,51.22 38.19,51.34 v1(38.67,51.34) ; U18.E17 59.07,103.08 v1(59.07,102.82)
M_A_DQ5: length 85.5
  IN4 w0.127: v1(40.08,49.27) 40.08,48.06 39.96,47.94 39.66,47.94 39.57,48.03 39.57,49.71 39.49,49.79 39.49,50.24 39.32,50.4 37.23,50.4 37.01,50.62 37.01,58.7 35.97,59.74 35.97,65.1 38.53,67.66 38.53,85.14 39.26,85.87 39.26,89.13 38.88,89.51 38.88,92.05 39.4,92.58 39.4,95.34 41.87,97.81 41.87,98.92 47.22,104.27 47.56,104.27 48.19,104.89 48.94,104.89 49.47,104.36 54.41,104.36 55.2,103.57 57.98,103.57 58.09,103.45 59.74,103.45 v1(60.38,102.82)
  BOTTOM w0.178: CN16.7 40.73,49.4 40.6,49.27 v1(40.08,49.27) ; v1(60.38,102.82) 59.79,103.4 U18.F17
M_A_DQ6: length 84.7
  IN4 w0.127: v1(43.24,51.64) 43.24,52.05 43.02,52.28 41.75,53.55 41.75,54.07 41.62,54.2 41.34,54.2 41.21,54.33 41.21,54.58 41.34,54.71 41.62,54.71 41.75,54.83 41.75,55.09 41.62,55.22 41.29,55.22 41.16,55.34 41.16,55.6 41.29,55.72 41.62,55.72 41.75,55.85 41.75,56.1 41.62,56.23 41.26,56.23 41.14,56.36 41.14,56.61 41.26,56.74 41.62,56.74 41.75,56.87 41.75,57.12 41.62,57.25 41.26,57.25 41.14,57.37 41.14,57.63 41.26,57.76 41.62,57.76 41.75,57.88 41.75,64.5 41.99,64.74 41.99,83.71 42.85,84.58 42.85,88.5 43.17,88.81 43.17,89.11 42.93,89.34 42.93,93.81 43.04,93.92 43.29,93.92 43.44,93.77 43.44,89.59 43.57,89.47 43.82,89.47 43.95,89.59 43.95,93.4 44.08,93.53 44.46,93.53 44.68,93.75 44.68,93.95 44.59,94.04 43.9,94.04 43.7,94.24 43.7,94.58 44.8,95.68 45.11,95.68 46.14,96.71 46.14,97.86 48.06,99.78 48.6,99.78 49.61,100.79 51.22,100.79 51.94,101.52 55.51,101.52 56.39,100.64 57.44,100.64 57.8,100.99 58.74,100.99 59.04,101.29 60.99,101.29 61.3,101.61 61.3,101.99 61.43,102.11 61.89,102.11 62.02,102.24 62.02,102.64 v1(62.31,102.93)
  BOTTOM w0.178: CN16.17 43.23,51.66 v1(43.24,51.64) ; v1(62.31,102.93) 62.72,102.93 U18.K18
M_A_DQ7: length 85.2
  IN4 w0.127: v1(57.16,101.29) 56.92,101.29 56.06,102.16 51.54,102.16 51.34,101.95 49.35,101.95 48.17,100.77 47.83,100.77 45.28,98.22 45.28,97.38 41.99,94.09 41.99,84.94 41.12,84.07 41.12,65.03 40.86,64.76 40.86,62.11 40.74,62 40.49,62 40.36,61.87 40.36,61.58 40.47,61.47 40.73,61.47 40.86,61.34 40.86,61.06 40.73,60.93 40.53,60.93 40.4,60.8 40.4,60.55 40.53,60.42 40.78,60.42 40.91,60.29 40.91,60.04 40.78,59.91 40.53,59.91 40.4,59.79 40.4,59.53 40.53,59.4 40.65,59.4 40.78,59.28 40.78,58.73 40.28,58.23 40.28,53.71 40.11,53.54 40.11,53.36 40.29,53.18 40.47,53.18 40.62,53.33 40.8,53.33 40.98,53.15 40.98,52.97 40.83,52.82 40.83,52.64 41.01,52.46 41.19,52.46 41.34,52.61 41.52,52.61 42.38,51.74 42.38,51.55 42.25,51.42 42,51.42 41.87,51.29 41.87,51.04 42,50.91 42.25,50.91 42.38,50.78 42.38,50.53 42.25,50.4 42,50.4 41.87,50.28 41.87,50.02 42,49.89 42.25,49.89 42.38,49.77 42.38,49.51 42.25,49.38 41.6,49.38 40.91,48.69 40.91,48.16 41.09,47.98 41.48,47.98 42.3,48.8 43.7,48.8 43.83,48.67 43.83,48.32 43.7,48.19 43.02,48.19 42.89,48.06 42.89,47.81 42.96,47.73 42.96,46.99 42.77,46.79 42.55,46.79 42.41,46.94 42.41,47.4 42.28,47.53 v1(42,47.53)
  BOTTOM w0.178: v1(57.16,101.29) 57.16,101.29 57.16,101.1 57.64,100.62 58.37,100.62 U18.E20 ; v1(42,47.53) 42.98,46.55 CN16.16
M_A_DQ8: length 65.6
  IN4 w0.127: v1(45.23,51.75) 45.23,52.39 45.24,52.41 45.24,53.14 45.11,53.26 44.87,53.26 44.74,53.39 44.74,53.64 44.87,53.77 45.11,53.77 45.24,53.9 45.24,54.15 45.11,54.28 44.72,54.28 44.59,54.41 44.59,54.66 44.72,54.79 45.11,54.79 45.24,54.91 45.24,55.17 45.11,55.3 44.72,55.3 44.59,55.42 44.59,55.68 44.72,55.8 45.11,55.8 45.24,55.93 45.24,56.38 43.93,57.69 43.93,65.67 43.71,65.89 43.71,80.47 43.84,80.6 44.08,80.6 44.2,80.72 44.2,80.98 44.08,81.11 43.84,81.11 43.71,81.23 43.71,81.49 43.84,81.61 44.04,81.61 44.17,81.74 44.17,81.99 44.04,82.12 43.84,82.12 43.71,82.25 43.71,83 44.16,83.44 44.51,83.44 44.58,83.51 44.58,87.78 45.68,88.88 45.68,92.28 46.7,93.31 46.7,94.83 47.94,96.07 47.94,97.22 48.98,98.26 49.23,98.26 49.63,98.66 50.5,99.52 55.44,99.52 55.56,99.65 55.56,99.9 55.44,100.03 54.34,100.03 54.2,100.17 v1(54.2,100.57)
  BOTTOM w0.102: v1(54.2,100.57) 54.57,100.2 U18.A21
  BOTTOM w0.178: v1(45.23,51.75) 45.23,51.75 CN16.25
M_A_DQ9: length 66.7
  IN4 w0.127: v1(45.25,50.45) 45.52,50.45 45.67,50.6 45.67,56.53 44.87,57.33 44.87,61.63 44.74,61.75 44.46,61.75 44.34,61.88 44.34,62.13 44.46,62.26 44.74,62.26 44.87,62.39 44.87,65.44 44.15,66.16 44.15,80.06 44.69,80.6 44.69,80.73 44.82,80.86 44.93,80.86 45.05,80.99 45.05,81.32 44.93,81.44 44.77,81.44 44.64,81.57 44.64,81.82 44.77,81.95 44.93,81.95 45.05,82.08 45.05,82.33 44.93,82.46 44.31,82.46 44.18,82.59 44.18,82.84 44.31,82.97 44.93,82.97 45.05,83.09 45.05,87.64 46.11,88.7 46.11,92.1 47.14,93.13 47.14,94.65 48.4,95.92 48.4,97.07 49.31,97.98 49.49,97.98 50.55,99.05 51.16,99.05 v1(51.19,99.07)
  BOTTOM w0.102: 55.31,99.95 55.41,99.84 55.68,99.84 55.74,99.91 56.16,99.91 56.22,99.84 56.79,99.84 U18.C21
  BOTTOM w0.108: 55.31,99.95 52.06,99.95
  BOTTOM w0.178: v1(45.25,50.45) 46.23,51.43 CN16.29 ; 52.06,99.95 50.85,99.95 50.72,99.82 50.72,99.2 50.85,99.07 v1(51.19,99.07)
M_A_DQ10: length 65.8
  IN4 w0.127: v1(54.33,97.71) 54.33,96.02 52.76,94.46 51.11,94.46 50.26,93.61 50.26,91.83 49.57,91.15 49.57,89.36 49.7,89.24 50.23,89.24 50.41,89.06 50.41,87.51 49.57,86.68 49.57,80.47 47.6,78.49 47.6,74.57 47.73,74.44 48.47,74.44 48.58,74.33 48.58,73.9 48.45,73.77 47.73,73.77 47.6,73.64 47.6,73.39 47.73,73.26 48.45,73.26 48.58,73.13 48.58,72.88 48.45,72.75 47.73,72.75 47.6,72.63 47.6,72.37 47.73,72.25 48.6,72.25 48.73,72.12 48.73,71.86 48.6,71.74 47.73,71.74 47.6,71.61 47.6,71.36 47.73,71.23 48.6,71.23 48.73,71.1 48.73,70.85 48.6,70.72 47.73,70.72 47.6,70.59 47.6,70.34 47.73,70.21 48.6,70.21 48.73,70.09 48.73,69.83 48.6,69.71 47.73,69.71 47.6,69.58 47.6,69.32 47.73,69.2 48.45,69.2 48.58,69.07 48.58,64.8 48.27,64.49 48.27,61.93 48.81,61.4 48.81,58.05 49.19,57.66 49.19,51.85 v1(49.13,51.79)
  BOTTOM w0.102: v1(54.33,97.71) 54.69,98.07 55.79,98.07 56.02,98.29 56.49,98.29 56.8,98.6 U18.C23
  BOTTOM w0.178: v1(49.13,51.79) 49.23,51.89 CN16.41
M_A_DQ11: length 66.6
  IN4 w0.127: v1(49.11,50.45) 49.21,50.35 49.21,49.87 49.09,49.74 48.76,49.74 48.63,49.87 48.63,51.2 48.69,51.26 48.69,57.68 48.45,57.92 48.45,61.17 47.87,61.75 47.87,66.73 48.15,67.01 48.15,67.44 48.02,67.57 47.28,67.57 47.17,67.68 47.17,68 47.3,68.13 48.02,68.13 48.15,68.26 48.15,68.51 48.02,68.64 47.3,68.64 47.17,68.77 47.17,78.67 49.11,80.62 49.11,86.97 49.44,87.3 49.44,88.85 49.11,89.18 49.11,91.1 49.87,91.86 49.87,93.68 51.02,94.83 52.79,94.83 53.63,95.67 53.63,96.22 53.48,96.37 52.59,96.37 52.4,96.55 52.4,96.91 52.55,97.06 52.89,97.06 53.02,97.19 v1(53.02,97.71)
  BOTTOM w0.102: v1(53.02,97.71) 53.03,97.71 53.82,96.92 54.76,96.92 55.04,97.21 55.04,97.21 55.34,97.51 55.34,97.51 55.81,97.51 55.82,97.5 56.08,97.5 56.42,97.84 56.42,97.9 56.75,98.22 57.57,98.22 U18.D23
  BOTTOM w0.178: CN16.37 48.23,51.33 v1(49.11,50.45)
M_A_DQ12: length 66.9
  IN4 w0.127: v1(44.98,46.18) 44.58,46.59 44.58,49.14 44.37,49.34 44.37,52.24 43.73,52.89 43.73,56.67 43.09,57.3 43.09,65.4 42.85,65.65 42.85,83.35 43.72,84.22 43.72,88.14 44.81,89.24 44.81,92.64 45.84,93.67 45.84,95.19 47.08,96.43 47.08,97.58 48.42,98.92 48.87,98.92 50.16,100.21 51.84,100.21 v1(52.21,100.59)
  BOTTOM w0.102: U18.B20 56.45,100.7 55.8,100.7 55.79,100.71 55.29,100.71 55.25,100.68 54.99,100.68 54.45,101.22 53.43,101.22 53.19,100.98 52.61,100.98 v1(52.21,100.59)
  BOTTOM w0.178: v1(44.98,46.18) CN16.24
M_A_DQ13: length 66.1
  IN4 w0.127: v1(53.55,100.58) 52.84,99.86 50.33,99.86 49.05,98.59 48.7,98.59 47.51,97.4 47.51,96.25 46.27,95.01 46.27,93.49 45.24,92.46 45.24,89.06 44.15,87.96 44.15,84.04 43.28,83.17 43.28,65.74 43.55,65.47 43.55,57.46 44.16,56.85 44.16,53.12 44.81,52.47 44.81,49.48 45,49.29 v1(45,47.5)
  BOTTOM w0.102: U18.B21 56,100.2 55.7,100.5 55.41,100.5 55.33,100.42 54.95,100.42 54.35,101.01 53.99,101.01 v1(53.55,100.58)
  BOTTOM w0.178: CN16.28 45.98,46.52 v1(45,47.5)
M_A_DQ14: length 66.2
  IN4 w0.127: v1(52.37,97.71) 52.37,97.37 52.22,97.21 51.55,97.21 51.42,97.09 51.42,96.77 50.76,96.12 50.76,95.08 49.54,93.86 49.54,92.05 48.68,91.19 48.68,80.79 46.74,78.85 46.74,67.28 47.54,66.48 47.54,58.07 48.26,57.35 48.26,50.59 47.89,50.22 47.89,48.52 48.02,48.39 48.4,48.39 48.53,48.52 48.53,48.85 48.68,49 50.36,49 50.48,48.87 50.48,48.34 50.1,47.95 49.68,47.95 49.6,48.03 49.6,48.2 49.46,48.34 49.16,48.34 49,48.18 v1(49,47.66)
  BOTTOM w0.102: v1(52.37,97.71) 52.93,98.27 55.7,98.27 56.03,98.6 U18.B23
  BOTTOM w0.178: v1(49,47.66) 48.48,47.14 CN16.38
M_A_DQ15: length 65.8
  IN4 w0.127: v1(49.48,46.18) 49.48,45.79 49.59,45.67 50.28,45.67 50.45,45.5 50.45,45.25 50.27,45.06 48.58,45.06 48.42,45.22 48.42,47.24 47.41,48.25 47.41,50.37 47.83,50.79 47.83,57.22 47.13,57.92 47.13,66.12 46.3,66.94 46.3,79.03 48.25,80.97 48.25,91.22 49.21,92.18 49.21,94.06 50.33,95.18 50.33,96.24 50.89,96.8 v1(50.89,97.54)
  BOTTOM w0.102: v1(50.89,97.54) 51.82,98.47 55.42,98.47 U18.A23
  BOTTOM w0.178: v1(49.48,46.18) CN16.42
M_A_DQ16: length 66.1
  IN4 w0.127: v1(60.11,100.37) 59.71,99.98 59.04,99.98 58.97,100.05 58.2,100.05 57.84,99.69 57.11,99.69 55.26,97.84 55.26,95.95 53.57,94.26 53.57,93.46 52.11,92 52.11,89.6 51.82,89.32 51.82,86.57 50.87,85.62 50.87,81.7 54.43,78.14 54.43,75.66 50.15,71.38 50.15,64.95 50.43,64.67 50.43,58.39 50.76,58.07 50.76,52.09 50.97,51.88 50.97,47.72 50.85,47.61 v1(50.46,47.61)
  BOTTOM w0.178: v1(50.46,47.61) 50.82,47.61 51.48,46.95 CN16.50 ; v1(60.11,100.37) 60.11,100.04 U18.G22
M_A_DQ17: length 66
  IN4 w0.127: v1(50.44,50.37) 50.44,49.59 50.31,49.46 49.88,49.46 49.75,49.59 49.75,57.71 49.16,58.3 49.16,72.65 49.01,72.8 49.01,74.51 48.03,75.49 48.03,78.31 50.01,80.29 50.01,86.37 50.89,87.25 50.89,89.36 50.55,89.7 50.55,90.69 50.89,91.03 50.89,92.4 51.29,92.8 52.18,92.8 53.1,93.72 53.1,94.46 54.75,96.11 54.75,98.17 56.74,100.16 57.65,100.16 58.01,100.52 58.94,100.52 59.25,100.83 60.66,100.83 60.83,100.66 v1(60.83,100.38)
  BOTTOM w0.178: v1(50.44,50.37) 50.85,50.37 51.23,50.74 CN16.49 ; U18.H22 61.15,100.06 v1(60.83,100.38)
M_A_DQ18: length 66.3
  IN4 w0.127: v1(58.33,96.64) 58.2,96.64 57.74,96.18 57.35,96.18 57.1,95.94 57.1,95.03 56.83,94.76 56.83,94.36 57.01,94.18 57.01,93.87 56.64,93.5 56.3,93.16 56.3,91.44 56.47,91.27 56.47,90.42 55.49,89.43 55.49,89.08 54.95,88.54 54.95,83.1 57.89,80.16 57.89,74.23 54.98,71.32 54.98,66.2 53.94,65.16 53.94,61.49 54.06,61.36 54.4,61.36 54.52,61.24 54.52,60.98 54.4,60.86 54.06,60.86 53.94,60.73 53.94,58.48 54.24,58.17 54.24,47.99 56.04,46.19 56.21,46.19 56.45,46.43 56.45,46.64 54.9,48.19 54.9,50.28 v1(54.72,50.46)
  BOTTOM w0.178: U18.E25 58.75,97.06 v1(58.33,96.64) ; v1(54.72,50.46) 53.73,51.45 CN16.59
M_A_DQ19: length 66
  IN4 w0.127: v1(60.15,97.97) 60.21,97.97 60.65,98.41 62.18,98.41 62.29,98.3 62.62,98.3 62.75,98.43 63.41,98.43 63.53,98.31 63.53,98 63.4,97.87 62.93,97.87 62.7,97.64 62.7,97.19 62.85,97.03 63.08,97.03 63.21,96.91 63.21,96.63 63.08,96.5 62.27,96.5 62.12,96.65 62.12,97.34 61.99,97.46 61.74,97.46 61.61,97.34 61.61,96.73 61.46,96.58 61.23,96.58 61.1,96.7 61.1,97.31 60.95,97.46 60.47,97.46 60.24,97.24 59.15,97.24 58.81,96.9 58.81,96.52 58.48,96.19 58.18,96.19 57.94,95.95 57.94,95.52 57.72,95.3 57.72,94.21 56.6,93.09 56.6,91.61 56.81,91.41 56.81,91.18 56.93,91.06 57.16,91.06 57.29,90.93 57.29,90.65 57.16,90.52 56.92,90.52 55.72,89.32 55.72,88.68 55.34,88.3 55.34,83.33 58.32,80.34 58.32,74.05 55.41,71.14 55.41,66.02 54.37,64.98 54.37,62.06 54.9,61.53 54.9,51.97 v1(54.71,51.78)
  BOTTOM w0.178: CN16.63 54.73,51.79 v1(54.71,51.78) ; U18.G25 60.35,97.77 v1(60.15,97.97)
M_A_DQ20: length 66.2
  IN4 w0.127: v1(50.48,46.26) 51.23,47.01 51.23,52.28 51.19,52.32 51.19,58.27 50.89,58.57 50.89,71.51 54.87,75.48 54.87,78.32 51.33,81.85 51.33,85.57 52.28,86.52 52.28,88.99 52.49,89.2 52.49,91.97 53.81,93.29 53.81,94.17 55.52,95.89 55.52,97.72 57.25,99.45 57.94,99.45 58.25,99.77 58.91,99.77 58.94,99.74 60.36,99.74 60.52,99.9 61.14,99.9 61.48,100.24 v1(61.48,100.38)
  BOTTOM w0.178: v1(50.48,46.26) CN16.46 ; v1(61.48,100.38) 61.56,100.38 61.95,100.77 U18.J20
M_A_DQ21: length 65.9
  IN4 w0.127: v1(50.43,51.7) 50.27,51.86 50.27,57.8 49.52,58.55 49.52,64.32 49.72,64.52 49.72,72.2 49.85,72.33 50.49,72.33 50.64,72.48 50.64,72.74 50.54,72.84 49.65,72.84 49.52,72.97 49.52,73.28 49.65,73.41 51.57,73.41 51.72,73.56 51.72,73.81 51.62,73.92 49.85,73.92 49.72,74.04 49.72,74.41 48.46,75.66 48.46,78.13 50.29,79.96 51.41,79.96 51.56,80.12 51.56,80.4 51.42,80.54 50.56,80.54 50.44,80.66 50.44,86.19 51.2,86.95 51.2,92.2 51.35,92.35 52.06,92.35 53.33,93.62 53.33,94.36 55,96.03 55,97.99 56.94,99.92 57.74,99.92 58.11,100.29 59.31,100.29 v1(59.42,100.4)
  BOTTOM w0.178: v1(50.43,51.7) 50.23,51.9 CN16.45 ; U18.E22 58.82,99.8 v1(59.42,100.4)
M_A_DQ22: length 66.3
  IN4 w0.127: v1(52.48,47.57) 52.75,47.3 53.18,47.3 53.38,47.5 53.38,47.82 53.25,47.95 53.08,47.95 52.96,48.07 52.96,48.33 53.08,48.46 53.25,48.46 53.38,48.58 53.38,48.84 53.25,48.96 52.97,48.96 52.84,49.09 52.84,49.35 52.97,49.47 53.25,49.47 53.38,49.6 53.38,57.38 53.07,57.69 53.07,65.52 54.12,66.56 54.12,71.68 57.03,74.59 57.03,79.58 53.5,83.1 53.5,85.41 54.13,86.04 54.13,88.55 54.96,89.39 54.96,89.89 54.69,90.16 54.69,90.58 55.71,91.6 55.71,93.42 56.14,93.84 56.14,94.95 56.55,95.36 56.55,97.22 57.21,97.89 57.77,97.89 58.18,97.48 58.58,97.48 58.84,97.74 58.84,98.16 59.33,98.65 60.22,98.65 60.74,99.17 v1(60.83,99.17)
  BOTTOM w0.178: v1(52.48,47.57) 53.48,46.57 CN16.58 ; v1(60.83,99.17) 61.15,98.85 U18.H23
M_A_DQ23: length 65.6
  IN4 w0.127: v1(54.47,46.2) 54.72,45.94 54.72,45.2 54.54,45.01 53.94,45.01 53.81,45.14 53.81,57.76 53.51,58.07 53.51,65.34 54.55,66.38 54.55,71.5 57.46,74.41 57.46,79.99 54.65,82.8 54.65,88.69 55.2,89.24 55.2,89.55 56.14,90.49 56.14,91.03 56.02,91.16 56.02,93.29 56.47,93.75 56.47,94.84 56.86,95.24 56.86,96.67 57.23,97.03 57.87,97.03 58,97.16 58.62,97.16 58.99,97.53 59.52,97.53 59.7,97.71 59.7,98.21 59.89,98.4 60.29,98.4 60.63,98.73 61.3,98.73 v1(61.63,99.06)
  BOTTOM w0.178: CN16.62 54.48,46.19 v1(54.47,46.2) ; v1(61.63,99.06) 61.95,98.75 U18.J23
M_A_DQ24: length 57.7
  IN4 w0.127: v1(57.01,48.2) 55.79,49.42 55.79,65.16 56.27,65.64 56.27,70.78 59.18,73.69 59.18,80.7 56.11,83.77 56.11,87.75 57.91,89.54 57.91,91.99 57.81,92.09 57.81,93.54 58.4,94.13 58.4,95.11 58.91,95.62 58.91,96.16 59.27,96.52 v1(59.27,96.72)
  BOTTOM w0.178: v1(57.01,48.2) 55.48,46.68 CN16.66 ; v1(59.27,96.72) 59.27,96.48 U18.F26
M_A_DQ25: length 57.7
  IN4 w0.127: v1(58.35,93.47) 58.35,92.96 58.66,92.66 58.66,92.15 58.25,91.74 58.25,90.91 58.66,90.5 58.66,90.13 58.55,90.02 58.37,90.02 58.26,89.91 58.26,89.55 56.5,87.78 56.5,85.25 56.58,85.17 56.76,85.17 56.88,85.04 56.88,84.64 56.76,84.51 56.62,84.51 56.5,84.38 56.5,84 56.7,83.8 57.47,83.8 57.56,83.72 57.56,82.94 59.62,80.88 59.62,73.51 56.71,70.6 56.71,65.46 56.22,64.98 56.22,50.7 56.35,50.58 56.58,50.58 56.71,50.45 56.71,50.12 56.58,49.99 56.35,49.99 56.22,49.87 56.22,49.64 56.86,49 57.09,49 57.17,49.08 v1(57.17,49.81)
  BOTTOM w0.178: U18.E27 58.75,93.86 v1(58.35,93.47) ; CN16.67 55.73,50.38 56.3,49.81 v1(57.17,49.81)
M_A_DQ26: length 57.6
  IN4 w0.127: v1(58.6,49.94) 58.6,48.88 58.69,48.8 58.99,48.8 59.83,49.64 59.83,51.04 59.3,51.57 59.3,69.53 62.21,72.44 62.21,81.96 61.13,83.03 61.13,84.89 60.7,85.32 60.7,88.85 61.07,89.22 61.07,92.89 60.42,93.54 60.42,95.97 60.62,96.17 60.92,96.17 61.05,96.04 v1(61.05,95.86)
  BOTTOM w0.178: v1(58.6,49.94) 58.85,50.18 58.85,50.61 59.03,50.79 59.03,51.86 58.73,52.16 CN16.79 ; U18.J26 61.65,96.41 61.47,96.58 61.17,96.58 60.89,96.3 60.89,96.02 v1(61.05,95.86)
M_A_DQ27: length 56.7
  IN4 w0.127: v1(60.46,46.88) 61.15,47.57 61.15,67.5 63.5,69.85 63.5,82.49 62.57,83.42 62.57,84.89 62.17,85.29 62.17,87.88 62.3,88.01 62.3,88.6 61.99,88.92 61.99,89.36 62.51,89.89 62.51,90.85 63.31,91.65 63.31,93.68 62.99,94 62.99,95.78 62.7,96.07 61.97,96.07 v1(61.1,95.2)
  BOTTOM w0.178: CN16.84 59.98,46.4 v1(60.46,46.88) ; U18.J27 61.2,95.3 v1(61.1,95.2)
M_A_DQ28: length 56.7
  IN4 w0.127: v1(57.17,51.11) 57.17,51.01 57.04,50.88 56.78,50.88 56.66,51.01 56.66,64.8 57.14,65.28 57.14,70.43 60.05,73.34 60.05,81.06 58.03,83.08 58.03,86.98 57.93,87.08 57.65,87.08 57.44,86.87 57.44,86.39 57.32,86.26 56.99,86.26 56.86,86.39 56.86,87.75 59.09,89.98 59.09,90.66 58.69,91.06 58.69,91.57 58.95,91.83 58.95,92.7 58.79,92.86 58.79,95.07 59.72,96 59.72,96.62 59.9,96.8 v1(60.67,96.8)
  BOTTOM w0.178: v1(60.67,96.8) 61.15,97.28 U18.H25 ; CN16.71 56.73,52.18 56.66,52.1 56.66,51.62 v1(57.17,51.11)
M_A_DQ29: length 57.9
  IN4 w0.127: v1(57.01,46.86) 55.33,48.53 55.33,61.66 54.8,62.2 54.8,64.8 55.84,65.84 55.84,70.96 58.75,73.87 58.75,80.52 55.75,83.53 55.75,87.74 57.55,89.54 57.55,91.1 56.88,91.77 56.88,92.99 58.07,94.18 58.07,95.22 58.34,95.5 58.34,95.72 58.36,95.73 v1(58.36,95.73)
  BOTTOM w0.178: v1(57.01,46.86) 56.48,46.33 CN16.70 ; U18.E26 58.91,96.2 59.04,96.07 59.04,95.79 58.88,95.64 58.45,95.64 v1(58.36,95.73)
M_A_DQ30: length 57.2
  IN4 w0.127: v1(60.44,48.19) 59.78,47.53 59.39,47.53 59.23,47.69 59.23,48.17 59.84,48.77 60.62,48.77 60.77,48.93 60.77,49.73 60.64,49.85 60.35,49.85 60.22,49.98 60.22,51.1 59.78,51.54 59.78,69.4 62.64,72.26 62.64,82.13 61.71,83.06 61.71,84.75 60.93,85.54 60.93,88.61 61.4,89.08 61.4,92.91 60.65,93.66 60.65,94.12 v1(61.07,94.54)
  BOTTOM w0.178: v1(61.07,94.54) 61.04,94.5 U18.G28 ; CN16.80 58.98,46.73 v1(60.44,48.19)
M_A_DQ31: length 56.7
  IN4 w0.127: v1(60.64,51.11) 60.21,51.54 60.21,52.33 60.52,52.63 60.52,53.88 60.21,54.18 60.21,64.78 60.34,64.91 60.59,64.91 60.72,65.04 60.72,65.29 60.59,65.42 60.34,65.42 60.21,65.55 60.21,65.8 60.34,65.93 60.59,65.93 60.72,66.05 60.72,66.31 60.59,66.44 60.34,66.44 60.21,66.56 60.21,67.17 62.3,69.26 62.3,69.62 61.58,70.34 61.58,70.59 61.81,70.82 61.99,70.82 62.73,70.08 62.88,70.08 63.07,70.28 63.07,70.6 62.4,71.28 62.4,71.41 63.07,72.08 63.07,82.31 62.13,83.25 62.13,84.66 61.15,85.63 61.15,88.38 61.7,88.93 61.7,89.76 61.99,90.05 61.99,91.57 62.17,91.75 62.75,91.75 62.98,91.98 62.98,93.32 62.62,93.68 62.35,93.68 62.24,93.58 62.24,93.02 62.13,92.9 61.83,92.9 61.71,93.02 61.71,93.76 61.62,93.85 v1(61.07,93.85)
  BOTTOM w0.178: CN16.83 59.73,51.79 60.41,51.11 v1(60.64,51.11) ; U18.G29 60.92,93.7 v1(61.07,93.85)
M_A_DQ32: length 53
  IN4 w0.127: v1(80.32,95.79) 80.76,95.79 80.89,95.67 80.89,93.25 81.38,92.76 81.38,91.75 81.62,91.51 81.62,87.01 81.74,86.88 82.7,86.88 82.83,86.76 82.83,86.5 82.7,86.38 81.76,86.38 81.62,86.23 81.62,85.82 82.26,85.17 82.26,67.88 82.74,67.4 82.74,65.05 82.55,64.86 82.55,63.05 82.34,62.84 82.34,55.02 82.79,54.57 82.79,50.86 v1(83.22,50.42)
  BOTTOM w0.178: v1(83.22,50.42) 84.16,51.36 84.16,52.1 84.23,52.17 CN16.173 ; v1(80.32,95.79) 80.63,96.1 U18.AN26
M_A_DQ33: length 53
  IN4 w0.127: v1(83.22,51.75) 83.46,51.98 83.46,53.33 83.22,53.56 83.22,54.77 82.77,55.22 82.77,55.47 82.9,55.6 83.22,55.6 83.34,55.73 83.34,55.98 83.22,56.11 82.9,56.11 82.77,56.24 82.77,56.49 82.9,56.62 83.2,56.62 83.33,56.74 83.33,57 83.2,57.13 82.9,57.13 82.77,57.25 82.77,57.51 82.9,57.63 83.2,57.63 83.33,57.76 83.33,58.01 83.2,58.14 82.9,58.14 82.8,58.24 82.8,64.52 83.28,64.99 83.28,67.66 83.15,67.79 82.96,67.79 82.83,67.92 82.83,68.17 82.96,68.3 83.15,68.3 83.28,68.42 83.28,68.67 83.15,68.8 82.82,68.8 82.69,68.92 82.69,69.18 82.82,69.31 83.15,69.31 83.28,69.43 83.28,69.69 83.15,69.82 82.82,69.82 82.69,69.95 82.69,70.2 82.82,70.33 83.15,70.33 83.28,70.46 83.28,70.71 83.15,70.84 82.8,70.84 82.69,70.94 82.69,71.24 82.79,71.34 83.15,71.34 83.28,71.47 83.28,71.76 83.15,71.89 82.82,71.89 82.69,72.01 82.69,85.63 83.17,86.11 83.17,87.29 83.09,87.37 82.76,87.37 82.63,87.5 82.63,87.83 82.76,87.96 83.02,87.96 83.15,88.09 83.15,88.5 83.02,88.63 82.73,88.63 82.62,88.75 82.62,89.37 82.89,89.65 82.89,90.19 82.64,90.45 81.98,90.45 81.85,90.59 81.85,91.6 81.6,91.84 81.6,93.13 v1(81.33,93.4)
  BOTTOM w0.178: v1(83.22,51.75) 83.23,51.75 CN16.169 ; U18.AP29 81.64,93.7 v1(81.33,93.4)
M_A_DQ34: length 53.1
  IN4 w0.127: v1(82.65,95.75) 82.65,95.61 83.1,95.16 83.1,94.84 83.35,94.59 83.35,93.7 83.3,93.65 83.3,93.1 83.66,92.75 83.99,92.75 84.2,92.53 84.2,91.7 84.69,91.21 85.37,91.21 86.05,90.53 86.05,88.93 85.64,88.52 85.64,85.36 85.72,85.28 85.72,73.69 86.78,72.63 86.78,70.99 87.06,70.71 87.06,65.23 86.78,64.95 86.78,51.88 87.15,51.51 87.15,51.23 86.88,50.96 86.88,50.73 87.26,50.35 87.59,50.35 v1(87.72,50.48)
  BOTTOM w0.178: U18.AR26 83,96.1 v1(82.65,95.75) ; CN16.183 86.73,51.31 87.57,50.48 v1(87.72,50.48)
M_A_DQ35: length 53
  IN4 w0.127: v1(87.72,51.77) 87.21,52.28 87.21,64.6 87.72,65.11 87.72,70.92 87.59,71.05 87.34,71.05 87.21,71.17 87.21,71.43 87.34,71.55 87.59,71.55 87.72,71.68 87.72,71.93 87.59,72.06 87.34,72.06 87.21,72.19 87.21,72.81 86.15,73.87 86.15,85.26 87.01,86.13 87.01,88.93 86.33,89.61 86.33,90.68 85.39,91.62 85.08,91.62 84.44,92.26 84.44,92.63 84.07,93 83.77,93 83.53,93.24 83.53,93.55 83.58,93.6 83.58,94.69 83.35,94.92 83.35,95.4 83.2,95.55 83.2,96.06 81.92,97.34 v1(81.47,97.34)
  BOTTOM w0.178: CN16.187 87.73,51.78 v1(87.72,51.77) ; v1(81.47,97.34) 82.05,97.92 U18.AP24
M_A_DQ36: length 53
  IN4 w0.127: v1(84.48,46.25) 83.61,47.12 83.43,47.12 83.21,46.91 83.03,46.91 82.85,47.09 82.85,47.27 83.07,47.48 83.07,47.66 82.89,47.84 82.71,47.84 82.53,47.66 82.35,47.66 82.17,47.84 82.17,48.02 82.35,48.2 82.35,48.38 82.06,48.66 82.06,53.73 81.48,54.32 81.48,62.97 82.02,63.51 82.02,66.89 81.4,67.52 81.4,85.07 81.16,85.31 81.16,91.26 80.92,91.5 80.92,92.57 80.2,93.29 v1(80.2,93.37)
  BOTTOM w0.178: v1(80.2,93.37) 80.52,93.37 U18.AN29 ; v1(84.48,46.25) 84.48,46.25 CN16.174
M_A_DQ37: length 53.7
  IN4 w0.127: v1(80.17,94.8) 80.49,94.8 80.66,94.63 80.66,93.15 81.15,92.67 81.15,91.59 81.39,91.35 81.39,85.56 81.83,85.12 81.83,67.7 82.3,67.22 82.3,63.32 81.91,62.93 81.91,54.84 82.36,54.39 82.36,49.34 84.13,47.57 v1(84.45,47.57)
  BOTTOM w0.178: CN16.170 83.48,46.6 v1(84.45,47.57) ; U18.AN27 80.66,95.3 v1(80.17,94.8)
M_A_DQ38: length 53.2
  IN4 w0.127: v1(82.68,94.31) 82.89,94.11 82.89,93.89 82.84,93.84 82.84,92.91 83.12,92.64 83.12,91.88 84.71,90.29 84.71,89.66 85.06,89.31 85.06,84.55 84.85,84.35 84.85,73.33 85.71,72.47 85.71,64.9 85.44,64.62 85.44,57.38 85.92,56.9 85.92,50.32 86.58,49.66 86.58,46.36 86.67,46.27 v1(87.48,46.27)
  BOTTOM w0.178: v1(82.68,94.31) 82.71,94.31 83.25,93.78 U18.AR29 ; v1(87.48,46.27) CN16.186
M_A_DQ39: length 54
  IN4 w0.127: v1(87.47,47.57) 87.47,49.48 86.35,50.6 86.35,72.45 85.28,73.51 85.28,88.61 85.81,89.13 85.81,90.14 85.16,90.79 84.68,90.79 83.35,92.12 83.35,92.73 83.07,93.01 83.07,93.74 83.12,93.79 83.12,94.49 82.65,94.97 v1(82.65,95)
  BOTTOM w0.178: U18.AR27 82.95,95.3 v1(82.65,95) ; v1(87.47,47.57) 86.48,46.58 CN16.182
M_A_DQ40: length 59.6
  IN4 w0.127: v1(89.72,51.71) 89.59,51.71 89.5,51.8 89.5,60.94 89.97,61.41 89.97,67.56 90.13,67.72 90.99,67.72 91.12,67.85 91.12,68.28 90.99,68.41 89.57,68.41 89.45,68.53 89.45,68.79 89.57,68.92 90.99,68.92 91.12,69.04 91.12,69.3 90.99,69.42 89.57,69.42 89.45,69.55 89.45,69.8 89.57,69.93 90.99,69.93 91.12,70.06 91.12,70.39 90.99,70.52 90.44,70.52 90.31,70.64 90.31,72.15 89.92,72.55 89.68,72.55 89.47,72.76 89.47,73 87.87,74.59 87.87,80.43 88.73,81.28 88.73,85.94 89.74,86.95 89.74,89.99 87.89,91.83 87.89,92.4 86.53,93.76 85.47,93.76 84.77,94.46 84.77,95.18 84.15,95.8 v1(83.85,95.8)
  BOTTOM w0.178: U18.AU26 84.25,96.2 v1(83.85,95.8) ; v1(89.72,51.71) 89.73,51.71 CN16.195
M_A_DQ41: length 59.5
  IN4 w0.127: v1(89.72,50.41) 89.57,50.26 89.57,49.4 90.08,48.88 90.08,48.56 89.99,48.47 89.14,48.47 89.01,48.6 89.01,65.03 89.14,65.15 89.42,65.15 89.55,65.28 89.55,65.53 89.42,65.66 89.14,65.66 89.01,65.79 89.01,66.04 89.14,66.17 89.42,66.17 89.55,66.3 89.55,66.55 89.42,66.68 89.14,66.68 89.01,66.8 89.01,67.06 89.14,67.18 89.41,67.18 89.54,67.31 89.54,67.57 89.41,67.69 89.14,67.69 89.01,67.82 89.01,70.4 89.14,70.53 89.75,70.53 89.88,70.65 89.88,70.91 89.75,71.03 89.14,71.03 89.01,71.16 89.01,71.41 89.14,71.54 89.75,71.54 89.88,71.67 89.88,71.92 89.75,72.05 89.14,72.05 89.01,72.18 89.01,72.84 87.44,74.41 87.44,80.61 88.29,81.46 88.29,86.67 88.75,87.13 88.75,89.17 88.25,89.67 88.25,89.8 88.12,89.93 88.12,91.22 87.61,91.73 87.61,92.28 86.59,93.3 86.36,93.3 v1(86.33,93.33)
  BOTTOM w0.178: v1(89.72,50.41) 89.54,50.41 88.73,51.22 CN16.191 ; U18.AV29 85.7,93.7 v1(86.33,93.33)
M_A_DQ42: length 60.5
  IN4 w0.127: v1(84.87,96.75) 85.39,96.23 86.79,96.23 87.34,95.68 87.55,95.68 91.83,91.4 91.83,90.05 92.05,89.84 92.05,86.59 91.85,86.39 91.85,82.72 96.43,78.14 96.43,75.66 94.15,73.37 94.15,64.57 94.22,64.5 94.22,61.7 93.84,61.32 93.84,55.71 92.96,54.83 92.96,47.69 v1(92.93,47.66)
  BOTTOM w0.178: CN16.204 91.98,46.71 v1(92.93,47.66) ; v1(84.87,96.75) 84.55,97.07 U18.AU25
M_A_DQ43: length 59.5
  IN4 w0.127: v1(86.5,96.68) 86.55,96.62 87.83,96.62 88.3,96.15 88.3,95.27 92.08,91.48 92.08,90.18 92.28,89.98 92.28,82.9 96.87,78.31 96.87,75.49 94.58,73.2 94.58,60.84 94.7,60.71 94.7,58.77 94.4,58.47 94.4,55.35 93.41,54.36 93.41,46.51 93.13,46.23 v1(92.98,46.23)
  BOTTOM w0.178: v1(92.98,46.23) 92.98,46.23 CN16.208 ; U18.AW25 86.15,97.03 v1(86.5,96.68)
M_A_DQ44: length 59.5
  IN4 w0.127: v1(83.96,93.42) 84.19,93.42 84.71,92.9 85.11,92.9 85.28,92.73 85.28,92.28 85.57,92 85.76,92 86.62,91.14 86.62,90.64 87.59,89.67 87.59,89.57 88.22,88.94 88.22,87.57 87.43,86.78 87.43,81.82 86.58,80.97 86.58,74.05 88.15,72.48 88.15,44.81 88.28,44.68 90.72,44.68 90.84,44.81 90.84,45.24 90.72,45.37 89.61,45.37 89.48,45.5 v1(89.48,46.18)
  BOTTOM w0.178: U18.AU29 84.17,93.42 v1(83.96,93.42) ; v1(89.48,46.18) CN16.194
M_A_DQ45: length 59.5
  IN4 w0.127: v1(89.49,47.49) 89.89,47.49 90.06,47.33 90.06,46.39 90.18,46.26 90.54,46.26 90.67,46.39 90.67,47.96 90.56,48.06 88.81,48.06 88.58,48.29 88.58,72.66 87.01,74.23 87.01,80.79 87.86,81.64 87.86,86.75 88.5,87.39 88.5,89.01 87.93,89.58 87.93,89.69 86.87,90.74 86.87,91.29 86.13,92.04 86.13,92.75 84.97,93.9 84.81,94.07 v1(84.02,94.07)
  BOTTOM w0.178: CN16.190 88.48,47.1 88.87,47.49 v1(89.49,47.49) ; U18.AU28 v1(84.02,94.07)
M_A_DQ46: length 59.5
  IN4 w0.127: v1(91.24,49.83) 91.59,49.83 92.26,49.16 92.44,49.16 92.57,49.29 92.57,50.14 92.42,50.3 92.25,50.3 92.1,50.45 92.1,55.19 92.95,56.04 92.95,57.99 92.56,58.39 92.56,60.54 92.83,60.81 92.83,65.05 93.28,65.51 93.28,73.28 93.1,73.46 92.06,73.46 90.03,75.48 90.03,78.72 90.26,78.95 90.59,78.95 90.72,79.08 90.72,79.3 90.36,79.66 90.36,79.86 90.56,80.07 90.77,80.07 91.17,79.66 91.38,79.66 91.58,79.86 91.58,80.07 90.99,80.66 90.99,86.02 90.68,86.32 90.68,90.49 88.9,92.27 88.9,92.73 86.45,95.18 v1(86.45,95.57)
  BOTTOM w0.178: U18.AW26 86.15,95.9 86.45,95.6 v1(86.45,95.57) ; v1(91.24,49.83) 91.73,50.32 CN16.203
M_A_DQ47: length 59.5
  IN4 w0.127: v1(92.53,51.55) 92.53,51.56 92.53,55.01 93.41,55.89 93.41,62.67 93.31,62.77 93.31,64.87 93.71,65.28 93.71,73.64 93.46,73.89 92.23,73.89 90.47,75.66 90.47,78.14 92.54,80.21 93.25,80.21 93.37,80.33 93.37,80.59 93.25,80.71 91.54,80.71 91.42,80.84 91.42,81.1 91.54,81.22 92.23,81.22 92.36,81.35 92.36,81.6 92.23,81.73 91.54,81.73 91.42,81.86 91.42,86.2 90.96,86.65 90.96,90.64 89.22,92.38 89.22,92.82 88.14,93.91 88.14,94.75 87.45,95.43 87.26,95.43 86.69,96 85.03,96 84.33,96.69 v1(84.16,96.69)
  BOTTOM w0.178: CN16.207 92.73,51.75 v1(92.53,51.55) ; v1(84.16,96.69) 84.16,96.99 U18.AT25
M_A_DQ48: length 71.1
  IN4 w0.127: v1(94.37,47.11) 93.97,46.7 93.97,44.94 94.27,44.63 96.4,44.63 96.59,44.82 96.59,45.38 96.48,45.5 95.59,45.5 95.34,45.75 95.34,46.94 94.7,47.58 94.7,48.49 95.06,48.85 95.06,53.75 96.45,55.14 96.45,61.3 95.94,61.81 95.94,64.64 96.45,65.15 96.45,73.24 98.17,74.95 98.17,78.85 93.64,83.37 93.64,92.13 89.97,95.81 89.72,95.81 88.14,97.38 87.37,97.38 87.17,97.58 86.07,97.58 v1(85.65,98)
  BOTTOM w0.178: v1(94.37,47.11) 93.98,46.72 CN16.212 ; U18.AV23 85.35,98.3 v1(85.65,98)
M_A_DQ49: length 71.4
  IN4 w0.127: v1(95.97,47.5) 95.34,47.5 95.14,47.71 95.14,48.21 95.32,48.39 96.35,48.39 96.56,48.19 96.56,47.02 96.69,46.89 96.97,46.89 97.09,47.02 97.09,48.7 96.89,48.9 95.62,48.9 95.49,49.03 95.49,49.28 95.62,49.41 96.15,49.41 96.28,49.54 96.28,49.79 96.15,49.92 95.62,49.92 95.49,50.05 95.49,53.55 96.88,54.94 96.88,61.5 96.37,62.02 96.37,64.53 96.88,65.05 96.88,73.06 98.6,74.78 98.6,79.02 94.08,83.55 94.08,92.63 91,95.71 90.49,95.71 89.22,96.98 87.98,98.22 87.37,98.22 87.15,98 v1(86.45,98)
  BOTTOM w0.178: CN16.216 94.98,47.6 95.16,47.78 95.7,47.78 v1(95.97,47.5) ; U18.AW23 86.15,98.3 v1(86.45,98)
M_A_DQ50: length 71.6
  IN4 w0.127: v1(98.33,48.26) 98.6,47.99 98.77,47.99 98.84,48.06 98.84,52.51 100.19,53.85 100.19,57.08 100.58,57.47 100.58,64.72 100.14,65.17 100.14,65.64 99.91,65.87 99.91,71.8 101.62,73.52 101.62,80.34 98.69,83.28 98.69,93.02 92.6,99.11 89.92,99.11 88.48,100.56 87.36,100.56 87.05,100.87 86.09,100.87 85.65,100.44 v2(85.65,100.44)
  BOTTOM w0.178: v2(85.65,100.44) 85.65,100.7 U18.AV20 ; v1(98.33,48.26) 98.33,48.65 97.99,48.99 97.14,48.99 96.98,48.83 CN16.224
