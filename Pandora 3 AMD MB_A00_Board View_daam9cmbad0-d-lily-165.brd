# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-DLP11SN900HL2L-4P-1
  rect 0.711x0.305 smd: 1(-0.625,0.275) 2(0.625,0.275) 3(0.625,-0.275) 4(-0.625,-0.275)
CHOKE-PCMB104T-R45MN-4P-SMT
  custom 0.997x0.997 smd: 1(-5.38,0) 2(5.38,0)
  rect 3.378x0.254 smd: 3(-3.31,0) 4(3.31,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
CHOKE-PCMC063T-R82MN-4P-SMT
  custom 0.591x0.591 smd: 1(-3.596,0) 2(3.596,0)
  rect 1.473x0.305 smd: 3(-2.452,0) 4(2.452,0)
DDR4-ADDR0069-P009A-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 2.007x3.505 smd: 261(-37.75,12) 262(37.75,8)
DDR4-ADDR0106-P005A-STD-SMT
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN6-1_2X1_4-4
  rect 0.991x0.203 smd: 1(0.8,-0.4) 2(0.8,0) 3(0.8,0.4) 4(-0.8,0.4) 5(-0.8,0) 6(-0.8,-0.4)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
DSMV
  rect 1.016x0.762 smd: 1(-1.27,0) 2(1.27,0)
F2_1X1_35-2_2-0_75H
  rect 0.991x1.499 smd: 1(-1.1,0) 2(1.1,0)
FSMD1206P150TS
  rect 1.016x1.803 smd: 1(-1.725,0) 2(1.725,0)
GS12201-1011-9F-20P-L-SMT
  round 0.965 hole 0.965 unplated: (-5.8,0.2) (5.8,0.2)
  rect 0.254x1.143 smd: 1(-4.75,-2.125) 2(-4.25,-2.125) 3(-3.75,-2.125) 4(-3.25,-2.125) 5(-2.75,-2.125) 6(-2.25,-2.125) 7(-1.75,-2.125) 8(-1.25,-2.125) 9(-0.75,-2.125) 10(-0.25,-2.125) 11(0.25,-2.125) 12(0.75,-2.125) 13(1.25,-2.125) 14(1.75,-2.125) 15(2.25,-2.125) 16(2.75,-2.125) 17(3.25,-2.125) 18(3.75,-2.125) 19(4.25,-2.125) 20(4.75,-2.125)
  rect 1.295x1.397 smd: 21(-5.8,-2) 22(5.8,-2) 23(-5.8,2) 24(5.8,2)
GS12401-1011-40P-R-NH-SMT
  round 0.94 hole 0.94 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.65,0) 42(-12.65,0)
  rect 2.794x1.499 smd: 43(5.7,-2.45) 44(-5.7,-2.45)
H-C157D83P2
  round 3.988 hole 2.108: 1(0,0)
H-C236O83X126P2
  round 5.994 hole 3.2x2.108: 1(0,0)
H-C303D197P2
  round 7.696 hole 5.004: 1(0,0)
H-C315D94P2
  round 8.001 hole 2.388: 1(0,0)
H-O83X126D83X126N
  oval 2.108x3.2 hole 2.108x3.2: 1(0,0)
H-TC256BC150D150PT
  round 6.502 hole 3.81: 1(0,0)
HDMI-59058-0190D-001-19P
  round 0.813 hole 0.508: 1(-4.5,6.08) 2(-4,7.58) 3(-3.5,6.08) 4(-3,7.58) 5(-2.5,6.08) 6(-2,7.58) 7(-1.5,6.08) 8(-1,7.58) 9(-0.5,6.08) 10(0,7.58) 11(0.5,6.08) 12(1,7.58) 13(1.5,6.08) 14(2,7.58) 15(2.5,6.08) 16(3,7.58) 17(3.5,6.08) 18(4,7.58) 19(4.5,6.08)
  oval 1.803x2.794 hole 0.787x1.803: 20(-9.25,0) 22(9.25,0)
  oval 1.397x3.15 hole 0.787x2.54: 21(-7.25,6.98) 23(7.25,6.98)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
LVDS-50473-0400M-V01-40P-L
  rect 0.254x1.092 smd: 1(-9.75,2.92) 2(-9.25,2.92) 3(-8.75,2.92) 4(-8.25,2.92) 5(-7.75,2.92) 6(-7.25,2.92) 7(-6.75,2.92) 8(-6.25,2.92) 9(-5.75,2.92) 10(-5.25,2.92) 11(-4.75,2.92) 12(-4.25,2.92) 13(-3.75,2.92) 14(-3.25,2.92) 15(-2.75,2.92) 16(-2.25,2.92) 17(-1.75,2.92) 18(-1.25,2.92) 19(-0.75,2.92) 20(-0.25,2.92) 21(0.25,2.92) 22(0.75,2.92) 23(1.25,2.92) 24(1.75,2.92) 25(2.25,2.92) 26(2.75,2.92) 27(3.25,2.92) 28(3.75,2.92) 29(4.25,2.92) 30(4.75,2.92) 31(5.25,2.92) 32(5.75,2.92) 33(6.25,2.92) 34(6.75,2.92) 35(7.25,2.92) 36(7.75,2.92) 37(8.25,2.92) 38(8.75,2.92) 39(9.25,2.92) 40(9.75,2.92)
  rect 0.559x1.092 smd: 41(-10.65,2.92) 42(10.65,2.92)
  rect 1.397x1.905 smd: 43(-12.85,0) 44(12.85,0)
NGFF-APCI0162-P001A-75P-KA
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 16(-5.5,-1.725) 17(-5.25,4.725) 18(-5,-1.725) 19(-4.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 24(-3.5,-1.725) 25(-3.25,4.725) 26(-3,-1.725) 27(-2.75,4.725) 28(-2.5,-1.725) 29(-2.25,4.725) 30(-2,-1.725) 31(-1.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 59(5.25,4.725) 60(5.5,-1.725) 61(5.75,4.725) 62(6,-1.725) 63(6.25,4.725) 64(6.5,-1.725) 65(6.75,4.725) 66(7,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TS85-KM-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,4.725) 2(-9,-1.725) 3(-8.75,4.725) 4(-8.5,-1.725) 5(-8.25,4.725) 6(-8,-1.725) 7(-7.75,4.725) 8(-7.5,-1.725) 9(-7.25,4.725) 10(-7,-1.725) 11(-6.75,4.725) 12(-6.5,-1.725) 13(-6.25,4.725) 14(-6,-1.725) 15(-5.75,4.725) 16(-5.5,-1.725) 17(-5.25,4.725) 18(-5,-1.725) 19(-4.75,4.725) 20(-4.5,-1.725) 21(-4.25,4.725) 22(-4,-1.725) 23(-3.75,4.725) 24(-3.5,-1.725) 25(-3.25,4.725) 26(-3,-1.725) 27(-2.75,4.725) 28(-2.5,-1.725) 29(-2.25,4.725) 30(-2,-1.725) 31(-1.75,4.725) 32(-1.5,-1.725) 33(-1.25,4.725) 34(-1,-1.725) 35(-0.75,4.725) 36(-0.5,-1.725) 37(-0.25,4.725) 38(0,-1.725) 39(0.25,4.725) 40(0.5,-1.725) 41(0.75,4.725) 42(1,-1.725) 43(1.25,4.725) 44(1.5,-1.725) 45(1.75,4.725) 46(2,-1.725) 47(2.25,4.725) 48(2.5,-1.725) 49(2.75,4.725) 50(3,-1.725) 51(3.25,4.725) 52(3.5,-1.725) 53(3.75,4.725) 54(4,-1.725) 55(4.25,4.725) 56(4.5,-1.725) 57(4.75,4.725) 58(5,-1.725) 67(7.25,4.725) 68(7.5,-1.725) 69(7.75,4.725) 70(8,-1.725) 71(8.25,4.725) 72(8.5,-1.725) 73(8.75,4.725) 74(9,-1.725) 75(9.25,4.725)
  rect 1.194x2.743 smd: 76(-10.35,4.505) 77(10.35,4.505)
O-AM9-3
  custom 1.437x1.437 hole 2.388: 1(0,0)
PG-TSDSON-8-8P-R
  rect 0.787x0.33 smd: 1(1.5,-0.975) 2(1.5,-0.325) 3(1.5,0.325) 4(1.5,0.975)
  custom 0.573x0.573 smd: 5(-0.72,0)
  rect 0.66x0.33 smd: 6(-1.575,0.325) 7(-1.575,-0.325) 8(-1.575,-0.975)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
QFN12-1_25X2_1-4
  rect 0.203x0.889 smd: 1(-0.8,-0.775) 2(-0.4,-0.775) 3(0,-0.775) 4(0.4,-0.775) 5(0.8,-0.775) 7(0.8,0.775) 8(0.4,0.775) 9(0,0.775) 10(-0.4,0.775) 11(-0.8,0.775)
  rect 1.194x0.254 smd: 6(1.05,0) 12(-1.05,0)
QFN16-3X3-5-17P-TPS2546RTER
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN20-3X3-4-26P
  rect 0.203x0.787 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.787x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN23-4X4-5-SMT
  rect 0.254x0.61 smd: 1(-1.25,-1.9) 2(-0.75,-1.9) 3(-0.25,-1.9) 4(0.25,-1.9) 5(0.75,-1.9) 6(1.25,-1.9) 12(1.25,1.9) 13(0.75,1.9) 14(0.25,1.9) 15(-0.25,1.9) 16(-0.75,1.9) 17(-1.25,1.9)
  rect 0.61x0.254 smd: 7(1.9,-1.25) 8(1.9,-0.75) 10(1.9,0.75) 18(-1.9,1.25) 19(-1.9,0.75) 20(-1.9,0.25) 21(-1.9,-0.25) 22(-1.9,-0.75) 23(-1.9,-1.25)
  custom 0.335x0.335 smd: 9(0.335,-0.67)
  custom 0.249x0.249 smd: 11(0.335,0.867)
QFN24-4X4-5-25P-ALC5629
  rect 0.305x0.991 smd: 1(-1.25,-2.1) 2(-0.75,-2.1) 3(-0.25,-2.1) 4(0.25,-2.1) 5(0.75,-2.1) 6(1.25,-2.1) 13(1.25,2.1) 14(0.75,2.1) 15(0.25,2.1) 16(-0.25,2.1) 17(-0.75,2.1) 18(-1.25,2.1)
  rect 0.991x0.305 smd: 7(2.1,-1.25) 8(2.1,-0.75) 9(2.1,-0.25) 10(2.1,0.25) 11(2.1,0.75) 12(2.1,1.25) 19(-2.1,1.25) 20(-2.1,0.75) 21(-2.1,0.25) 22(-2.1,-0.25) 23(-2.1,-0.75) 24(-2.1,-1.25)
  rect 2.261x2.261 smd: 25(0,0)
QFN28-4X4-4-38P
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
  round 0.508 hole 0.254: 30(-1,-1) 31(0,-1) 32(1,-1) 33(1,0) 34(1,1) 35(0,1) 36(-1,1) 37(-1,0) 38(0,0)
QFN32-4X4-4-26P
  rect 0.203x0.61 smd: 1(-1.4,-2) 2(-1,-2) 3(-0.6,-2) 4(-0.2,-2) 5(0.2,-2) 6(0.6,-2) 7(1,-2) 8(1.4,-2) 21(-0.2,2) 22(-0.6,2) 23(-1,2) 24(-1.4,2)
  rect 0.61x0.203 smd: 9(2,-1.4) 10(2,-1) 25(-2,1.4) 26(-2,1) 27(-2,0.6) 28(-2,0.2) 29(-2,-0.2) 30(-2,-0.6) 31(-2,-1) 32(-2,-1.4)
  custom 0.15x0.15 smd: 11(2,-0.6)
  custom 0.388x0.388 smd: 17(1.4,2)
  custom 0.263x0.263 smd: 33(-0.925,-0.9)
  rect 1.041x1.397 smd: 34(-0.925,0.75)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN40-5X5-4-41P-ISL62771-SMT
  rect 0.203x0.838 smd: 1(-1.8,-2.514) 2(-1.4,-2.514) 3(-1,-2.514) 4(-0.6,-2.514) 5(-0.2,-2.514) 6(0.2,-2.514) 7(0.6,-2.514) 8(1,-2.514) 9(1.4,-2.514) 10(1.8,-2.514) 21(1.8,2.514) 22(1.4,2.514) 23(1,2.514) 24(0.6,2.514) 25(0.2,2.514) 26(-0.2,2.514) 27(-0.6,2.514) 28(-1,2.514) 29(-1.4,2.514) 30(-1.8,2.514)
  rect 0.838x0.203 smd: 11(2.514,-1.8) 12(2.514,-1.4) 13(2.514,-1) 14(2.514,-0.6) 15(2.514,-0.2) 16(2.514,0.2) 17(2.514,0.6) 18(2.514,1) 19(2.514,1.4) 20(2.514,1.8) 31(-2.514,1.8) 32(-2.514,1.4) 33(-2.514,1) 34(-2.514,0.6) 35(-2.514,0.2) 36(-2.514,-0.2) 37(-2.514,-0.6) 38(-2.514,-1) 39(-2.514,-1.4) 40(-2.514,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN40-5X5-4-50P-0_75H
  custom 0.05x0.05 smd: 1(-1.8,-2.475) 2(-1.4,-2.475) 3(-1,-2.475) 4(-0.6,-2.475) 5(-0.2,-2.475) 6(0.2,-2.475) 7(0.6,-2.475) 8(1,-2.475) 9(1.4,-2.475) 10(1.8,-2.475) 11(2.475,-1.8) 12(2.475,-1.4) 13(2.475,-1) 14(2.475,-0.6) 15(2.475,-0.2) 16(2.475,0.2) 17(2.475,0.6) 18(2.475,1) 19(2.475,1.4) 20(2.475,1.8) 21(1.8,2.475) 22(1.4,2.475) 23(1,2.475) 24(0.6,2.475) 25(0.2,2.475) 26(-0.2,2.475) 27(-0.6,2.475) 28(-1,2.475) 29(-1.4,2.475) 30(-1.8,2.475) 31(-2.475,1.8) 32(-2.475,1.4) 33(-2.475,1) 34(-2.475,0.6) 35(-2.475,0.2) 36(-2.475,-0.2) 37(-2.475,-0.6) 38(-2.475,-1) 39(-2.475,-1.4) 40(-2.475,-1.8)
  rect 3.607x3.607 smd: 41(0,0)
  round 0.508 hole 0.254: 42(-1,-1) 43(0,-1) 44(1,-1) 45(1,0) 46(1,1) 47(0,1) 48(-1,1) 49(-1,0) 50(0,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216-4P
  custom 0.235x0.235 smd: 1(0,1.168) 2(0,-1.168)
  rect 1.092x0.559 smd: 1P(0,0.634) 2P(0,-0.634)
RJ45-C100MP-10809-L-8P
  round 1.194 hole 0.889: 1(-3.556,3.15) 2(-2.54,4.25) 3(-1.524,3.15) 4(-0.508,4.25) 5(0.508,3.15) 6(1.524,4.25) 7(2.54,3.15) 8(3.556,4.25)
  oval 0.889x2.311 hole 0.61x2.007: 9(-8,-6.6) 10(-8,0) 11(8,-6.6) 12(8,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
SC70-2_1-65-5P-TLV70033DCKR
  rect 0.889x0.406 smd: 1(1.1,-0.65) 2(1.1,0) 3(1.1,0.65) 4(-1.1,0.65) 5(-1.1,-0.65)
SC70-2_1-65-6P-0_95H
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SC70-2_1-65-6P-1_1H
  rect 1.092x0.279 smd: 1(1.1,-0.65) 2(1.1,0) 3(1.1,0.65) 4(-1.1,0.65) 5(-1.1,0) 6(-1.1,-0.65)
SDCARD-PSDBR2-09GLBS1NN4H0-11P
  round 1.499 hole 1.092: 1(-8.12,7.6) 2(-5.62,7.6) 3(-3.12,7.6) 4(-1.24,7.6) 5(0.62,7.6) 6(2.46,7.6) 7(4.38,7.6) 8(6.88,7.6) 9(9.3,7.6) 10(11.05,7.6) 11(13.11,7.6)
  rect 1.575x2.489 hole 0.61x1.905: 12(15.625,0) 13(-15.625,0) 14(15.625,-19.65) 15(-15.625,-19.65)
SOIC8-6-1_27
  rect 0.533x1.753 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
SOIC8-7_9-1_27
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SOLDERJUMPER-2
  custom 0.381x0.381 smd: 1(-1.016,0) 2(1.016,0)
SON14-3X2-4-15P-SMT
  custom 0.05x0.05 smd: 1(-1.2,-1.076) 2(-0.8,-1.076) 3(-0.4,-1.076) 4(0,-1.076) 5(0.4,-1.076) 6(0.8,-1.076) 7(1.2,-1.076) 8(1.2,1.076) 9(0.8,1.076) 10(0.4,1.076) 11(0,1.076) 12(-0.4,1.076) 13(-0.8,1.076) 14(-1.2,1.076)
  rect 2.489x0.889 smd: 15(0,0)
SOP8-6-1_27-9P
  rect 0.533x1.727 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
  rect 3.302x2.794 smd: 9(0,0)
SOT23-2_8-95-6P
  rect 1.346x0.508 smd: 1(1.325,-0.95) 2(1.325,0) 3(1.325,0.95) 4(-1.325,0.95) 5(-1.325,0) 6(-1.325,-0.95)
SOT23_213-2_8-1_9-1_45H
  rect 1.346x0.508 smd: 1(1.325,0.95) 2(1.325,-0.95) 3(-1.325,0)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT323_213-2_1-1_3-2N7002W
  rect 0.787x0.61 smd: 1(0.8,0.65) 2(0.8,-0.65) 3(-0.8,0)
SOT-363
  rect 1.219x0.254 smd: 1(1.038,-0.65) 2(1.038,0) 3(1.038,0.65) 4(-1.038,0.65) 5(-1.038,0) 6(-1.038,-0.65)
SPAD-AM9C-1
  custom 1.75x1.75 smd: 1(0,0)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-9_4-1_27-24P
  rect 0.762x1.219 smd: 1(-6.985,-4.35) 2(-5.715,-4.35) 3(-4.445,-4.35) 4(-3.175,-4.35) 5(-1.905,-4.35) 6(-0.635,-4.35) 7(0.635,-4.35) 8(1.905,-4.35) 9(3.175,-4.35) 10(4.445,-4.35) 11(5.715,-4.35) 12(6.985,-4.35) 13(6.985,4.35) 14(5.715,4.35) 15(4.445,4.35) 16(3.175,4.35) 17(1.905,4.35) 18(0.635,4.35) 19(-0.635,4.35) 20(-1.905,4.35) 21(-3.175,4.35) 22(-4.445,4.35) 23(-5.715,4.35) 24(-6.985,4.35)
TSOP6-2_8-95
  rect 0.787x0.635 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
TSOT23-2_8-95-5P-G916-475TOUF
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
TSSOP8-4_9-65
  rect 0.432x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
UDFN10-2_5X1-5
  rect 0.254x0.508 smd: 1(-1,-0.4) 2(-0.5,-0.4) 4(0.5,-0.4) 5(1,-0.4) 6(1,0.4) 7(0.5,0.4) 9(-0.5,0.4) 10(-1,0.4)
  rect 0.457x0.508 smd: 3(0,-0.4) 8(0,0.4)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
USB-YUSB0012-P001A-10P
  round 1.194 hole 0.787: 1(3.5,9.23) 2(1,9.23) 3(-1,9.23) 5(-4.5,10.53) 6(-2.25,10.53) 7(0,10.53) 8(2.25,10.53) 9(4.5,10.53)
  round 1.041 hole 0.787: 4(-3.5,9.23)
  round 0.965 hole 0.762: 10(-4.7,9.26)
  oval 1.626x2.718 hole 0.61x1.702: 11(7.9,0) 12(-7.9,0) 13(-6.4,10.4) 14(6.4,10.4)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
XTL-3_2X2_5-2_2X1_7-4P
  rect 1.397x1.194 smd: 1(1.1,0.85) 2(-1.1,0.85) 3(-1.1,-0.85) 4(1.1,-0.85)
XTL-3_2X2_5-2_2X1_8-4P
  rect 1.397x1.194 smd: 1(-1.1,-0.9) 2(1.1,-0.9) 3(1.1,0.9) 4(-1.1,0.9)

## Nets
0.775V_SUS_PWRGD: PU20.3(PGD) R1042.2
1.05V_SUS_PWRGD: PR510.2 PR514.2 PU18.1(PGOOD)
1.5V_SUS_PWRGD: PU21.1(POK) R1043.2
1.8V_GFX_EN: PR467.2 R1026.1 U203.4(Y)
1.8V_SUS_PWRGD: PR373.2 PR513.2 PU19.1(PGOOD)
2.5V_SUS_PWRGD: D50.1(OUT) PR498.2 PU23.1(POK)
3.3V_ALW_ON: C725.1 Q31.3(D) R228.1 R448.1
3.3V_BST: PR226.1 PU2.9(VBST2)
3.3V_DH: PQ39.4(G) PU2.10(DRVH2) TP42.1
3.3V_DL: PQ35.4(G) PU2.11(DRVL2) TP99.1
3.3V_SW: PC234.1 PC249.1 PL16.2 PQ35.5(D1) PQ35.6(D2) PQ35.7(D3) PQ35.8(D4) PQ39.1(S1) PQ39.2(S2) PQ39.3(S3) PU2.8(SW2)
3V3IN: C1133.1 C1134.2 R908.1 U28.4(3V3_IN)
3V_GFX_EN: PR468.1 R1023.1 U202.4(Y)
5V_BST: PR227.2 PU2.17(VBST1)
5V_DH: PQ38.4(G) PU2.16(DRVH1) TP100.1
5V_DL: PQ42.4(B) PU2.15(DRVL1) TP103.1
5V_SW: PC83.1 PC235.2 PL17.1 PQ38.1(S1) PQ38.2(S2) PQ38.3(S3) PQ42.5(C1) PQ42.6(C2) PQ42.7(C3) PQ42.8(C4) PU2.18(SW1)
5388VDDQSNS: PU9.2(VDDQSNS) SJ7.2
5388VLDOIN: PC9230.1 PU9.28(VLDOIN) SJ9.2
+1.5V_RTC: C874.1 R621.2 U21.1(VOUT)
+1.05V_RUN: C819.1 C820.1 C821.1 C822.1 C823.1 C824.1 C825.1 C826.1 C827.1 C828.1 C829.1 PC191.1 PC9353.1 PQ52.1(E1) PQ52.2(E2) PQ52.3(E3) PQ73.1(E1) PQ73.2(E2) PQ73.3(E3) R461.2 R576.2 R615.1 R616.1 R617.1 R1062.1 R1082.1 U18.AU17(VDDP_1) U18.AU19(VDDP_2) U18.AV17(VDDP_3) U18.AV19(VDDP_4) U18.AW17(VDDP_5) U18.AW19(VDDP_6)
+1.5V_SUS: C745.1 CN5.34 PC9214.1 PQ72.1(D1) PQ72.2(D2) PQ72.5(D5) PQ72.6(D6) PR374.1 PU21.6(VO) R618.1 R1065.1
+1.05V_SUS: PC9203.1 PC9204.2 PC9340.1 PC9341.1 PC9342.1 PC9347.1 PC9351.1 PC9356.1 PL31.1 PQ52.5(C1) PQ52.6(C2) PQ52.7(C3) PQ52.8(C4) PQ54.1(D1) PQ54.2(D2) PQ54.5(D5) PQ54.6(D6) PQ73.5(C1) PQ73.6(C2) PQ73.7(C3) PQ73.8(C4) PR494.2 R588.1 R625.1
+1.5V_VDD: C414.2 C415.1 C659.2 C660.1 C661.2 C662.2 C663.2 PQ72.4(S) U5.12(VDDRX1) U5.19(VDDTA) U5.20(VDDTX1) U5.31(VDDTX) U5.40(VDDRX)
+1.8V_GFX: C974.1 C979.2 C1006.1 C1007.1 C1008.1 C1009.2 C1010.2 C1011.2 PC9329.1 PC9330.2 PR411.2 PU29.13(VOUT1-1) PU29.14(VOUT1-2) R641.2 R642.2 R705.2 R709.2 R747.2 R748.2 R763.2 R765.2 R944.2 R947.2 R949.2 R951.2 R953.2 R955.2 R957.2 R959.2 R1021.1 R1030.1 U22.AM13(TSVDD) U22.AM15(VDD_18#0) U22.AP15(VDD_18#1) U22.AR15(VDD_18#2)
+1.8V_RUN: C753.2 C770.1 C878.1 C879.1 C1238.1 C9389.1 C9390.1 C9391.1 C9392.1 C9393.1 C9394.1 C9395.1 CN13.1(CPU_VDDIO1) CN13.19(CPU_VDDIO2) PC9327.1 PC9355.1 PQ53.4(S) PR268.1 PU17.6(VDDIO) PU29.1(VIN1-1) PU29.2(VIN1-2) Q9.2(G2) Q9.5(G1) Q32.2(G2) Q32.5(G1) Q33.2(G2) Q33.5(G1) Q44.2(G2) Q44.5(G1) R467.1 R468.1 R471.1 R473.1 R474.1 R475.1 R477.2 R478.2 R479.2 R480.2 R496.2 R498.2 R500.2 R501.2 R502.2 R508.2 R509.2 R510.2 R512.2 R514.1 R516.1 R520.2 R554.2 R555.2 R556.2 R557.2 R599.2 R600.1 R601.2 R1061.1 U18.AP16(VDD_18_1) U18.AP18(VDD_18_2) U19.5(VCC) U20.8(VDD) U202.5(VCC)
+1.8V_SUS: C880.1 C881.1 C1225.1 C1227.2 PC9195.1 PC9196.1 PC9197.1 PC9198.1 PC9199.1 PC9200.1 PL24.1 PQ53.1(D1) PQ53.2(D2) PQ53.5(D5) PQ53.6(D6) R523.1 R983.2 R984.2 R987.2 R988.2 R1080.1 SJ15.1(A) U18.AP10(VDD_18_S5_1) U18.AR9(VDD_18_S5_2) U209.3(VDD(1V8)) U210.3(VDD(1V8))
+1.35V_GFX: C1002.1 C1003.1 C1004.1 C1005.1 C1012.1 C1013.1 C1014.1 C1015.1 C1016.1 C1017.1 C1025.2 C1026.2 C1039.2 C1040.2 C1041.2 C1042.2 C1043.2 C1044.2 C1045.2 C1046.2 C1047.2 C1048.2 C1049.2 C1050.2 C1051.2 C1052.2 C1053.2 C1054.2 C1055.2 C1056.2 C1057.2 C1058.2 C1059.2 C1060.2 C1061.1 C1062.1 C1063.1 C1064.1 C1065.1 C1066.1 C1067.1 C1068.1 C1069.1 C1070.2 C1071.1 C1072.1 C1073.1 C1074.1 C1075.1 C1076.1 C1077.1 C1078.1 C1079.1 C1080.1 C1081.1 C1082.1 C1083.1 C1084.1 C1085.1 C1086.1 C1087.1 C1088.1 C1089.2 C1090.1 C1091.1 C1092.1 C1093.1 C1094.1 C1095.1 C1096.1 C1097.1 C1098.1 C9385.2 C9386.2 C9387.2 C9388.2 PC9291.1 PC9292.1 PC9293.1 PC9294.1 PC9295.1 PC9370.1 PL29.1 R664.1 R665.1 R768.1 R769.1 R770.1 R771.1 R772.1 R773.1 R774.1 R775.1 R785.2 R787.2 R788.1 R789.1 R790.1 R791.1 R796.1 R797.1 R798.1 R799.1 R804.1 R805.1 R806.1 R807.1 SJ20.1(A) U22.AC10(VMEMIO#9) U22.AG10(VMEMIO#10) U22.K11(VMEMIO#0) U22.K13(VMEMIO#1) U22.K19(VMEMIO#2) U22.K23(VMEMIO#3) U22.K27(VMEMIO#4) U22.K31(VMEMIO#5) U22.L10(VMEMIO#6) U22.N10(VMEMIO#7) U22.W10(VMEMIO#8) VRAM1.B1(VDDQ_B1) VRAM1.B3(VDDQ_B3) VRAM1.B12(VDDQ_B12) VRAM1.B14(VDDQ_B14) VRAM1.C5(VDD_C5) VRAM1.C10(VDD_C10) VRAM1.D1(VDDQ_D1) VRAM1.D3(VDDQ_D3) VRAM1.D11(VDD_D11) VRAM1.D12(VDDQ_D12) VRAM1.D14(VDDQ_D14) VRAM1.E5(VDDQ_E5) VRAM1.E10(VDDQ_E10) VRAM1.F1(VDDQ_F1) VRAM1.F3(VDDQ_F3) VRAM1.F12(VDDQ_F12) VRAM1.F14(VDDQ_F14) VRAM1.G1(VDD_G1) VRAM1.G2(VDDQ_G2) VRAM1.G4(VDD_G4) VRAM1.G11(VDD_G11) VRAM1.G13(VDDQ_G13) VRAM1.G14(VDD_G14) VRAM1.H3(VDDQ_H3) VRAM1.H12(VDDQ_H12) VRAM1.K3(VDDQ_K3) VRAM1.K12(VDDQ_K12) VRAM1.L1(VDD_L1) VRAM1.L2(VDDQ_L2) VRAM1.L4(VDD_L4) VRAM1.L11(VDD_L11) VRAM1.L13(VDDQ_L13) VRAM1.L14(VDD_L14) VRAM1.M1(VDDQ_M1) VRAM1.M3(VDDQ_M3) VRAM1.M12(VDDQ_M12) VRAM1.M14(VDDQ_M14) VRAM1.N5(VDDQ_N5) VRAM1.N10(VDDQ_N10) VRAM1.P1(VDDQ_P1) VRAM1.P3(VDDQ_P3) VRAM1.P11(VDD_P11) VRAM1.P12(VDDQ_P12) VRAM1.P14(VDDQ_P14) VRAM1.R5(VDD_R5) VRAM1.R10(VDD_R10) VRAM1.T1(VDDQ_T1) VRAM1.T3(VDDQ_T3) VRAM1.T12(VDDQ_T12) VRAM1.T14(VDDQ_T14) VRAM2.B1(VDDQ_B1) VRAM2.B3(VDDQ_B3) VRAM2.B12(VDDQ_B12) VRAM2.B14(VDDQ_B14) VRAM2.C5(VDD_C5) VRAM2.C10(VDD_C10) VRAM2.D1(VDDQ_D1) VRAM2.D3(VDDQ_D3) VRAM2.D11(VDD_D11) VRAM2.D12(VDDQ_D12) VRAM2.D14(VDDQ_D14) VRAM2.E5(VDDQ_E5) VRAM2.E10(VDDQ_E10) VRAM2.F1(VDDQ_F1) VRAM2.F3(VDDQ_F3) VRAM2.F12(VDDQ_F12) VRAM2.F14(VDDQ_F14) VRAM2.G1(VDD_G1) VRAM2.G2(VDDQ_G2) VRAM2.G4(VDD_G4) VRAM2.G11(VDD_G11) VRAM2.G13(VDDQ_G13) VRAM2.G14(VDD_G14) VRAM2.H3(VDDQ_H3) VRAM2.H12(VDDQ_H12) VRAM2.K3(VDDQ_K3) VRAM2.K12(VDDQ_K12) VRAM2.L1(VDD_L1) VRAM2.L2(VDDQ_L2) VRAM2.L4(VDD_L4) VRAM2.L11(VDD_L11) VRAM2.L13(VDDQ_L13) VRAM2.L14(VDD_L14) VRAM2.M1(VDDQ_M1) VRAM2.M3(VDDQ_M3) VRAM2.M12(VDDQ_M12) VRAM2.M14(VDDQ_M14) VRAM2.N5(VDDQ_N5) VRAM2.N10(VDDQ_N10) VRAM2.P1(VDDQ_P1) VRAM2.P3(VDDQ_P3) VRAM2.P11(VDD_P11) VRAM2.P12(VDDQ_P12) VRAM2.P14(VDDQ_P14) VRAM2.R5(VDD_R5) VRAM2.R10(VDD_R10) VRAM2.T1(VDDQ_T1) VRAM2.T3(VDDQ_T3) VRAM2.T12(VDDQ_T12) VRAM2.T14(VDDQ_T14) VRAM3.B1(VDDQ_B1) VRAM3.B3(VDDQ_B3) VRAM3.B12(VDDQ_B12) VRAM3.B14(VDDQ_B14) VRAM3.C5(VDD_C5) VRAM3.C10(VDD_C10) VRAM3.D1(VDDQ_D1) VRAM3.D3(VDDQ_D3) VRAM3.D11(VDD_D11) VRAM3.D12(VDDQ_D12) VRAM3.D14(VDDQ_D14) VRAM3.E5(VDDQ_E5) VRAM3.E10(VDDQ_E10) VRAM3.F1(VDDQ_F1) VRAM3.F3(VDDQ_F3) VRAM3.F12(VDDQ_F12) VRAM3.F14(VDDQ_F14) VRAM3.G1(VDD_G1) VRAM3.G2(VDDQ_G2) VRAM3.G4(VDD_G4) VRAM3.G11(VDD_G11) VRAM3.G13(VDDQ_G13) VRAM3.G14(VDD_G14) VRAM3.H3(VDDQ_H3) VRAM3.H12(VDDQ_H12) VRAM3.K3(VDDQ_K3) VRAM3.K12(VDDQ_K12) VRAM3.L1(VDD_L1) VRAM3.L2(VDDQ_L2) VRAM3.L4(VDD_L4) VRAM3.L11(VDD_L11) VRAM3.L13(VDDQ_L13) VRAM3.L14(VDD_L14) VRAM3.M1(VDDQ_M1) VRAM3.M3(VDDQ_M3) VRAM3.M12(VDDQ_M12) VRAM3.M14(VDDQ_M14) VRAM3.N5(VDDQ_N5) VRAM3.N10(VDDQ_N10) VRAM3.P1(VDDQ_P1) VRAM3.P3(VDDQ_P3) VRAM3.P11(VDD_P11) VRAM3.P12(VDDQ_P12) VRAM3.P14(VDDQ_P14) VRAM3.R5(VDD_R5) VRAM3.R10(VDD_R10) VRAM3.T1(VDDQ_T1) VRAM3.T3(VDDQ_T3) VRAM3.T12(VDDQ_T12) VRAM3.T14(VDDQ_T14) VRAM4.B1(VDDQ_B1) VRAM4.B3(VDDQ_B3) VRAM4.B12(VDDQ_B12) VRAM4.B14(VDDQ_B14) VRAM4.C5(VDD_C5) VRAM4.C10(VDD_C10) VRAM4.D1(VDDQ_D1) VRAM4.D3(VDDQ_D3) VRAM4.D11(VDD_D11) VRAM4.D12(VDDQ_D12) VRAM4.D14(VDDQ_D14) VRAM4.E5(VDDQ_E5) VRAM4.E10(VDDQ_E10) VRAM4.F1(VDDQ_F1) VRAM4.F3(VDDQ_F3) VRAM4.F12(VDDQ_F12) VRAM4.F14(VDDQ_F14) VRAM4.G1(VDD_G1) VRAM4.G2(VDDQ_G2) VRAM4.G4(VDD_G4) VRAM4.G11(VDD_G11) VRAM4.G13(VDDQ_G13) VRAM4.G14(VDD_G14) VRAM4.H3(VDDQ_H3) VRAM4.H12(VDDQ_H12) VRAM4.K3(VDDQ_K3) VRAM4.K12(VDDQ_K12) VRAM4.L1(VDD_L1) VRAM4.L2(VDDQ_L2) VRAM4.L4(VDD_L4) VRAM4.L11(VDD_L11) VRAM4.L13(VDDQ_L13) VRAM4.L14(VDD_L14) VRAM4.M1(VDDQ_M1) VRAM4.M3(VDDQ_M3) VRAM4.M12(VDDQ_M12) VRAM4.M14(VDDQ_M14) VRAM4.N5(VDDQ_N5) VRAM4.N10(VDDQ_N10) VRAM4.P1(VDDQ_P1) VRAM4.P3(VDDQ_P3) VRAM4.P11(VDD_P11) VRAM4.P12(VDDQ_P12) VRAM4.P14(VDDQ_P14) VRAM4.R5(VDD_R5) VRAM4.R10(VDD_R10) VRAM4.T1(VDDQ_T1) VRAM4.T3(VDDQ_T3) VRAM4.T12(VDDQ_T12) VRAM4.T14(VDDQ_T14)
+2.5V_SUS: C887.1 C906.1 C907.1 C908.1 C919.1 C936.1 C937.1 C938.1 CN16.257(VPP1) CN16.259(VPP2) CN17.257(VPP1) CN17.259(VPP2) PC9237.1 PR387.1 PU23.6(VO)
+3.3V_ALW: C638.2 C691.1 C1181.1 ESD1.5 J3.4 PC221.1 PC223.1 PC9210.1 PC9211.1 PC9233.1 PC9234.1 PC9306.1 PC9307.1 PL16.1 PR192.1 PR203.1 PR222.1 PR245.1 PR498.1 PR513.1 PR514.1 PU21.3(VIN) PU23.3(VIN) PU28.1(VIN1-1) PU28.2(VIN1-2) PU28.6(VIN2-1) PU28.7(VIN2-2) R436.2 R445.2 R852.1 R862.2 R863.1 R864.1 R865.1 R866.1 R876.1 R878.1 R966.2 R970.2 R1088.1 RT1.1 RT2.1 SJ13.1(A) U33.8(VCC) U207.5(IN)
+3.3V_ALW_AVCC: C1210.2 L14.1 U34.74(AVCC)
+3.3V_EC: C1175.1 C1176.2 C1177.2 C1178.2 C1211.2 L14.2 R852.2 U34.26(VSTBY1) U34.50(VSTBY2) U34.92(VSTBY3) U34.114(VSTBY4) U34.121(VSTBY5) U34.127(VSTBY)
+3.3V_EN2: PU2.6(EN2) R226.2 R228.2
+3.3V_RTC_LDO: PC225.1 PU2.3(VREG3) R435.1 R443.2 R447.1 R448.2 R861.2 RTCD1.1(ANODE1)
+3.3V_RUN: C413.2 C478.1 C479.1 C526.1 C529.1 C533.1 C573.1 C664.1 C700.1 C701.1 C746.1 C889.1 C917.1 CN5.35 CN9.6 CN10.2(3.3V) CN10.4(3.3V#4) CN10.72(3.3V#72) CN10.74(3.3V#74) CN16.255(VDDSPD) CN17.255(VDDSPD) PC9315.1 PC9316.1 PR507.1 PR509.1 PU28.8(OUT2-1) PU28.9(OUT2-2) Q51.2(G) R55.2 R73.2 R75.2 R92.2 R96.2 R97.2 R201.2 R235.2 R239.2 R241.2 R262.1 R264.1 R321.2 R345.2 R347.2 R349.2 R459.2 R469.1 R470.1 R481.1 R482.1 R524.1 R525.1 R526.1 R527.1 R528.2 R560.1 R580.2 R582.2 R592.1 R593.1 R594.1 R623.1 R867.1 R868.1 R908.2 R913.1 R914.1 R917.1 R918.1 R965.2 R994.1 R1006.2 R1011.1 R1012.1 R1027.2 R1029.1 R1032.1 R1045.2 R1060.1 R1070.2 R1089.2 U5.11(VDD33_1) U5.37(VDD33) U9.1(VDD) U34.11(VCC) U206.5(IN)
+3.3V_SSD: C692.1 C694.2 C703.1 C723.2 C729.1 C730.1 C733.1 C9368.2 C9369.2 CON1.2(3.3VAUX) CON1.4(3.3VAUX#4) CON1.70(3.3VAUX#70) CON1.72(3.3VAUX#72) CON1.74(3.3VAUX#74) R459.1
+3.3V_SUS: PC9313.1 PC9314.1 PC9328.1 PR111.2 PR456.2 PU28.13(VOUT1-1) PU28.14(VOUT1-2) PU29.6(VIN2-1) PU29.7(VIN2-2) Q26.3 R415.2 R532.1 R533.1 R536.2 R539.2 R543.2 R545.1 R546.1 R549.2 R550.2 R551.1 R552.2 R568.2 R570.2 R571.2 R573.2 R595.1 R596.1 R597.1 R598.1 R624.1 R1005.2 R1010.1 R1040.2 R1054.1 R1107.1
+3.3V_TP: C503.1 C504.1 C509.1 CN4.8 Q26.1 R150.2 R151.2 R170.2 R171.2 R172.1 R173.1 R415.1 R416.2
+3V_GFX: C964.1 C970.1 C9373.1 PC9331.2 PC9332.1 PR407.2 PU29.8(OUT2-1) PU29.9(OUT2-2) R645.2 R647.1 R679.2 R683.2 R688.2 R690.2 R731.1 R732.1 R923.2 R925.2 R927.2 R929.2 R931.2 R933.2 R934.2 R936.2 R938.2 R940.2 R942.2 R960.2 R1016.1 R1028.1 R1031.1 R1091.2 U22.AM31(VDD_33) U24.5(+3V) U208.3(WP#) U208.7(HOLD#) U208.8(VDD)
+3V_RTC: C876.1 C877.1 R1071.1 R1087.1 RTCD1.3(CATHODE) U21.3(VIN)
+3VLANVCC: C341.1 C624.2 C627.1 C628.2 C632.2 C634.2 C635.1 Q49.2(G) R303.1 U2.11(AVDD33(NC)) U2.23(VDDREG(DVDD33)) U2.32(AVDD33) U207.1(OUT)
+5V_ALW: C496.2 C497.2 C512.1 C513.1 C517.1 C9375.2 C9376.2 CN3.7 CN3.8 J2.1 J3.1 PC86.1 PC222.1 PC233.1 PC237.1 PC9213.1 PC9236.1 PC9305.1 PC9308.1 PC9317.2 PC9318.2 PC9333.2 PD5.2 PL17.2 PR107.2 PR363.2 PR453.2 PR457.2 PR471.2 PU21.4(VPP) PU23.4(VPP) PU27.1(VIN1-1) PU27.2(VIN1-2) PU27.4(VBIAS) PU27.6(VIN2-1) PU27.7(VIN2-2) PU28.4(VBIAS) PU29.4(VBIAS) R132.2 R404.2 R1063.1 R1078.1 SJ11.1(A) SJ12.1(A) U7.1(IN)
+5V_ALW2: C724.1 PC248.1 PD1.1 PR175.1 PR196.2 PR214.1 PR484.1 PU2.13(VREG5) R399.1
+5V_ALW_USB3: C688.2 R404.1 U7.4(ILIM_SEL)
+5V_HDMIF1: C391.1 CN7.18(+5V) D1.2(IN) D2.2(IN) HDMIF1.2
+5V_HDMIF1_D: D1.1(OUT) R84.1
+5V_HDMIF1_D24: D2.1(OUT) R83.1
+5V_RUN: C334.1 C339.2 C370.2 C371.1 C530.1 C531.1 C734.1 C735.1 C743.1 C744.1 CN5.37 CN5.38 CN5.39 CN5.40 CN12.5(5V_2) CN12.6(5V_1) CN12.7(5V_0) FAN1.4 FAN2.4 FS1.1 HDMIF1.1 PC9311.1 PC9312.1 PU27.8(OUT2-1) PU27.9(OUT2-2) Q20.1(E) R1059.1
+5V_SUS: PC9106.1 PC9146.1 PC9207.2 PC9254.1 PC9309.1 PC9310.1 PR254.2 PR305.2 PR312.2 PR397.2 PR455.2 PR461.2 PU16.26(VDDP) PU17.26(VDDP) PU20.1(VCC) PU24.26(VDDP) PU27.13(VOUT1-1) PU27.14(VOUT1-2) PU30.8(POWER)
+15V_ALW: PC87.1 PD6.1 PD7.1 PR62.2 PR178.1 PR485.1 R393.1 R417.1
+5388VCC: PC138.2 PC142.2 PR103.2 PR107.1 PU9.9(VCC)
+VCCRTC_2: RTCD1.2(ANODE2) RTCR1.2
+VDDBT_RTC: C873.1 C875.1 Q37.3 R621.1 U18.AR17(VDDBT_RTC_G)
+VDDCI: C980.1 C981.1 C983.1 C990.1 C991.2 C992.2 C1018.1 C1019.1 C1020.1 C1021.1 C1022.1 C1023.1 C1024.1 C9384.1 PC9247.1 PC9248.1 PC9249.1 PC9250.1 PL26.1 PR390.1 SJ19.1(A) U22.AA11(VDDCI#7) U22.AC32(VDD_08#0) U22.AE11(VDDCI#8) U22.AG32(VDD_08#1) U22.AG35(VDD_08#2) U22.AJ32(VDD_08#3) U22.AJ34(VDD_08#4) U22.AL34(VDD_08#5) U22.L13(VDDCI#0) U22.L17(VDDCI#1) U22.L21(VDDCI#2) U22.L25(VDDCI#3) U22.L29(VDDCI#4) U22.N11(VDDCI#5) U22.U11(VDDCI#6) U22.W32(VDD_08)
+VDDCR_CPU: C776.1 C777.1 C779.1 C792.1 C793.1 C802.1 C803.1 C804.1 C805.1 C806.1 C807.1 C808.1 C809.1 C810.1 C1107.1 C1108.1 C1109.1 C1110.1 C1111.1 C1112.1 C1113.1 C1122.2 C1123.2 C1125.2 CS1.2 CS2.1 CS8.2 PC9116.1 PC9117.1 PC9119.1 PC9120.1 PC9121.1 PC9138.1 PC9140.1 PC9142.1 PC9143.1 PL19.2 PL20.2 PR294.1 R1057.1 U18.AB7(VDDCR_CPU_13) U18.AB9(VDDCR_CPU_14) U18.AB12(VDDCR_CPU_15) U18.AB15(VDDCR_CPU_16) U18.AB18(VDDCR_CPU_17) U18.AB21(VDDCR_CPU_18) U18.AD6(VDDCR_CPU_19) U18.AD10(VDDCR_CPU_20) U18.AD13(VDDCR_CPU_21) U18.AD16(VDDCR_CPU_22) U18.AD19(VDDCR_CPU_23) U18.AD22(VDDCR_CPU_24) U18.AE7(VDDCR_CPU_25) U18.AE12(VDDCR_CPU_26) U18.AE15(VDDCR_CPU_27) U18.AE18(VDDCR_CPU_28) U18.AE21(VDDCR_CPU_29) U18.AG6(VDDCR_CPU_30) U18.AG10(VDDCR_CPU_31) U18.AG13(VDDCR_CPU_32) U18.AG16(VDDCR_CPU_33) U18.AG19(VDDCR_CPU_34) U18.AG22(VDDCR_CPU_35) U18.AH7(VDDCR_CPU_36) U18.AH12(VDDCR_CPU_37) U18.AH15(VDDCR_CPU_38) U18.AH18(VDDCR_CPU_39) U18.AH21(VDDCR_CPU_40) U18.AK6(VDDCR_CPU_41) U18.AK9(VDDCR_CPU_42) U18.AK10(VDDCR_CPU_43) U18.AK13(VDDCR_CPU_44) U18.AK16(VDDCR_CPU_45) U18.AK19(VDDCR_CPU_46) U18.AK22(VDDCR_CPU_47) U18.AL7(VDDCR_CPU_48) U18.AN6(VDDCR_CPU_49) U18.U8(VDDCR_CPU_1) U18.W7(VDDCR_CPU_2) U18.W12(VDDCR_CPU_3) U18.W15(VDDCR_CPU_4) U18.W18(VDDCR_CPU_5) U18.W21(VDDCR_CPU_6) U18.Y8(VDDCR_CPU_7) U18.Y10(VDDCR_CPU_8) U18.Y13(VDDCR_CPU_9) U18.Y16(VDDCR_CPU_10) U18.Y19(VDDCR_CPU_11) U18.Y22(VDDCR_CPU_12)
+VDDCR_FCH_ALW: PC9302.1 PC9303.1 PC9304.1 PQ64.3 PQ68.3 R619.1
+VDDCR_FCH_S5: PC9205.1 PC9206.1 PQ54.4(S) PQ65.3 PQ67.3 PR366.2
+VDDCR_FCH_S5_R: C842.1 C843.1 C844.1 R619.2 U18.AP13(VDDCR_FCH_S5_1) U18.AR12(VDDCR_FCH_S5_2)
+VDDCR_GFX: C833.1 C834.1 C835.1 C836.1 C837.1 C838.1 C839.1 C840.1 C841.1 C845.1 C846.1 C847.1 C848.1 C849.1 C850.1 C851.1 C852.1 C853.1 C854.1 C1114.1 C1115.1 C1116.1 C1117.1 C1118.1 C1119.1 C1120.1 C1121.1 C1126.2 C1127.2 C1131.2 CS1.1 PC9151.1 PC9152.1 PC9153.1 PC9154.1 PC9155.1 PC9167.1 PC9168.1 PC9169.1 PC9171.1 PC9172.1 PC9173.1 PL21.2 PL22.2 PR338.1 R1058.1 U18.F12(VDDCR_GFX_1) U18.F15(VDDCR_GFX_2) U18.G11(VDDCR_GFX_3) U18.G14(VDDCR_GFX_4) U18.J8(VDDCR_GFX_5) U18.J9(VDDCR_GFX_6) U18.J11(VDDCR_GFX_7) U18.K7(VDDCR_GFX_8) U18.K12(VDDCR_GFX_9) U18.K13(VDDCR_GFX_10) U18.K15(VDDCR_GFX_11) U18.K16(VDDCR_GFX_12) U18.K19(VDDCR_GFX_13) U18.L8(VDDCR_GFX_14) U18.L13(VDDCR_GFX_15) U18.L16(VDDCR_GFX_16) U18.L19(VDDCR_GFX_17) U18.L22(VDDCR_GFX_18) U18.N7(VDDCR_GFX_19) U18.N12(VDDCR_GFX_20) U18.N15(VDDCR_GFX_21) U18.N18(VDDCR_GFX_22) U18.N21(VDDCR_GFX_23) U18.P8(VDDCR_GFX_24) U18.P13(VDDCR_GFX_25) U18.P16(VDDCR_GFX_26) U18.P19(VDDCR_GFX_27) U18.P22(VDDCR_GFX_28) U18.T7(VDDCR_GFX_29) U18.T12(VDDCR_GFX_30) U18.T15(VDDCR_GFX_31) U18.T18(VDDCR_GFX_32) U18.T21(VDDCR_GFX_33) U18.U13(VDDCR_GFX_34) U18.U16(VDDCR_GFX_35) U18.U19(VDDCR_GFX_36) U18.U22(VDDCR_GFX_37)
+VDDCR_NB: C860.1 C862.1 C863.1 C864.1 C865.1 C866.1 C867.1 C868.1 C869.1 C870.1 C871.1 C872.1 C1200.1 C1202.1 C1206.1 C1209.1 CS2.2 CS4.1 PC9107.1 PC9108.1 PC9109.1 PC9110.1 PL18.2 PQ63.3 PR246.1 PR458.2 PU30.3(PLUS INPUT) R1056.1 U18.AL12(VDDCR_NB_1) U18.AL13(VDDCR_NB_2) U18.AL15(VDDCR_NB_3) U18.AL18(VDDCR_NB_4) U18.AL21(VDDCR_NB_5) U18.AN13(VDDCR_NB_6) U18.AN16(VDDCR_NB_7) U18.AN19(VDDCR_NB_8) U18.AN22(VDDCR_NB_9)
+VDDP_GFX: C817.1 C818.1 R615.2 R616.2 R617.2 U18.AE5(VDDP_GFX_1) U18.AE6(VDDP_GFX_2)
+VDDP_S5: C885.1 C886.1 R625.2 U18.AN12(VDDP_S5_1) U18.AP12(VDDP_S5_2)
