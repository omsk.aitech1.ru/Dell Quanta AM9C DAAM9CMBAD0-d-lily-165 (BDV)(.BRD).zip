# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_CLK+: length 3.6
  TOP w0.114: C424.2 274.18,61.86 274.26,61.94 274.26,62.2 274.06,62.39 273.56,62.39 272.77,63.18 272.77,63.49 272.68,63.58 U5.9
HDMI_CLK+_C: length 11.9
  TOP w0.102: v1(278.07,73.37) 277.78,73.08 277.67,73.08 R337.2 277.17,73.06 276.37,73.06 R336.1
  BOTTOM w0.102: v1(278.07,73.37) 278.36,73.08 278.75,73.08 278.88,73.21 278.88,74.57 278.75,74.7 276.93,74.7 276.63,75 276.63,76.03 276.93,76.34 279.57,76.34 CN7.10
HDMI_CLK+_R: length 10.4
  TOP w0.102: R336.2 275.11,73.23 273.82,73.23 273.7,73.36 273.7,73.64 273.39,73.94 272.62,73.94 272.32,73.64 272.32,72.04 272.7,71.66 273.8,71.66 273.98,71.48 273.98,71.23 273.78,71.02 273.09,71.02 272.73,70.66 272.73,69.63 272.68,69.58 U5.22
HDMI_CLK-: length 3.6
  TOP w0.114: U5.10 273.08,63.58 272.99,63.49 272.99,63.27 273.65,62.61 274.15,62.61 274.47,62.29 274.47,62 274.61,61.86 C425.2
HDMI_CLK-_C: length 11.9
  TOP w0.102: R340.1 276.43,72.75 277.21,72.75 R337.1 277.67,72.77 277.78,72.77 v1(278.07,72.48)
  BOTTOM w0.102: v1(278.07,72.48) 278.36,72.77 278.88,72.77 279.18,73.08 279.18,74.7 278.88,75 277.06,75 276.93,75.13 276.93,75.9 277.06,76.03 279.57,76.03 CN7.12
HDMI_CLK-_R: length 10.3
  TOP w0.102: U5.21 273.08,69.58 273.03,69.62 273.03,70.54 273.22,70.72 273.9,70.72 274.28,71.1 274.28,71.61 273.93,71.96 272.82,71.96 272.62,72.17 272.62,73.51 272.75,73.64 273.27,73.64 273.39,73.51 273.39,73.23 273.7,72.93 275.17,72.93 275.26,72.84 R340.2
HDMI_DCIN_EN: length 3.5
  TOP w0.114: R97.1 276.11,65.08 276.11,65.45 275.78,65.77 274.43,65.77 274.31,65.65 U5.13
HDMI_DDCBUF: length 5.1
  TOP w0.114: U5.14 274.31,66.05 274.35,66.02 275.08,66.02 v1(275.3,66.24)
  BOTTOM w0.114: R349.1 276.02,64.84 275.3,65.56 v1(275.22,65.56) 274.68,65.56 R348.1 274.6,65.99 275.06,65.99 v1(275.3,66.24)
HDMI_EQ: length 3.6
  TOP w0.114: v1(275.22,67.19) 275.16,67.25 U5.17
  BOTTOM w0.114: R347.1 R346.1 275.86,66.55 v1(275.22,67.19)
HDMI_HP: length 16.9
  TOP w0.191: v1(270.26,69.99) 270.28,69.97 U5.28
  IN1 w0.089: v1(270.26,69.99) 270.28,69.99 270.94,70.65 276.17,70.65 276.65,70.17 276.65,68.37 277.09,67.93 277.94,67.93 278.76,68.74 278.76,69.8 279.53,70.57 279.8,70.57 CN7.19
HDMI_ISET: length 4
  TOP w0.114: U5.34 268.32,67.25 268.01,67.56 267.1,67.56 266.85,67.82 R94.1 v1(266.85,68.76) R92.1
HDMI_PRE: length 3.6
  TOP w0.114: U5.16 274.48,66.85 274.55,66.92 274.87,66.92 275.12,66.67 275.63,66.67 275.73,66.57 R95.1 276.53,66.06 R96.1
HDMI_SCL: length 320.4
  TOP w0.114: v1(267.48,65.54) 267.6,65.65 U5.38
  IN1 w0.089: v1(267.48,65.54) 268.04,65.54 268.86,64.72 268.86,64.07 271.06,61.88 271.33,61.88 271.92,61.3 271.92,61.3 273.09,60.13 273.09,56.01 272.49,55.41 272.49,53.92 269.45,50.87 266.01,50.87 248.62,33.48 205.7,33.48 203.09,30.87 191.37,30.87 189.71,29.21 162.22,29.21 161.58,28.57 151,28.57 149.85,27.42 128.79,27.42 126.84,29.37 121.89,29.37 119.18,32.09 117.68,32.09 114.18,35.59 114.18,47.22 113.46,47.94 113.46,69.1 114.06,69.7 114.06,76.97 116.31,79.21 116.31,84.2 116.71,84.6 116.71,85.79 115.85,86.66 114.58,86.66 113.13,88.1 113.13,88.69 109.81,92.01 109.81,95.73 106.03,99.51 106.03,102.75 102.86,105.92 102.86,107.38 99.53,110.72 98.09,110.72 97.57,111.23 97.57,111.77 97.3,112.04 96.23,112.04 94.79,113.49 89.85,113.49 88.08,111.72 86.48,111.72 86.31,111.88 84.71,111.88 84.46,112.13 82.52,112.13 81.81,112.85 81.81,113.16 81.59,113.38 80.67,113.38 80.51,113.54 78.63,113.54 78.17,114 75.39,114 73.9,112.5 71.8,112.5 71.18,113.12 71.18,113.57 70.87,113.88 62.14,113.88 61.85,113.6 59.74,113.6 59.01,112.86 59.01,112.63 v2(59.13,112.51)
  BOTTOM w0.114: U18.F7 59.55,112.09 v2(59.13,112.51)
HDMI_SCL_SNK: length 21.4
  TOP w0.114: R84.2 278.29,70.5 v1(278.44,70.34) ; v1(267.48,68.75) 267.51,68.71 267.69,68.71 268.35,68.05 U5.32
  IN1 w0.089: v1(267.48,68.75) 267.58,68.75 271.6,72.78 276.43,72.78 277.91,71.3 277.91,70.88 v1(278.44,70.34) 279.37,71.28 279.67,71.28 280.69,72.3 280.69,73.46 CN7.15
HDMI_SDA: length 320.3
  TOP w0.114: U5.39 267.82,65.25 v1(267.46,64.89)
  IN1 w0.089: v1(58.48,112.51) 58.61,112.64 58.61,113.03 59.58,113.99 61.69,113.99 61.97,114.27 71.03,114.27 71.57,113.73 71.57,113.29 71.96,112.9 73.73,112.9 75.23,114.39 78.33,114.39 78.79,113.93 80.68,113.93 80.83,113.77 81.75,113.77 82.2,113.32 82.2,113.01 82.69,112.53 84.65,112.53 84.9,112.27 86.48,112.27 86.64,112.11 87.91,112.11 89.68,113.88 94.95,113.88 96.39,112.44 97.46,112.44 97.97,111.93 97.97,111.39 98.25,111.11 99.69,111.11 103.25,107.55 103.25,106.08 106.42,102.92 106.42,99.67 110.2,95.89 110.2,92.2 113.53,88.88 113.53,88.26 114.74,87.05 116.02,87.05 117.51,85.55 117.51,79.81 114.46,76.76 114.46,69.54 113.85,68.93 113.85,48.11 114.57,47.39 114.57,35.75 117.85,32.48 119.35,32.48 122.06,29.77 127,29.77 128.95,27.82 149.68,27.82 150.83,28.97 161.42,28.97 162.06,29.6 189.55,29.6 191.21,31.26 202.87,31.26 205.48,33.87 248.45,33.87 265.85,51.27 269.28,51.27 272.09,54.08 272.09,55.58 272.69,56.18 272.69,59.96 271.17,61.49 270.89,61.49 268.47,63.91 268.47,64.56 267.89,65.13 267.71,65.13 v1(267.46,64.89)
  BOTTOM w0.114: U18.E7 58.87,111.92 58.87,112.11 v1(58.48,112.51)
HDMI_SDA_SNK: length 23.3
  TOP w0.114: v1(267.5,67.97) 268,67.97 268.31,67.65 U5.33 ; R83.2 v1(277.45,68.76)
  IN1 w0.089: v1(267.5,67.97) 267.83,67.97 268.77,68.91 268.77,69.39 271.77,72.38 276.27,72.38 277.38,71.27 277.38,70.85 277.79,70.44 277.79,69.1 v1(277.45,68.76)
  IN4 w0.089: CN7.16 279.06,72.82 279.06,71.82 277.8,70.55 277.8,69.11 v1(277.45,68.76)
HDMI_TX0+: length 2.8
  TOP w0.114: U5.6 271.48,63.69 271.57,63.6 271.57,63.14 272.25,62.46 272.25,62.27 C422.2
HDMI_TX0+_C: length 13.9
  TOP w0.102: CN7.7 281.08,77.84 280.85,77.84 280.51,77.51 280.51,72.19 280.28,71.96 279.58,71.96 279.01,72.53 279.01,74.36 278.03,75.34 277.67,75.34 R342.2 277.17,75.31 276.4,75.31 R341.1
HDMI_TX0+_R: length 9.6
  TOP w0.102: R341.2 275.14,75.54 272.81,75.54 271.36,74.1 271.36,71.05 271.53,70.88 271.53,69.64 271.48,69.59 U5.25
HDMI_TX0-: length 2.8
  TOP w0.114: U5.7 271.88,63.72 271.79,63.63 271.79,63.23 272.47,62.55 272.47,62.25 C423.2
HDMI_TX0-_C: length 13.9
  TOP w0.102: CN7.9 281.06,77.54 280.98,77.54 280.82,77.38 280.82,72.07 280.41,71.65 279.45,71.65 278.7,72.4 278.7,74.23 277.9,75.04 277.67,75.04 R342.1 277.22,75.01 276.4,75.01 R344.1
HDMI_TX0-_R: length 9.6
  TOP w0.102: R344.2 275.26,75.1 275.12,75.24 272.94,75.24 271.67,73.97 271.67,71.18 271.83,71.01 271.83,69.64 271.88,69.59 U5.24
HDMI_TX1+: length 2.8
  TOP w0.114: C420.2 270.21,62.26 270.21,62.5 270.79,63.09 270.79,63.57 270.68,63.68 U5.4
HDMI_TX1+_C: length 12.3
  TOP w0.102: R329.1 274.72,77.37 275.54,77.37 R330.2 276.01,77.37 276.67,77.37 276.77,77.47 276.77,78.87 277.08,79.18 277.71,79.18 278.02,78.87 278.02,76.71 278.14,76.59 278.37,76.59 278.73,76.95 278.73,79.05 279.01,79.34 279.57,79.34 CN7.4
HDMI_TX1+_R: length 10.5
  TOP w0.102: R329.2 273.46,77.55 272.61,77.55 272.12,77.07 272.12,76.38 270.47,74.73 270.47,70.62 270.73,70.36 270.73,69.65 270.68,69.6 U5.27
HDMI_TX1-: length 2.8
  TOP w0.114: U5.5 271.08,63.67 271.01,63.59 271.01,63 270.42,62.41 270.42,62.26 C421.2
HDMI_TX1-_C: length 12.3
  TOP w0.102: CN7.6 279.57,79.03 279.14,79.03 279.03,78.92 279.03,76.82 278.49,76.28 278.02,76.28 277.71,76.59 277.71,78.75 277.58,78.87 277.2,78.87 277.08,78.75 277.08,77.35 276.8,77.07 276.02,77.07 R330.1 275.54,77.07 274.77,77.07 R333.1
HDMI_TX1-_R: length 10.4
  TOP w0.102: U5.26 271.08,69.6 271.03,69.65 271.03,70.49 270.78,70.75 270.78,74.61 272.43,76.26 272.43,76.94 272.73,77.25 273.52,77.25 273.61,77.15 R333.2
HDMI_TX2+: length 3.6
  TOP w0.114: C418.2 268.03,61.86 268.11,61.94 268.11,62.31 268.51,62.71 269.02,62.71 269.57,63.26 269.57,63.51 269.48,63.61 U5.1
HDMI_TX2+_C: length 12.6
  TOP w0.102: R320.1 274.75,79.51 275.52,79.51 R324.2 276.04,79.51 276.26,79.51 276.62,79.86 276.62,81.41 276.92,81.72 277.69,81.72 277.99,81.41 277.99,80.24 278.09,80.14 278.45,80.14 278.55,80.24 278.55,81.49 278.96,81.89 279.97,81.89 280.99,80.88 281.11,80.88 CN7.1
HDMI_TX2+_R: length 13.1
  TOP w0.102: U5.30 269.48,69.6 269.51,69.63 269.51,74.94 270.98,76.41 270.98,78.31 272.38,79.71 273.46,79.71 R320.2
HDMI_TX2-: length 3.6
  TOP w0.114: C419.2 268.39,61.86 268.33,61.93 268.33,62.22 268.6,62.49 269.11,62.49 269.79,63.17 269.79,63.51 269.88,63.61 U5.2
HDMI_TX2-_C: length 12.6
  TOP w0.102: R325.1 274.75,79.2 275.56,79.2 R324.1 275.99,79.2 276.39,79.2 276.92,79.74 276.92,81.29 277.05,81.41 277.56,81.41 277.69,81.29 277.69,80.12 277.97,79.84 278.57,79.84 278.85,80.12 278.85,81.36 279.08,81.59 279.85,81.59 280.86,80.57 281.04,80.57 281.42,80.19 CN7.3
HDMI_TX2-_R: length 13
  TOP w0.102: U5.29 269.88,69.6 269.81,69.67 269.81,74.81 271.29,76.28 271.29,78.19 272.51,79.41 273.52,79.41 273.61,79.31 R325.2
HDT_APU_TDI: length 3.1
  TOP w0.114: CN13.6 47.62,26.65 v1(48.13,26.14) R511.2
HDT_DBREQ#: length 3.2
  TOP w0.114: R519.2 48.39,20.3 v1(48.07,20.3) CN13.16
HDT_TRST#: length 3
  TOP w0.114: CN13.9 v1(40.17,24.11) 39.92,23.86 R513.1
HSYNC: length 23
  TOP w0.114: v2(133.92,103.91) 133.92,104.57 133.78,104.71 133.78,105.05 133.09,105.74 131.35,105.74 129.28,107.81 129.28,108.53 128.48,109.33 126.36,109.33 124.29,111.4 122.91,111.4 119.78,114.53 v1(119.19,114.53) R940.1 R941.2
  BOTTOM w0.127: U22.W34 133.55,103.54 v2(133.92,103.91)
HVBEN_L: length 2.8
  TOP w0.114: v2(87.4,105.96) 87.4,105.55 87.72,105.23 88.15,105.23 88.57,104.82 R541.1
  BOTTOM w0.102: U18.BB14 87.56,105.8 v2(87.4,105.96)
HWPG: length 279.2
  TOP w0.114: v1(219.69,31.05) 221.35,32.71 229.28,32.71 230.61,31.38 231.31,31.38 232.2,30.5 232.2,29.9 232.6,29.5 232.73,29.5 ; 232.73,29.5 231.02,27.79 230.49,27.79 229.97,27.27 U34.109 ; 232.73,29.5 R433.1 ; v1(202.41,9.93) 201.95,9.48 195.76,9.48 189.75,15.49 185.57,15.49 179.81,21.25 166.74,21.25 166.13,21.87 159.51,21.87 159.1,22.28 136.31,22.28 135.77,22.81 135.77,23.61 135.02,24.36 131.16,24.36 130.06,23.26 125.22,23.26 124.57,23.9 120.26,23.9 119.11,22.75 114.35,22.75 113.2,23.89 113.2,25.58 112.84,25.95 112.84,28.02 111.94,28.92 111.94,32.29 116.03,36.39 116.03,37.71 116.35,38.03 116.35,47.33 118.33,49.31 118.33,55.35 117.02,56.67 117.02,60.96 115.9,62.08 115.9,69.61 107.93,77.58 107.93,89.33 111.21,92.61 111.21,112.51 103.07,120.65 99.65,120.65 98.64,121.65 90.72,121.65 90.14,122.23 87.86,122.23 87.38,121.75 86.73,121.75 86.73,121.75 86.34,121.75 v1(85.9,122.19)
  BOTTOM w0.114: D21.1 84.77,123.93 85.15,123.55 85.66,123.55 85.9,123.31 v1(85.9,122.19) ; v1(219.69,31.05) v1(217.75,29.11) 217.72,29.09 217.72,29.09 217.22,28.59 212.89,28.59 204.14,19.83 204.14,11.6 202.47,9.93 v1(202.41,9.93)
I2C_SCL1: length 14
  BOTTOM w0.102: R547.1 v1(94.4,114.01) 93.92,113.53 93.92,112.43 93.48,111.99 89.99,111.99 89.65,111.65 89.65,111.27 89.48,111.1 89.22,111.1 88.92,111.4 U18.BB7
  BOTTOM w0.114: R547.1 95.56,114.71 95.65,114.62 97.55,114.62 97.86,114.92 97.86,115.63 97.59,115.89 R556.1
I2C_SCL_TP: length 171.7
  TOP w0.114: v1(161.44,35.39) 161.44,34.64 157.79,30.98 152.14,30.98 149.23,28.07 138.71,28.07 137.63,29.15 128.24,29.15 127.63,29.76 119.05,29.76 117.41,28.12 117.41,28.02 v1(116.74,27.35) ; Q9.4 169.72,38.01 169.63,37.93 169.24,37.93 169.08,38.09 R159.2 169.15,37.41 v1(169.15,37.33)
  IN1 w0.089: v1(161.44,35.39) 162.33,36.27 168.09,36.27 v1(169.15,37.33)
  BOTTOM w0.102: 91.36,109.5 91.3,109.5 91.08,109.29 89.12,109.29 89.03,109.38 88.89,109.38 88.51,109 U18.BB10 ; R1009.1 95.56,110.7 95.72,110.55 96.61,110.55 97.13,111.07 R554.1
  BOTTOM w0.114: 91.36,109.5 93.21,109.5 94.77,111.07 R1009.1 ; v1(116.74,27.35) 116.72,27.35 v1(115.05,29.02) 115.05,30.38 114,31.44 114,43.02 111.71,45.31 111.71,46.71 114.22,49.23 114.22,53.43 113.91,53.74 113.91,55.75 111.07,58.58 111.07,73.56 107.87,76.77 107.87,90.31 110.49,92.93 110.49,100.15 106.18,104.46 106.18,107.88 103.4,110.66 97.69,110.66 97.59,110.76 R554.1
I2C_SDA1: length 11
  BOTTOM w0.114: U18.BC7 89.35,111.65 90.08,112.37 91.07,112.37 94.22,115.52 v1(94.58,115.52) 94.9,115.52 R548.1 95.56,116.49 95.84,116.77 96.22,116.77 96.65,117.2 R557.1
I2C_SDA_TP: length 176.1
  TOP w0.114: v1(171.97,37.32) R163.2 171.27,37.61 171.44,37.78 171.44,39.55 171.02,39.97 Q9.1 ; v1(160.8,35.41) 160.8,34.58 157.61,31.4 151.96,31.4 149.06,28.49 138.88,28.49 137.8,29.57 128.42,29.57 127.81,30.18 118.88,30.18 v1(116.69,28)
  IN1 w0.089: v1(160.8,35.41) 162.13,36.74 167.94,36.74 168.97,37.77 171.52,37.77 v1(171.97,37.32)
  BOTTOM w0.102: 96.06,112.52 95.87,112.52 95.56,112.21 R1008.1 ; U18.BB9 88.71,109.64 89.06,109.64 89.2,109.5 90.91,109.5 91.38,109.96 93.16,109.96
  BOTTOM w0.114: 96.06,112.52 97.17,112.52 97.59,112.1 R555.1 98.03,112.52 102.14,112.52 106.6,108.06 106.6,104.63 110.91,100.32 110.91,92.75 108.29,90.13 108.29,76.94 111.49,73.74 111.49,58.76 114.32,55.93 114.32,53.92 114.64,53.6 114.64,49.05 112.13,46.54 112.13,45.49 114.42,43.2 114.42,31.61 115.47,30.56 115.47,29.22 v1(116.22,28.48) v1(116.69,28) ; 93.16,109.96 95.28,112.09 R1008.1
IINP: length 191
  TOP w0.114: U34.72 v1(235.22,14.61)
  IN4 w0.089: v1(235.22,14.61) 233.72,13.11 226.47,13.11 222.92,9.57 222.92,8.29 220.28,5.64 189.08,5.64 184.58,10.14 179.78,10.14 172.77,17.15 156.29,17.15 155.8,16.66 146.65,16.66 145.11,15.11 141.64,15.11 140.69,16.06 124.6,16.06 123.59,15.05 118.89,15.05 117.45,13.61 115.47,13.61 115.47,13.6 115.1,13.6 115.09,13.61 114.73,13.61 114.72,13.61 114.36,13.61 114.35,13.61 109.42,13.61 107.36,15.67 97.29,15.67 96.81,16.15 79.57,16.15 77.89,14.47 73.92,14.47 73.37,15.02 68.52,15.02 67.02,13.52 v1(67.02,10.27)
  BOTTOM w0.114: v1(67.02,10.27) PC238.1 66.39,9.7 66.91,9.18 v1(67.2,9.18) 68.54,9.18 68.74,9.39 PU15.7
ILIM_HI: length 2.2
  TOP w0.114: R133.2 263.8,44.58 v1(264.08,44.58) U7.16
ILIM_LO: length 2
  TOP w0.114: R128.2 263.87,45.06 263.89,45.08 U7.15
IMON: length 2.7
  TOP w0.254: v1(115.62,141.34) 115.75,141.35 116.04,141.64 PC9123.2 116.04,142.75 116.02,142.78 PR283.2
  BOTTOM w0.203: v1(115.62,141.34) 115.62,141.56 PU16.10
IMON_CI_GPU: length 3.8
  TOP w0.254: PR426.2 PC9265.2 141.17,46.41 v1(141.34,46.23) 142.08,46.23 v1(142.27,46.43)
  BOTTOM w0.203: v1(142.27,46.43) 142.18,46.52 PU24.2
IMON_GFX: length 4.1
  TOP w0.254: PC9156.2 36.47,117.38 PR328.2 36.47,117.7 36.23,117.94 v1(36.23,118.19)
  BOTTOM w0.203: PU17.10 37.6,119.1 37.48,118.98 36.82,118.98 36.23,118.39 v1(36.23,118.19)
IMON_GPU: length 3.5
  TOP w0.254: v1(138.54,46.52) 138.83,46.22 v1(139.1,46.22) 139.16,46.28 PR427.2 PC9266.2
  BOTTOM w0.203: PU24.10 138.98,46.96 v1(138.54,46.52)
IMON_NB: length 3.3
  TOP w0.254: PR282.2 116.01,144.73 116.03,144.76 PC9122.2 116.03,145.71 v1(116.27,145.95)
  BOTTOM w0.203: PU16.2 116.08,145.06 116.27,145.24 v1(116.27,145.95)
IMON_NB_GFX: length 3.3
  BOTTOM w0.203: PU17.2 40.8,118.89 41.54,118.14 v1(42.33,118.14) 42.48,117.99 42.48,117.45 PR327.1
IMVP_PWRGD: length 9.6
  TOP w0.114: R1046.1 v1(243.78,19.92) 243.78,19.54 242.41,18.17 238.72,18.17 237.97,17.41 U34.79
INT_HDMI_HPD: length 364.9
  TOP w0.114: U5.3 v1(270.28,63.31)
  IN1 w0.089: v1(34.1,92.64) 33.97,92.64 33.3,91.97 33.3,90.93 30.13,87.75 30.13,83.37 v1(31.02,82.48)
  IN2 w0.127: v1(133.66,31.56) 131.71,33.51 127.27,33.51 123.2,37.58 116.08,37.58 112.26,33.76 102.55,33.76 v1(101.84,34.47)
  IN4 w0.089: v1(31.02,82.48) 31.18,82.32 31.59,82.32 33.86,80.04 33.86,73.65 31.3,71.09 31.3,68.78 31.44,68.64 31.44,36.38 34.77,33.06 36.81,33.06 37.51,33.76 61.47,33.76 64.44,30.78 95.1,30.78 98.79,34.47 v1(101.84,34.47) ; v1(57.56,112.68) 54.76,109.89 52.39,109.89 51.59,110.68 47.87,110.68 47.57,110.97 46.68,110.97 43.87,108.16 42.79,108.16 38.76,104.12 38.76,98.06 36.03,95.33 36.03,94.8 34.1,92.87 v1(34.1,92.64) ; v1(133.66,31.56) 134.07,31.97 138.16,31.97 138.62,31.51 145.67,31.51 146.48,32.32 146.48,34.08 147.15,34.75 148.36,34.75 148.74,34.37 149.62,34.37 149.73,34.48 151.8,34.48 152.76,33.53 162.03,33.53 164.22,35.71 217.36,35.71 218.12,36.47 243.43,36.47 254.55,47.59 254.55,48.01 256.63,50.09 256.92,50.09 257.24,50.41 257.56,50.41 261.38,54.23 261.38,55.99 264.5,59.11 266.01,59.11 270.21,63.31 v1(270.28,63.31)
  BOTTOM w0.114: v1(57.56,112.68) 58.07,112.68 58.5,113.11 59.24,113.11 U18.F5
INT_HDMI_TXCN: length 316.3
  TOP w0.114: v1(269.97,57.83) 270.15,58.02 270.78,58.02 271.12,57.68 271.76,57.68 274.49,60.41 274.49,60.68 C425.1
  IN1 w0.102: v1(269.97,57.83) 269.73,58.07 269.59,58.07 269.35,57.83 267.29,57.83 265.4,55.94 263.49,55.94 261.23,53.67 261.23,50.13 248.18,37.09 204.96,37.09 201.19,33.32 186.82,33.32 184.96,31.46 162.47,31.46 161.84,32.08 151.31,32.08 148.9,29.67 129.72,29.67 127.77,31.62 123.16,31.62 120.97,33.81 120.97,36.33 116.83,40.47 116.83,46.08 118.16,47.41 118.16,66.43 119.37,67.65 119.37,70.45 123.2,74.28 123.2,76.97 121.48,78.7 121.48,81.39 120.21,82.66 120.21,86.2 112.69,93.72 112.69,97.11 108.89,100.91 108.89,103.95 106.89,105.95 106.89,107.48 104.42,109.95 103.59,109.95 99.74,113.8 98.74,113.8 98.23,114.31 97.14,114.31 95.72,115.73 90.54,115.73 89.28,116.99 86.72,116.99 86.01,116.29 77.32,116.29 76.41,117.2 75.4,117.2 74.48,116.27 62.53,116.27 62.31,116.49 57.48,116.49 55.16,114.17 55.16,114 v1(55.41,113.75)
  BOTTOM w0.102: v1(55.41,113.75) 55.68,113.48 55.68,113.3 55.98,113 U18.B5
INT_HDMI_TXCP: length 316.3
  TOP w0.114: v1(269.97,58.59) 269.97,58.45 270.18,58.23 270.87,58.23 271.21,57.89 271.67,57.89 274.27,60.5 274.27,60.68 C424.1
  IN1 w0.102: v1(269.97,58.59) 269.97,58.38 269.86,58.27 269.51,58.27 269.27,58.03 267.21,58.03 265.31,56.14 263.41,56.14 261.02,53.75 261.02,50.22 248.1,37.29 204.87,37.29 201.1,33.52 186.74,33.52 184.88,31.66 162.55,31.66 161.93,32.29 151.23,32.29 148.81,29.87 129.8,29.87 127.86,31.82 123.25,31.82 121.17,33.89 121.17,36.41 117.03,40.55 117.03,45.99 118.36,47.33 118.36,66.35 119.58,67.56 119.58,70.37 123.41,74.2 123.41,77.05 121.68,78.78 121.68,81.47 120.41,82.74 120.41,86.29 112.89,93.81 112.89,97.19 109.09,100.99 109.09,104.03 107.09,106.03 107.09,107.57 104.51,110.15 103.67,110.15 99.82,114 98.82,114 98.32,114.51 97.23,114.51 95.8,115.93 90.63,115.93 89.36,117.19 86.63,117.19 85.93,116.49 77.41,116.49 76.49,117.4 75.32,117.4 74.39,116.48 62.61,116.48 62.4,116.69 57.39,116.69 54.95,114.25 54.95,113.29 v1(55.06,113.19)
  BOTTOM w0.102: U18.A5 55.24,113 v1(55.06,113.19)
INT_HDMI_TXN0: length 309.6
  TOP w0.114: v1(271.39,59.09) 271.6,59.3 272.01,59.3 272.46,59.75 272.46,60.68 C423.1
  IN1 w0.102: v1(271.39,59.09) 271.62,59.31 271.89,59.31 271.95,59.26 271.95,56.9 270.27,55.22 267.02,55.22 265.72,53.92 265.72,52.98 248.54,35.79 205.31,35.79 201.67,32.15 188.67,32.15 187.83,31.31 187.83,30.74 187.38,30.28 161.86,30.28 161.22,30.91 151.8,30.91 149.38,28.5 129.24,28.5 127.29,30.45 122.65,30.45 119.62,33.47 119.62,36.02 115.66,39.98 115.66,47.82 114.95,48.53 114.95,67.87 115.58,68.51 115.58,76.13 118.62,79.16 118.62,86.1 111.52,93.2 111.52,96.55 107.72,100.35 107.72,103.46 105.72,105.46 105.72,106.92 104.42,108.22 103.66,108.22 99.25,112.63 98.23,112.63 97.72,113.14 96.66,113.14 95.23,114.56 89.32,114.56 88.77,115.11 61.86,115.11 61.65,115.32 58.59,115.32 57.58,114.31 57.58,113.95 57.51,113.88 57.44,113.88 v1(57.34,113.98)
  BOTTOM w0.102: v1(57.34,113.98) 57.24,113.98 57.1,113.84 57.1,113.05 U18.C5
INT_HDMI_TXN1: length 311.3
  TOP w0.114: C421.1 270.56,61.08 270.46,60.98 270.46,60.44 v1(270.7,60.2)
  IN1 w0.102: v2(56.09,114.32) 56.91,114.32 58.39,115.8 61.85,115.8 62.06,115.59 86.29,115.59 87,116.3 89,116.3 90.26,115.04 95.43,115.04 96.86,113.62 97.92,113.62 98.43,113.11 99.45,113.11 103.3,109.26 104.14,109.26 106.2,107.2 106.2,105.66 108.2,103.66 108.2,100.59 112,96.8 112,93.42 119.52,85.9 119.52,83.18 119.27,82.93 119.27,79.64 119.89,79.02 120.18,79.02 122.52,76.68 122.52,74.61 118.16,70.25 118.16,67.94 115.43,65.22 115.43,48.74 116.14,48.03 116.14,40.18 120.23,36.09 120.23,33.55 122.85,30.93 127.49,30.93 129.44,28.98 149.18,28.98 151.6,31.4 161.47,31.4 162.1,30.76 185.3,30.76 187.17,32.63 201.47,32.63 205.19,36.35 248.41,36.35 265.24,53.18 265.24,54.12 266.82,55.71 270.07,55.71 270.8,56.44 270.8,59.01 270.49,59.32 270.49,60 v1(270.7,60.2)
  BOTTOM w0.102: U18.A4 55.95,114.18 v2(56.09,114.32)
INT_HDMI_TXN2: length 318.1
  TOP w0.114: C419.1 268.46,61.08 268.32,60.94 268.32,59.87 268.43,59.76 268.88,59.76 v1(269.06,59.94)
  IN1 w0.102: v1(54.98,115) 54.76,115.22 54.45,115.22 54.22,115.45 54.22,116.69 55.33,117.81 62.79,117.81 63.01,117.59 66.35,117.59 66.56,117.38 70.57,117.38 71.88,118.69 84.32,118.69 84.63,119 88.15,119 88.47,118.69 90.61,118.69 92.68,116.62 97.93,116.62 98.97,117.66 104.38,117.66 105.74,116.29 105.74,109.89 107.78,107.85 107.78,106.31 109.78,104.31 109.78,101.3 113.58,97.5 113.58,94.11 121.1,86.59 121.1,83.37 121.99,82.48 122.88,82.48 124.09,81.26 124.09,73.91 121.24,71.06 121.24,67.82 119.05,65.62 119.05,47.02 117.71,45.69 117.71,40.84 121.88,36.67 121.88,34.28 123.66,32.5 128.14,32.5 130.09,30.55 148.53,30.55 150.95,32.97 173.84,32.97 174.35,32.46 184.67,32.46 186.42,34.21 200.82,34.21 204.59,37.98 247.81,37.98 260.34,50.5 260.34,54.04 263.25,56.95 265.15,56.95 267.92,59.71 268.83,59.71 v1(269.06,59.94)
  BOTTOM w0.102: v1(54.98,115) 54.99,114.99 55.06,114.99 U18.A3
INT_HDMI_TXP0: length 309.5
  TOP w0.114: C422.1 272.24,60.68 272.24,59.84 271.92,59.51 271.52,59.51 271.39,59.64 v1(271.39,59.85)
  IN1 w0.102: v1(271.39,59.85) 271.39,59.72 271.59,59.52 271.98,59.52 272.15,59.35 272.15,56.82 270.35,55.02 267.11,55.02 265.93,53.84 265.93,52.89 248.62,35.59 205.4,35.59 201.76,31.95 188.76,31.95 188.04,31.23 188.04,30.65 187.46,30.08 161.77,30.08 161.14,30.71 151.88,30.71 149.47,28.29 129.15,28.29 127.2,30.24 122.56,30.24 119.42,33.39 119.42,35.94 115.45,39.9 115.45,47.73 114.75,48.44 114.75,67.96 115.38,68.59 115.38,76.21 118.42,79.25 118.42,86.01 111.32,93.11 111.32,96.47 107.52,100.26 107.52,103.38 105.52,105.38 105.52,106.83 104.33,108.02 103.57,108.02 99.17,112.43 98.14,112.43 97.64,112.93 96.57,112.93 95.15,114.36 89.24,114.36 88.69,114.9 61.77,114.9 61.56,115.11 58.67,115.11 57.79,114.23 57.79,113.59 v1(57.57,113.37)
  BOTTOM w0.102: v1(57.57,113.37) 57.94,113 U18.D5
INT_HDMI_TXP1: length 311.3
  TOP w0.114: v1(269.94,60.2) 270.12,60.2 270.24,60.33 270.24,60.96 270.13,61.08 C420.1
  IN1 w0.102: v1(56.52,114.81) 57.11,114.81 58.3,116 61.93,116 62.14,115.79 86.2,115.79 86.92,116.51 89.08,116.51 90.34,115.24 95.52,115.24 96.94,113.82 98.01,113.82 98.51,113.32 99.54,113.32 103.38,109.47 104.22,109.47 106.41,107.28 106.41,105.75 108.41,103.75 108.41,100.68 112.21,96.88 112.21,93.5 119.72,85.98 119.72,83.09 119.47,82.84 119.47,79.72 119.97,79.22 120.27,79.22 122.72,76.77 122.72,74.53 118.36,70.17 118.36,67.86 115.63,65.13 115.63,48.82 116.34,48.12 116.34,40.27 120.43,36.18 120.43,33.63 122.94,31.13 127.57,31.13 129.52,29.18 149.1,29.18 151.51,31.6 161.55,31.6 162.18,30.97 185.21,30.97 187.08,32.84 201.39,32.84 205.1,36.55 248.33,36.55 265.04,53.26 265.04,54.21 266.74,55.91 269.98,55.91 270.6,56.53 270.6,58.92 270.29,59.24 270.29,60.03 270.12,60.2 v1(269.94,60.2)
  BOTTOM w0.102: v1(56.52,114.81) 56.75,114.58 U18.B4
INT_HDMI_TXP2: length 318.1
  TOP w0.114: v1(269.06,59.18) 269.06,59.37 268.89,59.54 268.34,59.54 268.1,59.78 268.1,60.97 267.98,61.08 C418.1
  IN1 w0.102: v1(269.06,59.18) 269.06,59.4 268.95,59.51 268,59.51 265.24,56.74 263.33,56.74 260.54,53.95 260.54,50.42 247.9,37.77 204.67,37.77 200.9,34.01 186.5,34.01 184.75,32.25 174.27,32.25 173.75,32.77 151.03,32.77 148.61,30.35 130.01,30.35 128.06,32.3 123.57,32.3 121.68,34.19 121.68,36.59 117.51,40.75 117.51,45.77 118.84,47.1 118.84,65.71 121.04,67.9 121.04,71.15 123.89,74 123.89,81.18 122.79,82.27 121.9,82.27 120.89,83.28 120.89,86.51 113.37,94.03 113.37,97.41 109.58,101.21 109.58,104.23 107.58,106.23 107.58,107.77 105.54,109.81 105.54,116.21 104.29,117.45 99.05,117.45 98.01,116.41 92.59,116.41 90.52,118.48 88.38,118.48 88.07,118.8 84.72,118.8 84.4,118.48 71.97,118.48 70.66,117.17 66.48,117.17 66.27,117.39 62.92,117.39 62.71,117.6 55.41,117.6 54.42,116.61 54.42,115.53 54.53,115.42 54.83,115.42 54.92,115.51 v1(54.92,115.64)
  BOTTOM w0.102: v1(54.92,115.64) 55.16,115.4 U18.A2
ISEN1: length 10.4
  TOP w0.254: PR303.2 119.42,137.24 119.42,137.83 v1(119.3,137.96) 118.47,138.79 117.46,138.79 v1(116.83,139.43)
  BOTTOM w0.203: PU16.13 114.1,140.53
  BOTTOM w0.254: v1(116.83,139.43) 117.08,139.43 117.29,139.63 117.78,139.63 PC9126.1 117.8,140.01 116.45,140.01 116.16,139.72 114.91,139.72 114.1,140.53
ISEN1_GFX: length 12.9
  TOP w0.254: PR344.2 35.6,114.17 v1(33.92,114.17) 33.92,114.17 33.14,114.94 33.14,117.67 34.72,119.24 35.38,119.24 v1(35.55,119.41)
  BOTTOM w0.203: PU17.13 36.32,120.89
  BOTTOM w0.254: v1(33.92,114.17) 34.45,113.64 PC9163.1 ; 36.32,120.89 35.75,120.32 35.75,119.61 v1(35.55,119.41)
ISEN1_GPU: length 8.7
  TOP w0.254: PR441.2 133.29,46.81 v1(133.66,46.43) v1(134.17,45.92)
  BOTTOM w0.203: 136.88,47.69 136.88,47.91 137.74,48.76 PU24.13
  BOTTOM w0.254: v1(134.17,45.92) 134.56,45.54 PC9273.1 134.8,45.13 135.55,45.88 136.25,45.88 136.88,46.51 136.88,47.69
ISEN2: length 12.1
  TOP w0.254: v1(116.86,140.52) v1(116.12,139.85) 116.12,139.32 117.03,138.41 118.31,138.41 118.72,138 118.72,137.37 118.46,137.11 PR284.2
  BOTTOM w0.203: PU16.12 114.5,140.63
  BOTTOM w0.254: 114.5,140.63 115.03,140.11 115.64,140.11 116.61,141.08 117.18,141.08 117.35,141.24 PC9124.2 117.26,140.52 v1(116.86,140.52)
ISEN2_GFX: length 11.5
  TOP w0.254: v1(35.3,118.74) 34.78,118.74 33.57,117.53 33.57,116.08 33.8,115.85 v1(34.05,115.85) 34.05,115.02 34.4,114.66 36,114.66 PR319.2
  BOTTOM w0.203: PU17.12 36.42,120.49 36.11,120.18 36.11,119.29 35.56,118.74 v1(35.3,118.74)
  BOTTOM w0.254: v1(34.05,115.85) 34.45,115.46 PC9157.2
ISEN2_GPU: length 8.3
  TOP w0.254: v1(135.37,44.53) v1(134.76,45.15) 134.74,45.16 133.21,45.16 PR418.2
  BOTTOM w0.203: 137.26,47.66 137.26,47.82 137.8,48.36 PU24.12
  BOTTOM w0.254: v1(135.37,44.53) 135.97,45.13 PC9268.2 136.04,45.13 137.26,46.36 137.26,47.66
ISUMN: length 3.3
  BOTTOM w0.203: PU16.15 113.3,140.11 v1(114.14,139.27) 114.88,138.53 PR298.1
ISUMN_CI: length 3.5
  BOTTOM w0.203: 144.14,48.15 144.11,48.15 143.9,48.36 PU24.39
  BOTTOM w0.254: PR403.1 145.7,46.6 v1(145.26,47.03) 144.14,48.15
ISUMN_GFX: length 7.2
  BOTTOM w0.203: PU17.15 36.04,121.69
  BOTTOM w0.254: 36.04,121.69 34.73,120.38 v1(34.73,120.2) 34.33,119.8 33.84,119.8 33.63,119.6 33.63,118.42 32.92,117.7 32.8,117.7 32.31,117.21 PR343.1
ISUMN_GPU: length 12.5
  TOP w0.254: v1(132.74,44.02) v1(136.41,44.02) 136.8,44.02 138.03,45.25 138.03,46.78 138.53,47.28 138.53,48.21 v1(137.28,49.46)
  BOTTOM w0.203: v1(137.28,49.46) 137.5,49.46 137.6,49.56 PU24.15
  BOTTOM w0.254: v1(132.74,44.02) 132.98,44.26 PR443.1
ISUMN_NB: length 6.7
  TOP w0.254: v1(114.96,147.25) 116.52,147.25 116.98,147.7 v1(119.01,147.7) 119.41,148.1 PR259.1
  BOTTOM w0.203: v1(114.96,147.25) 114.96,147.09 114.5,146.63 PU16.39
JTAG_TCK: length 3.4
  BOTTOM w0.114: TP273.1 125.91,99.77 128.87,99.77 U22.AE41
JTAG_TDI: length 6.5
  BOTTOM w0.114: TP271.1 124.47,101.38 126.23,101.38 126.86,100.74 129.19,100.74 129.27,100.83 129.52,100.83 129.85,100.5 U22.AD40
JTAG_TDO: length 6.1
  BOTTOM w0.114: TP270.1 123.88,98.93 126.24,98.93 126.55,99.23 129.23,99.23 U22.AF41
JTAG_TESTEN: length 9.2
  BOTTOM w0.114: U22.AE40 129.51,100.19 129.27,100.19 129.2,100.26 128.73,100.26 128.52,100.05 124.91,100.05 TP274.1 123.97,100.11 123.45,100.11 R649.2 R645.1
JTAG_TMS: length 4.4
  BOTTOM w0.114: U22.AD41 125.35,100.5 TP272.1
JTAG_TRSTB: length 10.6
  BOTTOM w0.114: R650.2 TP275.1 122.51,98.62 R647.2 123.97,99.17 126.12,99.17 126.39,99.45 128.99,99.45 129.32,99.78 129.48,99.78 129.86,99.4 U22.AF40
KB_BACKLITE_EN: length 137.1
  TOP w0.203: v1(222.41,13.02) 222,12.61 U34.30
  TOP w0.254: v1(99.5,32.36) Q11.2
  IN1 w0.254: v1(99.5,32.36) 105.75,26.11 107.41,26.11 109.2,24.33 113.51,24.33 114.85,22.99 118.05,22.99 118.51,23.45 119.99,23.45 120.6,24.06 124.64,24.06 125.32,23.38 131.67,23.38 132.46,22.59 136.97,22.59 138.19,23.81 139.39,23.81 139.64,23.56 147.38,23.56 148.05,24.23 152.01,24.23 152.83,25.05 163.57,25.05 164.11,24.51 172.59,24.51 173.6,23.5 184.47,23.5 185.6,22.37 204.15,22.37 210.16,16.36 211.52,16.36 215.05,12.83 222.22,12.83 v1(222.41,13.02)
KB_DET#: length 179.2
  TOP w0.114: v1(105.83,42.91) 97.69,34.77 v1(97.52,34.77) 68.53,34.77 67.72,35.57 61.07,35.57 55.4,41.25 43.74,41.25 36.91,34.42 34.16,34.42 32.92,35.65 32.92,38.42 32.81,38.53 CN2.30 ; R994.2 88.4,107.04 87.97,107.04 87.8,106.86 87.33,106.86 86.56,106.09 85.14,106.09 v2(84.98,106.25)
  IN4 w0.089: 97.2,103.06 97.16,103.1 84.41,103.1 84.34,103.03 83.67,103.03 82.9,103.8 82.9,104.4 83.15,104.65 83.86,104.65 84.98,105.77 v2(84.98,106.25) ; v1(105.83,42.91) 107.28,44.36 107.28,47.46 109.39,49.57 109.39,66.47 108.18,67.67 108.18,82.83 105.09,85.93 105.09,99.52 104.57,100.04 103.89,100.73 100.78,100.73
  IN4 w0.102: 97.2,103.06 99.53,100.73 100.78,100.73
  BOTTOM w0.114: U18.AU12 84.55,106.68 v2(84.98,106.25)
KB_LED_DET: length 107.1
  TOP w0.114: R179.1 R178.1 102.58,34.41 v1(102.5,34.49)
  IN3 w0.127: v1(101.92,105.81) 101.92,104.7 101.02,103.79 95.85,103.79 95.12,104.52 90.6,104.52 90.3,104.83 89.24,104.83 88.9,104.49 85.74,104.49 v2(85.26,104.01)
  BOTTOM w0.114: R526.2 100.76,105.87 101.86,105.87 v1(101.92,105.81) v1(102.45,105.29) 103.01,105.29 108.86,99.43 108.86,93.6 106.25,90.98 106.25,76.05 109.21,73.09 109.21,58.67 107.94,57.41 107.94,52.82 109.71,51.05 109.71,48.26 108.96,47.51 108.96,43.94 106.29,41.27 104.22,41.27 102.5,39.55 v1(102.5,34.49) ; U18.AT14 84.04,105.8 84.99,104.85 84.99,104.41 85.26,104.14 v2(85.26,104.01)
KB_LED_DET_R: length 3
  TOP w0.114: R179.2 v1(104.45,36.02) J1.2
LAD0: length 221.8
  TOP w0.114: v1(106.49,27.77) 105.6,26.88 R242.2 ; R1102.1 v1(209.87,20.55)
  IN1 w0.089: v1(106.49,27.77) 109.74,27.77 110.51,28.54 110.51,32.52 112.31,34.33 112.31,44.25 111.36,45.2 111.36,68.73 111.12,68.97 111.12,84.86 107,88.98 107,91.78 100.94,97.83 100.94,100.32 101.7,101.08 101.7,102.8 101.49,103.01 100.45,103.01 99.55,103.92 98.98,103.92 98.33,104.56 98.33,105.93 98.33,106.26 95.09,109.5 92.7,109.5 v1(92.03,108.83)
  IN4 w0.089: v1(209.87,20.55) 209.39,20.07 206.87,20.07 204.6,22.34 198.03,22.34 196.04,20.34 196.04,19.05 190.93,13.95 180.11,13.95 173.97,20.08 155.11,20.08 154.59,19.57 140.64,19.57 140.05,18.97 132.74,18.97 132.19,19.52 113.46,19.52 109.56,23.42 108.32,23.42 106.49,25.25 v1(106.49,27.77)
  BOTTOM w0.102: v1(92.03,108.83) 91.69,108.49 90.72,108.49 90.55,108.66 89.38,108.66 88.92,108.2 U18.BB11
LAD0_EC: length 9.9
  TOP w0.114: R1102.2 211.65,20.55 212.34,21.25 218.95,21.25 219.59,20.61 U34.10
LAD0_R: length 119.5
  TOP w0.114: R242.1 v1(105.6,24.49)
  IN4 w0.089: v1(5.39,14.74) 4.98,15.15 4.98,16.91 7.13,19.06 13.75,19.06 14.49,19.8 21.05,19.8 22.13,20.88 22.13,22.52 27.72,28.11 32.01,28.11 37.53,22.59 46.46,22.59 47.49,23.61 49.62,23.61 50.52,24.51 51.94,24.51 53.17,23.28 60.15,23.28 62.46,25.58 80.14,25.58 80.14,25.58 82.2,25.58 82.2,25.58 104.51,25.58 v1(105.6,24.49)
  BOTTOM w0.114: v1(5.39,14.74) 4.12,16.01 4.12,17.39 3.08,18.43 CN10.64
LAD1: length 219.4
  TOP w0.114: R236.2 106.62,26.91 v1(107.03,27.32) ; R1103.1 v1(207.58,20.55)
  IN1 w0.089: v1(91.39,108.92) 91.5,108.92 92.31,109.73 95.42,109.73 98.72,106.42 98.72,106.09 98.72,105.77 98.72,104.73 99.14,104.31 99.71,104.31 100.62,103.41 101.65,103.41 102.1,102.96 102.1,100.92 101.33,100.16 101.33,98 107.4,91.93 107.4,89.13 111.52,85.02 111.52,69.13 111.76,68.89 111.76,45.36 112.7,44.41 112.7,34.16 110.9,32.36 110.9,28.37 109.85,27.32 v1(107.03,27.32)
  IN4 w0.089: v1(107.03,27.32) 107.03,25.27 108.49,23.81 109.81,23.81 113.71,19.91 132.36,19.91 132.9,19.37 139.89,19.37 140.48,19.96 154.43,19.96 154.96,20.49 159.27,20.49 159.84,21.06 165.65,21.06 166.23,20.48 174.13,20.48 180.27,14.34 190.77,14.34 195.64,19.22 195.64,20.51 197.87,22.73 205.4,22.73 v1(207.58,20.55)
  BOTTOM w0.102: U18.BA11 88.05,108.5 88.94,108.5 89.47,109.04 91.27,109.04 v1(91.39,108.92)
LAD1_EC: length 12.3
  TOP w0.114: U34.9 219.69,21.01 219.22,21.49 212.2,21.49 211.77,21.06 209.5,21.06 R1103.2
LAD1_R: length 114.8
  TOP w0.114: R236.1 v1(106.62,22.44)
  IN4 w0.089: v1(106.62,22.44) 105.64,23.42 62.52,23.42 60.32,21.21 55.61,21.21 54.87,20.48 39.91,20.48 39.33,19.9 38.2,18.77 33.18,18.77 31.04,20.9 28.59,20.9 28.35,21.15 24.66,21.15 21.73,18.22 16.82,18.22 16.08,17.49 11.55,17.49 11.06,17 8.93,17 7.32,15.39 v1(5.43,15.39)
  BOTTOM w0.114: CN10.66 3.17,18.93 4.54,17.56 4.54,16.28 v1(5.43,15.39)
LAD2: length 221.3
  TOP w0.114: R233.2 103.57,26.88 105.4,28.7 v1(106.71,28.7) ; R1104.1 v1(209.87,21.57)
  IN1 w0.089: v1(91.99,107.85) 92.25,108.1 95.37,108.1 97.54,105.93 97.54,104.04 99.35,102.23 99.35,101.54 100.15,100.73 100.15,97.48 106.19,91.45 106.19,88.68 110.33,84.53 110.33,68.64 110.57,68.4 110.57,44.87 111.52,43.92 111.52,34.65 109.72,32.85 109.72,29.02 108.93,28.22 107.19,28.22 v1(106.71,28.7)
  IN4 w0.089: v1(106.71,28.7) 106.71,28.7 107.48,27.94 107.48,25.43 108.71,24.2 109.97,24.2 113.87,20.31 132.52,20.31 133.07,19.76 139.72,19.76 140.32,20.35 154.27,20.35 154.8,20.88 159.11,20.88 159.68,21.46 165.81,21.46 166.39,20.87 174.3,20.87 180.43,14.73 190.6,14.73 195.25,19.38 195.25,20.67 197.7,23.13 205.73,23.13 207.29,21.57 v1(209.87,21.57)
  BOTTOM w0.102: 91.86,107.97 90.59,107.97 90.39,108.18 89.78,108.18 89.5,107.9 89.23,107.9 89.17,107.96 88.79,107.96 88.73,107.9 87.25,107.9 U18.AY11
  BOTTOM w0.114: 91.86,107.97 v1(91.99,107.85)
LAD2_EC: length 9.5
  TOP w0.114: U34.8 219.71,21.41 219.39,21.73 211.56,21.73 R1104.2
LAD2_R: length 112.8
  TOP w0.114: R233.1 v1(103.57,24.49)
  IN4 w0.089: v1(103.57,24.49) 103.44,24.36 62.35,24.36 59.99,22 53.06,22 51.35,23.72 50.84,23.72 49.95,22.82 47.81,22.82 46.26,21.26 39.58,21.26 39.28,20.96 37.99,20.96 37.15,21.8 31.26,21.8 28.56,24.5 25.23,24.5 22.92,22.19 22.92,20.55 21.39,19.01 16.49,19.01 15.75,18.27 11.22,18.27 10.74,17.79 7.17,17.79 v1(5.42,16.03)
  BOTTOM w0.114: v1(5.42,16.03) 4.96,16.5 4.96,17.73 3.26,19.43 CN10.68
LAD3: length 213.7
  TOP w0.114: R232.2 104.59,26.6 106.25,28.27 106.98,28.27 v1(107.37,28.66) ; R1105.1 v1(208.21,22.28)
  IN1 w0.089: v1(107.37,28.66) 107.85,29.14 108.7,29.14 108.94,29.37 108.94,36.71 109.78,37.55 109.78,68.08 109.55,68.32 109.55,84.2 105.37,88.37 105.37,91.14 99.35,97.16 99.35,100.42 98.56,101.21 98.56,101.91 96.62,103.85 96.34,103.85 95.8,104.39 95.8,107.02 95.11,107.71 92.79,107.71 92.14,107.07 v1(91.03,107.07)
  IN4 w0.089: v1(208.21,22.28) 206.97,23.52 197.54,23.52 194.86,20.83 194.86,19.54 190.44,15.13 180.6,15.13 174.46,21.26 166.56,21.26 165.97,21.85 159.52,21.85 158.94,21.28 154.63,21.28 154.1,20.75 140.15,20.75 139.56,20.15 133.23,20.15 132.68,20.7 115.4,20.7 113.73,22.37 113.02,22.37 112.37,22.37 110.14,24.6 109.07,24.6 107.87,25.8 107.87,28.16 v1(107.37,28.66)
  BOTTOM w0.102: 91.03,107.06 90.87,106.9 90.47,106.9 90.46,106.9 90.29,106.9 90.28,106.9 89.19,106.9 89.18,106.89 88.72,106.89 88.71,106.91 88.43,106.91 88.12,106.6 U18.BA13
  BOTTOM w0.114: 91.03,107.06 v1(91.03,107.07)
LAD3_EC: length 12
  TOP w0.114: U34.7 219.86,21.81 219.7,21.97 211.9,21.97 211.79,22.08 209.5,22.08 R1105.2
LAD3_R: length 116.2
  TOP w0.114: v1(104.59,24.49) R232.1
  IN4 w0.089: v1(5.44,16.68) 5.44,16.82 6.81,18.18 10.57,18.18 11.06,18.67 15.58,18.67 16.18,19.27 16.19,19.27 16.32,19.41 21.22,19.41 22.53,20.71 22.53,22.36 27.89,27.72 31.78,27.72 38.15,21.35 39.11,21.35 39.42,21.66 46.09,21.66 47.65,23.21 49.78,23.21 50.68,24.11 51.51,24.11 53.23,22.4 59.83,22.4 62.38,24.95 104.13,24.95 v1(104.59,24.49)
  BOTTOM w0.114: v1(5.44,16.68) 5.44,17.84 3.36,19.93 CN10.70
LAN_ISOLAT#: length 3.9
  TOP w0.114: U2.20 270.88,85.73 270.85,85.7 270.85,84.77 v1(270.57,84.49) 270.45,84.37 R73.1 R1003.1
LAN_LED0: length 6
  TOP w0.114: TP15.1 277.88,84.89 276.74,86.03 275.86,86.03 275.68,86.21 275.28,86.21 273.69,87.8 U2.27
LAN_LED1: length 3.8
  TOP w0.114: U2.26 273.75,87.4 275.18,85.97 275.51,85.97 TP78.1
LAN_LED2: length 1.7
  TOP w0.114: U2.25 273.7,87 274.33,86.37 TP79.1
LAN_MCTG:
  vias: v1(276.82,107.65) v1(278.19,110.88) v1(278.22,110.14)
LAN_MCTG0: length 2.5
  TOP w0.508: R43.1 274.48,105.37 v1(274.46,105.39)
  BOTTOM w0.508: U12.15 v1(274.46,105.39)
LAN_MCTG1: length 2.5
  TOP w0.508: v1(274.46,104.12) 274.48,104.1 R45.1
  BOTTOM w0.508: U12.16 v1(274.46,104.12)
LAN_MCTG2: length 2.4
  TOP w0.508: R53.1 274.61,97.75 v1(274.42,97.94)
  BOTTOM w0.508: v1(274.42,97.94) 274.59,97.77 U12.21
LAN_MCTG3: length 2.2
  TOP w0.508: R54.1 274.64,96.48 274.61,96.5 v1(274.46,96.5)
  BOTTOM w0.508: v1(274.46,96.5) U12.22
LAN_MX0+: length 9.7
  IN1 w0.081: CN6.1 278.54,103.1 278.3,103.1 274.99,106.41 274.08,106.41 273.82,106.66 273.82,107.07 273.98,107.22 274.28,107.22 274.43,107.06 v1(274.43,106.98)
  BOTTOM w0.102: v1(274.43,106.98) 274.43,107.11 274.52,107.2 274.92,107.2 275.46,106.66 U12.14
LAN_MX0-: length 9.7
  IN1 w0.081: v1(274.43,107.62) 274.3,107.49 273.86,107.49 273.55,107.18 273.55,106.55 273.96,106.14 274.88,106.14 277.8,103.21 CN6.2
  BOTTOM w0.102: v1(274.43,107.62) 274.55,107.51 275.04,107.51 275.46,107.93 U12.13
LAN_MX1+: length 9.7
  IN1 w0.081: CN6.3 277.35,101.42 276.7,100.78 276.7,100.41 276.61,100.31 275.68,100.31 275.59,100.4 275.59,100.57 275.79,100.76 275.79,101.17 275.46,101.49 275.06,101.49 274.77,101.21 274.4,101.21 274.05,101.56 274.05,101.96 274.2,102.11 274.46,102.11 274.56,102.01 v1(274.56,101.9)
  BOTTOM w0.102: U12.18 275.29,102.1 274.76,102.1 v1(274.56,101.9)
LAN_MX1-: length 9.7
  IN1 w0.081: v1(274.56,102.54) 274.4,102.39 274.09,102.39 273.78,102.07 273.78,101.44 274.29,100.94 274.88,100.94 275.17,101.22 275.35,101.22 275.51,101.06 275.51,100.88 275.32,100.68 275.32,100.29 275.56,100.04 276.71,100.04 277.8,98.95 CN6.6
  BOTTOM w0.102: U12.17 275.37,102.41 274.7,102.41 v1(274.56,102.54)
LAN_MX2+: length 9.7
  IN3 w0.102: v1(274.58,99.36) 274.58,99.53 274.51,99.6 274.27,99.6 274.1,99.43 274.1,99.14 274.43,98.81 275.28,98.81 275.45,98.99 275.45,99.87 275.74,100.16 276.23,100.16 276.52,99.87 276.52,99.7 276.65,99.56 277.95,99.56 278.27,99.89 278.27,100.26 278.13,100.41 CN6.4
  BOTTOM w0.102: v1(274.58,99.36) 274.58,99.48 274.71,99.61 275.64,99.61 275.81,99.43 U12.20
LAN_MX2-: length 9.7
  IN3 w0.102: v1(274.59,100.04) 274.43,99.88 274.16,99.88 273.82,99.54 273.82,99.03 274.32,98.53 275.39,98.53 275.73,98.87 275.73,99.76 275.86,99.89 276.11,99.89 276.24,99.76 276.24,99.58 276.54,99.28 278.06,99.28 278.17,99.39 CN6.5
  BOTTOM w0.102: v1(274.59,100.04) 274.71,99.92 275.42,99.92 U12.19
LAN_MX3+: length 9.7
  IN3 w0.102: v1(274.61,94.26) 274.45,94.42 274.13,94.42 273.8,94.75 273.8,95.35 274.47,96.02 275.63,96.02 275.96,96.35 275.96,97.13 276.56,97.73 277.07,97.73 277.25,97.55 278,97.55 278.19,97.36 CN6.7
  BOTTOM w0.102: U12.24 275.4,94.37 274.72,94.37 v1(274.61,94.26)
LAN_MX3-: length 9.7
  IN3 w0.102: CN6.8 278.17,96.34 278.28,96.45 278.28,96.87 277.88,97.27 277.14,97.27 276.96,97.45 276.67,97.45 276.24,97.01 276.24,96.23 275.75,95.74 274.59,95.74 274.08,95.23 274.08,94.87 274.24,94.7 274.51,94.7 274.61,94.8 v1(274.61,94.91)
  BOTTOM w0.102: U12.23 275.81,94.81 275.68,94.68 274.74,94.68 274.61,94.81 v1(274.61,94.91)
LAN_PWR_EN_EC: length 127.8
  TOP w0.114: v1(225.97,11.36) 224.35,12.98 224.35,15.45 223.6,16.2 221.92,16.2 221.51,16.61 U34.20
  IN4 w0.089: v1(278.41,83.3) 277.11,83.3 275.81,82 275.81,74.66 273.41,72.25 273.41,62.8 271.95,61.35 269.54,61.35 266.94,58.75 266.94,53.93 269.51,51.36 269.51,41.82 267.52,39.83 258.84,39.83 253.66,34.65 253.66,24.14 249.42,19.89 249.42,15.2 246.89,12.68 234.48,12.68 234.04,12.24 226.85,12.24 v1(225.97,11.36)
  BOTTOM w0.114: U207.4 276.16,82.35 277.11,83.3 C648.1 v1(278.41,83.3)
LAN_XTALI: length 6
  TOP w0.114: U2.28 273.82,88.2 274.03,87.99 275,87.99 C347.1 275.75,87.94 277.38,87.94 Y1.3
LAN_XTALO: length 4
  TOP w0.114: U2.29 273.86,88.6 274.18,88.27 275.03,88.27 C345.1 275.69,88.64 276.17,89.11 Y1.1
LATCH: length 17.8
  BOTTOM w0.114: D15.2 228.27,20.62 228,20.35 228,18.6 228.49,18.12 v1(229.5,18.12) 229.9,18.12 C716.1 230.88,17.14 Q31.6 232.46,17.14 232.6,17 232.6,16.6 232.49,16.49 Q31.5 230.45,16.49 R443.1 229.99,16.95 Q30.3 227.99,16.95 227.56,16.52 227.56,13.36 227.31,13.1 D16.2
LCD_BAK: length 91.4
  TOP w0.114: v1(191.23,36.97) 191.23,28.82 190.96,28.54 190.96,20.81 199.45,12.32 201.29,12.32 201.46,12.15 205.73,12.15 208.65,9.23 219.06,9.23 221.15,11.31 222.97,11.31 223.17,11.12 U34.35 ; v1(175.13,40.38) 175.13,40.73 170.29,45.57 170.29,46.83 170.93,47.48 173.93,47.48 174.57,48.12 176.04,48.12 D4.2 178.33,48.76 R899.2
  BOTTOM w0.114: v1(191.23,36.97) v1(190.18,38.02) 188.69,39.52 175.99,39.52 v1(175.13,40.38)
LCD_BAK_R: length 7
  TOP w0.114: v1(181.8,51.17) v1(180.89,50.26) 180.37,49.73 R899.1 179.51,49.16 R117.1 D4.3
  BOTTOM w0.114: v1(181.8,51.17) 182.6,50.37 CN9.31
LCD_PWM_EC: length 77.9
  TOP w0.114: v1(177.03,40.4) 175.18,42.25 175.18,45.25 176.16,46.22 D5.2 ; v1(191.35,39.45) 191.7,39.1 191.7,28.93 191.2,28.43 191.2,20.91 198.8,13.31 205.27,13.31 208.86,9.72 218.5,9.72 219.22,10.44 219.22,12.62 219.62,13.01 U34.29
  BOTTOM w0.114: v1(177.03,40.4) 177.43,40 189.64,40 190.18,39.45 v1(190.44,39.45) v1(191.35,39.45)
LCD_PWM_IN: length 7.1
  TOP w0.114: v1(181.02,48.78) 180.77,48.53 180.77,47.78 180.16,47.17 179.67,47.17 v1(179.64,47.15) 179.44,46.94 R110.1 178.48,46.32 178.28,46.12 D5.3
  BOTTOM w0.114: v1(181.02,48.78) 181.64,48.78 182.1,49.24 CN9.30
LCD_TST: length 95.4
  TOP w0.114: U34.85 235.57,19.81 235.33,19.57 233.92,19.57 233.13,20.35 230.47,20.35 229.44,21.38 224.18,21.38 221.74,23.82 221.74,24.81 220.06,26.49 214.22,26.49 211.52,23.79 210.91,23.79 210.29,24.41 210.29,30.85 208.85,32.29 197.85,32.29 v1(193.21,36.92) ; v1(189.75,36.99) 189.52,37.22 189.52,50.12 185.97,53.67 176.17,53.67 175.04,52.54 D3.2 174.49,51.25 174.14,51.59 v1(173.6,51.59)
  BOTTOM w0.114: v1(193.21,36.92) 192.44,36.15 190.59,36.15 v1(190.31,36.43) v1(189.75,36.99) ; v1(173.6,51.59) CN9.13
LDRQ#0: length 6.3
  BOTTOM w0.102: 91.12,119.99 91.12,119.87 U18.BA1
  BOTTOM w0.114: TP146.1 91.12,119.99
LED_BL_ON: length 12.6
  TOP w0.114: R122.1 175.73,47.25 176.01,46.97 177.25,46.97 177.52,46.7 177.52,43.5 v1(178.27,42.75) 178.5,42.52 R135.2 179.25,42.97 179.04,43.18 C485.2 179.04,44.35 179.3,44.61 180.63,44.61 180.79,44.76 Q7.2
LED_PWM#: length 4.3
  TOP w0.254: Q11.3 101.87,35.44 102.45,36.02 v1(102.45,36.56) J1.4
LFRAME#: length 217.6
  TOP w0.114: v1(209.87,22.59) R1106.1 ; v1(108.03,28.7) 108.03,26.29 R231.1
  IN1 w0.089: v1(96.91,105.95) 96.19,105.23 96.19,104.55 96.5,104.24 96.79,104.24 98.96,102.07 98.96,101.37 99.76,100.57 99.76,97.31 105.78,91.29 105.78,88.52 109.94,84.36 109.94,68.48 110.18,68.25 110.18,37.39 109.33,36.54 109.33,29.18 108.84,28.7 v1(108.03,28.7)
  IN4 w0.089: v1(108.03,28.7) 108.8,27.92 108.8,26.49 112.53,22.76 112.85,22.76 113.89,22.76 115.56,21.09 132.85,21.09 133.39,20.55 139.4,20.55 139.99,21.14 153.94,21.14 155.07,22.28 166.1,22.28 166.72,21.66 174.62,21.66 180.76,15.52 190.28,15.52 194.46,19.71 194.46,21 197.38,23.91 208.54,23.91 v1(209.87,22.59)
  BOTTOM w0.102: U18.AV14 85.65,105.8 86.03,105.42 86.03,105.28 86.52,104.78 86.58,104.78 86.68,104.68 87.06,104.68 87.45,105.07 87.45,105.13 87.62,105.3 87.88,105.3 87.97,105.21 88.28,105.21 88.37,105.3 88.7,105.3 88.71,105.29 89.19,105.29 89.29,105.39 93.38,105.39 ; v1(96.91,105.95) 97.18,105.95 97.21,105.97 R594.2
  BOTTOM w0.114: 93.38,105.39 v1(93.66,105.67) 93.83,105.84 95.93,105.84 R604.1 96.7,106.62 96.95,106.62 R594.2
LFRAME#_EC: length 9.5
  TOP w0.114: R1106.2 212.03,22.59 212.41,22.21 U34.6
LGATE_1: length 31.9
  IN2 w1.143: 83.48,137.98 88.86,137.98 89.68,138.79 89.68,141.94 91.61,143.87 104.94,143.87 106.01,142.8 v3(108.79,142.8)
  BOTTOM w0.203: PU16.24 109.94,143.06
  BOTTOM w0.381: 109.94,143.06 109.05,143.06 v3(108.79,142.8)
  vias: v3(82.04,138.84) v3(82.04,138)
LGATE_2: length 50.8
  IN2 w1.143: 73.11,140.11 73.11,141.63 72.62,142.13 72.62,146.78 75.67,149.83 107.45,149.83 109.74,147.54 109.74,144.83 v3(109.36,144.45)
  BOTTOM w0.203: v3(109.36,144.45) 109.56,144.26 PU16.27
  vias: v3(73.18,138.84) v3(73.18,138)
LGATE_CI: length 17.4
  IN4 w0.889: v1(152.9,61.5) v1(152.9,60.66) 152.9,57.99 150.89,55.99 148.25,55.99 145.53,53.27 145.53,51.26 144.74,50.47 v3(144.29,50.47)
  BOTTOM w0.203: PU24.34 144.18,50.36 v3(144.29,50.47)
LGATE_GFX1: length 24.2
  IN2 w1.143: 54.94,133.15 54.94,128.45 52.9,126.41 48.87,126.41 46.96,124.5 42.08,124.5 41.81,124.77 39.34,124.77 v3(38.63,125.48)
  BOTTOM w0.203: v3(38.63,125.48) 38.63,125.47 38.8,125.31 PU17.24
  vias: v1(55.46,137.85) v3(54.68,134.59) v3(55.36,134.98)
LGATE_GFX2: length 33.8
  IN3 w1.143: v3(40.47,125.79) 40.83,125.79 42.03,124.58 46.94,124.58 48.76,126.41 52.9,126.41 54.94,128.45 54.94,131.45 61.39,137.9 64.35,137.9 64.77,138.32
  BOTTOM w0.203: v3(40.47,125.79) 40,125.31 PU17.27
  vias: v3(65.7,138.84) v3(65.7,138)
LGATE_GPU1: length 20
  IN2 w1.143: 139.03,55.02 137.48,56.57 137.48,63.5 136.53,64.45 v3(136.53,65.38) v3(135.51,65.38) v3(130.79,65.38) v3(129.77,65.38)
  BOTTOM w0.203: v3(140.18,53.33) PU24.24
  BOTTOM w0.381: v3(139.65,53.86) v3(140.18,53.33)
  vias: v1(136.03,65.87)
LGATE_GPU2: length 26.6
  IN2 w1.143: 144.04,54.98 145.07,56.01 150.96,56.01 152.66,57.71 152.66,58.93 151.7,59.89 v3(151.7,65.38) v3(150.69,65.38) v3(146.16,65.38) v3(145.15,65.38)
  BOTTOM w0.203: PU24.27 141.38,53.38 v3(141.6,53.6)
  BOTTOM w0.381: v3(142.06,54.23) 141.6,53.78 v3(141.6,53.6)
LGATE_NB: length 22.3
  TOP w1.016: 98.44,141.66 v1(98.44,144.94) 98.44,146.11 101.97,149.64 108.86,149.64 110.01,148.48 v3(111.67,148.48)
  BOTTOM w0.203: PU16.34 112.5,146.74 112.32,146.93 112.32,147.64 111.67,148.29 v3(111.67,148.48)
  vias: v3(98.79,139.73) v3(98.77,138.89)
LID_SW#: length 60.1
  TOP w0.114: J3.5 204.9,31.44 205.04,31.58 207.74,31.58 EC165.2 209.35,30.6 209.61,30.33 v1(209.61,29.3) ; v1(238.41,19.68) 238.41,20.22 R966.1 237.78,20.43 237.2,21.01 U34.88
  IN4 w0.089: v1(209.61,29.3) 213.14,29.3 215.87,26.57 227.5,26.57 228.72,27.79 228.72,29.95 230.4,31.64 239.5,31.64 242.98,28.16 242.98,24.01 238.65,19.68 v1(238.41,19.68)
LLB#: length 11.5
  BOTTOM w0.102: U18.AE2 74.67,115.67 74.67,115.99 74.55,116.12 74.55,116.42 74.76,116.64 74.76,117.42 75.18,117.84 75.18,118.97
  BOTTOM w0.114: 75.18,118.97 75.18,119.38 75.75,119.94 75.75,121.79 75.69,121.85 75.69,122.39 76.34,123.04 76.34,124.52 v1(76.62,124.8) 76.93,125.11 R552.1
LPC_CLK0: length 15.8
  BOTTOM w0.102: U18.AW14 86.48,106.13 86.9,106.13 87.17,106.4 87.53,106.4 87.64,106.28 88.87,106.28 89.05,106.09 92.05,106.09
  BOTTOM w0.114: 92.05,106.09 93.7,107.75 95.86,107.75 R602.1 R592.2 98,107.68 99.24,107.68 v1(99.53,107.4) 99.66,107.27 R589.2
LPC_CLK1: length 15.7
  BOTTOM w0.102: U18.AY13 87.25,106.9 88.08,106.9 88.29,107.11 88.79,107.11 88.8,107.1 89.1,107.1 89.11,107.11 90.37,107.11 90.37,107.11
  BOTTOM w0.114: 90.37,107.11 90.38,107.11 90.75,107.48 91.21,107.48 91.61,107.08 92.11,107.08 94.23,109.2 95.81,109.2 R603.1 R593.2 98.06,109.13 99.18,109.13 99.54,109.5 v1(99.78,109.5) 99.88,109.4 R590.2
LPC_LFRAME#_R: length 114.8
  TOP w0.114: v1(107.63,22.44) R231.2
  IN4 w0.089: v1(7.53,16.36) 8.56,17.39 10.9,17.39 11.39,17.88 15.91,17.88 16.65,18.62 21.55,18.62 25.19,22.25 30.25,22.25 33.34,19.16 38.04,19.16 39.29,20.42 39.75,20.87 54.71,20.87 55.44,21.61 60.15,21.61 62.42,23.87 106.2,23.87 v1(107.63,22.44)
  BOTTOM w0.114: v1(7.53,16.36) 6.9,17.1 6.9,19.46 8.12,20.68 CN10.73
LPC_PD#: length 1.8
  TOP w0.114: R591.1 75.02,110.96 v2(75.4,110.58)
  BOTTOM w0.102: v2(75.4,110.58) 74.85,110.03 U18.AE9
LPC_RST#: length 215.1
  TOP w0.114: U34.22 v1(218.81,15.81)
  IN1 w0.089: v1(218.81,15.81) 218.34,16.28 213.35,16.28 212.76,16.87 210.25,16.87 204.44,22.68 185.72,22.68 184.6,23.81 173.73,23.81 172.72,24.82 164.24,24.82 163.7,25.36 152.7,25.36 151.88,24.54 147.92,24.54 147.25,23.87 139.77,23.87 139.51,24.12 138.06,24.12 137.67,23.73 125.41,23.73 124.77,24.37 123.65,24.37 122.77,25.25 118.37,25.25 117.56,24.45 115.32,24.45 114.92,24.85 114.41,24.85 v1(114.2,25.07)
  BOTTOM w0.114: v1(114.2,25.07) 113.09,26.18 v1(113.09,26.45) 113.09,29.06 113.58,29.55 113.58,42.85 111.29,45.14 111.29,46.88 113.8,49.4 113.8,53.25 113.49,53.57 113.49,55.58 110.65,58.41 110.65,73.39 107.45,76.59 107.45,90.48 110.07,93.1 110.07,99.97 105.76,104.28 105.76,107.71 103.23,110.24 97.88,110.24 97.59,109.96 C757.2 R521.2 ; R1072.1 218.81,15.94 v1(218.81,15.81)
LPC_RST#_R: length 8.9
  BOTTOM w0.102: 91.34,107.72 90.56,107.72 90.3,107.97 89.86,107.97 89.58,107.69 89.12,107.69 89.06,107.75 88.88,107.75 88.81,107.69 88.44,107.69 U18.BB12
  BOTTOM w0.114: R521.1 v1(94.65,109.68) 94.41,109.68 92.1,107.37 91.68,107.37 91.34,107.72
M_A0_CS#0: length 53.4
  IN4 w0.127: v2(77.93,95.61) 78.51,95.61 78.67,95.46 78.67,92.81 78.76,92.72 79.01,92.72 79.27,92.46 79.27,91.12 79.42,90.97 79.42,86.08 79.57,85.93 79.57,84.31 79.78,84.09 79.78,65.18 79.5,64.9 79.5,62.15 79.19,61.83 79.19,60.57 79.5,60.25 79.5,50.97 79.74,50.73 79.74,50.2 79.55,50.01 79.35,50.01 v1(78.93,50.42)
  BOTTOM w0.114: v1(78.93,50.42) 78.65,50.14 77.95,50.14 77.81,50.28 77.81,51.42 78.23,51.83 CN16.149
  BOTTOM w0.165: v2(77.93,95.61) 77.45,96.1 U18.AH26
M_A0_CS#1: length 53.6
  IN4 w0.127: v1(80.76,49.79) 80.34,49.37 80.34,48.81 80.45,48.71 80.67,48.71 80.81,48.57 80.81,48.3 80.67,48.17 79.7,48.17 79.59,48.28 79.59,49.54 80.05,49.99 80.05,50.88 79.78,51.15 79.78,60.3 79.41,60.67 79.41,61.64 79.78,62.01 79.78,64.75 80.05,65.02 80.05,84.46 79.9,84.61 79.9,86.09 79.65,86.33 79.65,91.06 79.51,91.2 79.51,92.53 79.14,92.91 v2(79.14,93.37)
  BOTTOM w0.114: v1(80.76,49.79) 80.23,50.32 CN16.157
  BOTTOM w0.165: U18.AL29 79.32,93.37 v2(79.14,93.37)
M_A_A0: length 53.1
  IN4 w0.127: v1(75.4,94.92) 75.02,94.92 74.86,94.76 74.86,91.02 74.5,90.65 74.5,85.32 75.51,84.31 75.51,66.25 73.77,64.51 73.77,61.73 74.1,61.4 74.1,58.52 74.92,57.7 74.92,48.09 75.1,47.9 75.1,47.38 v1(74.97,47.25)
  BOTTOM w0.178: v1(75.4,94.92) 74.98,94.5 U18.AE28 ; CN16.144 74.98,47.26 v1(74.97,47.25)
M_A_A1: length 53.7
  IN4 w0.127: v1(71.29,50.34) 70.74,50.34 70.35,50.73 70.35,57.54 69.46,58.43 69.46,60.29 69.05,60.69 69.05,60.94 69.2,61.09 69.85,61.09 70.04,61.27 70.04,65.28 70.89,66.14 70.89,82.97 71.81,83.89 71.81,86.83 71.29,87.35 71.29,93.6 71.22,93.67 71.22,95.1 71.13,95.19 v2(70.66,95.19)
  BOTTOM w0.178: v2(70.66,95.19) 70.87,94.98 71.17,94.98 71.25,95.06 U18.Y27 ; v1(71.29,50.34) 71.83,49.8 72.1,49.8 72.23,49.93 CN16.133
