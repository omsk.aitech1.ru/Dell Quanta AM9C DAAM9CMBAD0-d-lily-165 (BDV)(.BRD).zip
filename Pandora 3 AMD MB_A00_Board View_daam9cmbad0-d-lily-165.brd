# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2P3_CR_R: length 2.8
  BOTTOM w0.102: U28.3 250.71,15.73 250.57,15.59 250.01,15.59 249.72,15.3 249.6,15.3 249.4,15.49 249.1,15.49 248.87,15.73 R909.1
USB3_CTL2: length 6.1
  TOP w0.254: U7.8 269.15,46.08 269.38,45.85 ; 269.38,45.85 v1(269.68,45.85) 269.92,45.61 269.92,45.27 271.86,43.32 R132.1 ; 269.38,45.85 269.11,45.58 U7.7
USB3_RXN0: length 232.8
  IN3 w0.114: v1(27.02,20.55) 27.02,20.42 27.34,20.1 27.51,20.1 27.8,19.81 27.8,16.72 28.22,16.31 39.68,16.31 57.64,34.26 86.68,34.26 90.41,38 104.2,38 104.72,38.52 107.31,38.52 107.72,38.93 110.58,38.93 114.03,42.37 114.03,80.24 115.01,81.22 115.01,83.69 112.66,86.04 111.75,86.04 109.82,87.96 109.82,103.11 108.83,104.11 108.83,111.11 106.27,113.67 106.27,116.86 104.45,118.67 98.93,118.67 98.3,118.04 93.35,118.04 91.39,120 88.72,120 87.93,120.79 83.34,120.79 83.1,120.55 81.79,120.55 81.2,119.96 77.27,119.96 75.52,118.2 74.68,118.2 72.72,116.25 71.39,116.25 68.85,113.71 68.85,110.21 69.12,109.93 69.38,109.93 69.44,109.99 v2(69.44,110.15)
  BOTTOM w0.102: U18.W8 70.17,110.58 70.17,110.37 70.07,110.27 69.94,110.27 69.81,110.39 69.58,110.39 69.44,110.25 v2(69.44,110.15)
  BOTTOM w0.114: v1(27.02,20.55) 27.02,20.32 26.9,20.2 26.53,20.2 25.84,20.9 25.84,21.9 25.64,22.1 25.24,22.1 24.99,22.35 C1212.1
USB3_RXN0_C: length 2.6
  BOTTOM w0.114: U209.7 23.82,22.25 C1212.2
USB3_RXN0_L: length 17.3
  TOP w0.114: CN5.5 21.54,22.3 21.4,22.44 15.16,22.44 14.09,21.37 14.09,20.96 14.19,20.86 v1(14.4,20.86)
  BOTTOM w0.114: v1(14.4,20.86) 14.25,20.86 14.1,20.71 14.1,20.44 14.21,20.33 16.08,20.33 17.89,22.14 18.39,22.14 18.51,22.26 18.51,22.36 18.67,22.52 18.85,22.52 19,22.36 19,22.26 19.12,22.14 19.65,22.14 19.76,22.25 U209.5
USB3_RXN1: length 219.7
  IN3 w0.114: v1(30.66,16.96) 30.43,17.19 30.43,17.37 30.61,17.55 38.72,17.55 39.72,18.54 40.29,18.54 41.18,19.43 41.18,19.59 47.8,26.2 48.65,26.2 57.21,34.76 86.48,34.76 90.21,38.49 103.98,38.49 104.51,39.02 106.94,39.02 107.35,39.42 110.38,39.42 113.53,42.58 113.53,69.35 111.18,71.7 111.18,85.89 109.33,87.74 109.33,102.91 108.33,103.9 108.33,110.91 105.78,113.47 105.78,116.65 104.25,118.18 99.13,118.18 98.5,117.55 93.14,117.55 91.19,119.5 88.52,119.5 87.73,120.29 83.54,120.29 83.3,120.05 82.01,120.05 81.42,119.46 77.5,119.46 75.7,117.66 74.83,117.66 72.63,115.46 71.84,115.46 69.94,113.56 69.94,112.6 70.2,112.34 70.46,112.34 v2(70.65,112.15)
  BOTTOM w0.102: U18.W6 70.5,112.3 v2(70.65,112.15)
  BOTTOM w0.114: C1214.1 26.61,17.33 28.49,17.33 28.99,17.83 30.17,17.83 30.44,17.55 30.44,17.18 v1(30.66,16.96)
USB3_RXN1_C: length 4.4
  BOTTOM w0.114: C1214.2 25.19,17.14 24.41,17.14 24.05,16.78 22.99,16.78 22.34,16.13 U210.7
USB3_RXN1_L: length 17.5
  TOP w0.114: v1(14.92,14.88) 14.92,14.74 14.77,14.58 14.47,14.58 14.34,14.71 14.34,15.37 16.92,17.95 21.39,17.95 21.54,17.8 CN5.14
  BOTTOM w0.114: v1(14.92,14.88) 14.92,14.74 15.13,14.53 16.18,14.53 16.47,14.82 16.47,15.62 16.86,16.01 17.46,16.01 17.57,16.12 17.57,16.26 17.65,16.34 17.99,16.34 18.07,16.26 18.07,16.12 18.18,16.01 19.64,16.01 19.77,16.13 U210.5
USB3_RXN2: length 288.8
  TOP w0.102: v1(259,50.89) 259.22,50.67 259.46,50.67 259.91,51.12 259.91,52.86 262.03,54.98 262.32,54.98 C1143.1
  IN4 w0.102: v2(72.01,111.18) 72.01,111.35 72.35,111.69 72.35,111.71 72.68,112.05 72.68,113.62 75.1,116.03 75.89,116.03 76.32,116.47 76.32,117.04 77.77,118.48 87.47,118.48 88.14,117.81 90.79,117.81 92.72,115.88 98.16,115.88 99.68,117.4 103.65,117.4 104.69,116.36 104.69,113.34 108.85,109.18 108.85,104.41 110.78,102.48 110.78,93.34 117.58,86.54 117.58,79.8 114.47,76.69 114.47,47.6 115.15,46.91 115.15,43.25 118.68,39.72 120.1,39.72 130.14,29.68 138.93,29.68 139.16,29.91 149.39,29.91 151.49,32.01 161.9,32.01 162.4,31.51 185.08,31.51 187.28,33.72 217.51,33.72 218.74,34.95 244.09,34.95 254.92,45.78 257.01,45.78 260.35,49.12 260.35,50.41 260.02,50.74 259.15,50.74 v1(259,50.89)
  BOTTOM w0.102: v2(72.01,111.18) 71.69,111.5 U18.Y7
USB3_RXN2_C: length 2.5
  TOP w0.102: U29.7 264.73,54.37 264.64,54.28 264.37,54.28 263.83,54.83 263.42,54.83 263.34,54.91 C1143.2
USB3_RXN2_L: length 8.3
  TOP w0.102: CN8.5 275.92,56.28 275.68,56.04 275.07,56.04 273.72,54.69 273.5,54.69 273.31,54.87 EU1.5 EU1.6 271.86,54.87 271.72,54.74 271.57,54.74 271.47,54.83 271.47,55.34 271.24,55.57 271.01,55.57 270.72,55.86 270.42,55.86 270.26,56.02 R832.1
USB3_RXN2_RE: length 3.5
  TOP w0.102: R832.2 269.03,55.86 268.26,55.86 267.89,55.49 267.77,55.49 267.49,55.21 267.49,54.52 267.35,54.37 U29.5
USB3_RXP0: length 232.9
  IN3 w0.114: v1(27.02,19.75) 27.16,19.88 27.42,19.88 27.58,19.72 27.58,16.63 28.13,16.09 39.77,16.09 57.73,34.05 86.77,34.05 90.5,37.78 104.29,37.78 104.81,38.3 107.4,38.3 107.81,38.71 110.67,38.71 114.24,42.28 114.24,80.15 115.22,81.13 115.22,83.78 112.75,86.25 111.83,86.25 110.04,88.05 110.04,103.2 109.04,104.2 109.04,111.2 106.49,113.76 106.49,116.95 104.54,118.89 98.84,118.89 98.21,118.26 93.44,118.26 91.48,120.21 88.81,120.21 88.02,121 83.25,121 83.01,120.76 81.7,120.76 81.11,120.17 77.18,120.17 75.43,118.42 74.59,118.42 72.63,116.46 71.3,116.46 68.63,113.8 68.63,110.12 69.03,109.72 69.22,109.72 69.44,109.5 v2(69.44,109.5)
  BOTTOM w0.102: U18.W9 69.66,109.5 v2(69.44,109.5)
  BOTTOM w0.114: C1213.1 24.99,21.65 25.23,21.88 25.55,21.88 25.62,21.82 25.62,20.81 26.44,19.98 26.79,19.98 v1(27.02,19.75)
USB3_RXP0_C: length 2.7
  BOTTOM w0.114: U209.8 22.24,21.85 22.43,22.03 23.82,22.03 24.2,21.65 C1213.2
USB3_RXP0_L: length 17.3
  TOP w0.114: v1(13.63,20.86) 13.87,21.09 13.87,21.46 15.07,22.66 21.4,22.66 21.54,22.8 CN5.4
  BOTTOM w0.114: U209.4 19.75,21.85 19.67,21.93 17.98,21.93 16.17,20.11 14.12,20.11 13.88,20.35 13.88,20.6 13.63,20.85 v1(13.63,20.86)
USB3_RXP1: length 219.7
  IN3 w0.114: v2(70.69,112.75) 70.5,112.55 70.29,112.55 70.16,112.69 70.16,113.47 71.93,115.24 72.72,115.24 74.92,117.44 75.79,117.44 77.59,119.25 81.51,119.25 82.1,119.84 83.39,119.84 83.63,120.08 87.64,120.08 88.43,119.29 91.1,119.29 93.05,117.33 98.59,117.33 99.22,117.96 104.16,117.96 105.56,116.56 105.56,113.38 108.12,110.82 108.12,103.82 109.11,102.82 109.11,87.65 110.96,85.8 110.96,71.61 113.32,69.26 113.32,42.67 110.29,39.64 107.26,39.64 106.85,39.23 104.42,39.23 103.89,38.71 90.12,38.71 86.39,34.97 57.12,34.97 48.56,26.42 47.71,26.42 40.97,19.67 40.97,19.52 40.2,18.76 39.63,18.76 38.64,17.76 30.52,17.76 30.21,17.46 30.21,17.01 30.16,16.96 v1(29.86,16.96)
  BOTTOM w0.102: v2(70.69,112.75) 70.54,112.59 70.24,112.59 70.05,112.79 U18.W5
  BOTTOM w0.114: v1(29.86,16.96) 30.17,16.96 30.22,17.02 30.22,17.46 30.08,17.61 29.08,17.61 28.58,17.12 26.48,17.12 26.39,17.02 C1215.1
USB3_RXP1_C: length 4.5
  BOTTOM w0.114: C1215.2 25.2,16.92 24.5,16.92 24.14,16.57 23.08,16.57 22.24,15.73 U210.8
USB3_RXP1_L: length 17.5
  TOP w0.114: v1(14.92,14.11) 14.67,14.37 14.38,14.37 14.12,14.62 14.12,15.46 16.83,18.17 21.4,18.17 21.53,18.3 CN5.13
  BOTTOM w0.114: v1(14.92,14.11) 15.05,14.24 15.05,14.24 15.12,14.32 16.27,14.32 16.69,14.73 16.69,15.53 16.95,15.79 19.69,15.79 19.75,15.73 U210.4
USB3_RXP2: length 288.8
  TOP w0.102: C1142.1 262.75,54.4 262.75,54.62 262.61,54.77 262.12,54.77 260.12,52.77 260.12,51.03 259.55,50.46 259.16,50.46 259,50.3 v1(259,50.03)
  IN4 w0.102: v1(259,50.03) 259,50.34 259.12,50.46 259.91,50.46 260.07,50.3 260.07,49.24 256.9,46.06 254.81,46.06 243.97,35.23 218.63,35.23 217.4,33.99 187.16,33.99 184.96,31.79 162.51,31.79 162.02,32.29 151.37,32.29 149.27,30.19 139.04,30.19 138.82,29.96 130.25,29.96 120.22,40 118.8,40 115.43,43.37 115.43,47.02 114.75,47.71 114.75,76.57 117.86,79.68 117.86,86.66 111.06,93.45 111.06,102.59 109.13,104.52 109.13,109.29 104.97,113.46 104.97,116.48 103.77,117.68 99.56,117.68 98.04,116.16 92.83,116.16 90.9,118.09 88.26,118.09 87.59,118.76 77.65,118.76 76.04,117.16 76.04,116.58 75.77,116.31 74.98,116.31 72.4,113.73 72.4,112.16 72.14,111.9 71.99,111.9 v2(71.98,111.91)
  BOTTOM w0.102: U18.Y6 71.58,112.3 71.98,111.9 v2(71.98,111.91)
USB3_RXP2_C: length 2.5
  TOP w0.102: U29.8 264.75,53.97 264.66,54.07 264.29,54.07 263.74,54.62 263.44,54.62 263.34,54.52 C1142.2
USB3_RXP2_L: length 8.3
  TOP w0.102: CN8.6 275.92,55.57 275.67,55.82 275.16,55.82 273.81,54.48 273.5,54.48 273.39,54.37 EU1.4 EU1.7 271.85,54.37 271.7,54.52 271.48,54.52 271.26,54.74 271.26,55.25 271.15,55.36 271.06,55.36 270.76,55.06 270.16,55.06 R831.1
USB3_RXP2_RE: length 3.5
  TOP w0.102: R831.2 269.01,55.06 268.25,55.06 268.04,55.28 267.86,55.28 267.7,55.12 267.7,54.43 267.25,53.97 U29.4
USB3_TXN0: length 212.4
  IN3 w0.114: v1(28.42,19.27) 28.42,19.01 28.52,18.92 29.32,18.92 29.76,18.47 38.34,18.47 55.55,35.69 86.09,35.69 89.82,39.42 101.05,39.42 101.98,40.35 109.99,40.35 112.19,42.55 112.19,46.02 112.61,46.44 112.61,68.97 110.17,71.4 110.17,85.14 108.4,86.92 108.4,102.52 107.4,103.52 107.4,110.52 104.85,113.08 104.85,116.27 103.86,117.25 99.52,117.25 98.89,116.62 92.76,116.62 90.8,118.57 88.13,118.57 87.34,119.37 83.93,119.37 83.69,119.12 82.4,119.12 81.81,118.53 77.89,118.53 77.13,117.77 77.13,116.56 76.52,115.96 74.65,115.96 72.52,113.82 72.14,113.82 71.99,113.67 v2(71.99,113.52)
  BOTTOM w0.102: v2(71.99,113.52) 71.65,113.85 U18.AA4
  BOTTOM w0.114: v1(28.42,19.27) 28.13,18.98 26.46,18.98 26.37,19.07 C1216.1
USB3_TXN0_C: length 4.8
  BOTTOM w0.114: C1216.2 25.21,19.14 24.67,19.14 22.85,20.96 22.49,20.96 22.4,21.05 U209.10
USB3_TXN0_L: length 18.1
  TOP w0.114: CN5.2 21.54,23.8 21.37,23.96 15.06,23.96 12.43,21.34 12.43,20.96 12.55,20.85 v1(12.7,20.85)
  BOTTOM w0.114: v1(12.7,20.85) 12.6,20.85 12.38,20.63 12.38,18.75 12.89,18.24 13.59,18.24 13.7,18.36 13.7,18.51 13.81,18.63 14.08,18.63 14.19,18.51 14.19,18.36 14.31,18.24 15.25,18.24 C1221.2
USB3_TXN0_RE: length 5.4
  BOTTOM w0.114: C1221.1 16.99,18.29 17.4,18.29 19.24,20.13 19.24,20.75 19.45,20.96 19.71,20.96 19.75,21.01 19.75,21.01 19.79,21.05 U209.2
USB3_TXN1: length 224.6
  IN3 w0.114: v1(29.59,15.37) 29.81,15.15 29.81,14.9 30.12,14.59 39.28,14.59 49.91,25.22 51.79,25.22 52.76,26.2 52.76,27.53 57.29,32.06 85.79,32.06 90.8,37.07 104.67,37.07 105.19,37.59 107.73,37.59 108.14,38 110.97,38 114.95,41.99 114.95,79.7 116.2,80.95 116.2,84.05 111.06,89.19 110.75,89.5 110.75,110.5 107.2,114.05 107.2,117.24 104.84,119.6 98.54,119.6 97.91,118.97 93.73,118.97 91.78,120.92 89.11,120.92 88.32,121.72 82.95,121.72 82.71,121.47 81.4,121.47 80.81,120.88 76.76,120.88 75.44,119.56 72.92,119.56 71.48,118.12 v2(71.48,117.4)
  BOTTOM w0.114: v1(29.59,15.37) 29.8,15.16 29.8,14.95 29.58,14.73 28.58,14.73 27.05,13.2 26.63,13.2 C1219.1 ; v2(71.48,117.4) 71.7,117.17 71.7,116.74 71.97,116.46 71.97,116.17 71.93,116.12 71.93,116.11 71.83,116.01 71.71,116.01 71.65,116.07 U18.AA1
USB3_TXN1_C: length 5.4
  BOTTOM w0.114: C1219.2 25.61,13.23 25.47,13.09 25.24,13.09 25.09,13.24 25.09,13.61 24.53,14.17 24.53,14.42 23.87,15.09 23.21,15.09 22.96,14.84 22.31,14.84 22.21,14.93 U210.10
USB3_TXN1_L: length 16.2
  TOP w0.114: CN5.11 21.51,19.3 21.35,19.46 17.2,19.46 13.58,15.84 13.58,13.33 14.43,12.48 14.8,12.48 14.92,12.6 v1(14.92,12.74)
  BOTTOM w0.114: C1223.2 15.91,12.75 15.91,12.53 15.81,12.43 15.13,12.43 14.92,12.63 v1(14.92,12.74)
USB3_TXN1_RE: length 5.7
  BOTTOM w0.114: C1223.1 16.96,12.48 18.38,12.48 19.16,13.26 19.16,14.61 19.39,14.84 19.68,14.84 19.77,14.93 U210.2
USB3_TXN2: length 285.2
  TOP w0.102: v1(257.43,49.71) 257.7,49.44 258.13,49.44 258.38,49.19 259.26,49.19 260.85,50.78 260.85,52.28 261.39,52.82 262.32,52.82 C1139.1
  IN4 w0.102: v1(257.43,49.71) 257.62,49.53 258.32,49.53 258.72,49.13 258.72,48.59 256.68,46.54 254.61,46.54 243.77,35.71 218.43,35.71 217.2,34.48 186.93,34.48 185.23,32.77 151.17,32.77 149.13,30.73 138.88,30.73 138.59,30.44 130.45,30.44 120.42,40.48 119,40.48 115.91,43.57 115.91,47.22 115.23,47.91 115.23,76.37 118.34,79.48 118.34,87.39 111.54,94.19 111.54,102.79 110.32,104.02 110.32,108.79 105.45,113.66 105.45,117.06 104.27,118.23 99.44,118.23 97.84,116.64 93.03,116.64 91.1,118.57 88.47,118.57 87.79,119.25 77.45,119.25 75.1,116.9 75.02,116.82 73.37,116.82 72.94,117.25 72.94,117.38 v2(72.63,117.68)
  BOTTOM w0.102: U18.AC2 72.74,116.01 72.74,116.65 72.95,116.86 72.95,117.37 v2(72.63,117.68)
USB3_TXN2_C: length 2.4
  TOP w0.102: U29.10 264.63,53.17 264.53,53.08 264.27,53.08 263.87,52.68 263.41,52.68 263.34,52.75 C1139.2
USB3_TXN2_L: length 13
  TOP w0.102: R1018.1 271.27,51.64 271.92,51.64 272.22,51.35 272.3,51.35 272.38,51.43 272.38,52.02 272.15,52.25 271.56,52.25 271.31,52.5 271.31,52.99 271.51,53.19 271.68,53.19 271.87,53.37 EU1.9 EU1.2 273.19,53.37 273.34,53.22 273.83,53.22 274.18,52.86 274.18,49.59 274.46,49.31 275.73,49.31 275.92,49.5 CN8.8
USB3_TXN2_R: length 2.2
  TOP w0.102: R1018.2 270.31,51.64 269.57,51.64 269.24,51.31 268.85,51.31 268.71,51.45 C1141.2
USB3_TXN2_RE: length 3.4
  TOP w0.102: U29.2 267.24,53.17 267.67,52.75 267.67,52.29 267.29,51.91 267.29,51.6 267.54,51.35 267.79,51.35 267.93,51.49 C1141.1
USB3_TXP0: length 212.4
  IN3 w0.114: v1(28.42,18.47) 28.65,18.7 29.23,18.7 29.67,18.26 38.43,18.26 55.64,35.47 86.18,35.47 89.91,39.2 101.14,39.2 102.07,40.13 110.08,40.13 112.41,42.46 112.41,45.93 112.82,46.35 112.82,69.05 110.39,71.49 110.39,85.23 108.62,87.01 108.62,102.61 107.62,103.61 107.62,110.61 105.06,113.17 105.06,116.36 103.95,117.47 99.43,117.47 98.8,116.83 92.85,116.83 90.89,118.79 88.22,118.79 87.43,119.58 83.84,119.58 83.6,119.34 82.31,119.34 81.72,118.75 77.8,118.75 76.91,117.86 76.91,116.65 76.43,116.17 74.56,116.17 72.43,114.04 72.3,114.04 v2(72.03,114.3)
  BOTTOM w0.102: v2(72.03,114.3) 71.65,114.68 U18.AA3
  BOTTOM w0.114: v1(28.42,18.47) 28.13,18.76 26.6,18.76 C1217.1
USB3_TXP0_C: length 4.8
  BOTTOM w0.114: U209.11 22.4,20.65 22.49,20.74 22.76,20.74 24.58,18.92 25.19,18.92 C1217.2
USB3_TXP0_L: length 18.1
  TOP w0.114: v1(11.94,20.85) 12.22,21.13 12.22,21.43 14.97,24.18 21.42,24.18 21.54,24.3 CN5.1
  BOTTOM w0.114: v1(11.94,20.85) 12.16,20.62 12.16,18.66 12.8,18.03 15.33,18.03 C1220.2
USB3_TXP0_RE: length 5.4
  BOTTOM w0.114: U209.1 19.8,20.65 19.7,20.75 19.54,20.75 19.45,20.66 19.45,20.04 17.49,18.07 16.99,18.07 C1220.1
USB3_TXP1: length 224.6
  IN3 w0.114: v1(30.39,15.37) 30.19,15.37 30.03,15.21 30.03,14.99 30.21,14.81 39.19,14.81 49.82,25.44 51.7,25.44 52.55,26.29 52.55,27.62 57.2,32.28 85.7,32.28 90.71,37.29 104.58,37.29 105.1,37.81 107.64,37.81 108.05,38.22 110.88,38.22 114.74,42.08 114.74,79.79 115.98,81.03 115.98,83.96 110.9,89.04 110.53,89.41 110.53,110.41 106.98,113.97 106.98,117.15 104.75,119.39 98.63,119.39 98,118.75 93.64,118.75 91.69,120.71 89.02,120.71 88.23,121.5 83.04,121.5 82.8,121.26 81.49,121.26 80.9,120.67 76.85,120.67 75.53,119.35 73.01,119.35 71.72,118.06 71.72,117.78 72.07,117.43 v2(72.07,117.4)
  BOTTOM w0.114: C1218.1 26.38,12.88 26.48,12.98 27.14,12.98 28.67,14.51 29.67,14.51 30.02,14.86 30.02,15.22 30.17,15.37 v1(30.39,15.37) ; U18.AA2 71.65,115.53 72.14,116.02 72.14,116.03 72.19,116.08 72.19,116.55 71.93,116.81 71.93,117.25 v2(72.07,117.4)
USB3_TXP1_C: length 5.5
  BOTTOM w0.114: C1218.2 25.6,12.73 25.46,12.87 25.15,12.87 24.87,13.15 24.87,13.52 24.32,14.08 24.32,14.33 23.78,14.87 23.3,14.87 23.05,14.62 22.3,14.62 22.21,14.53 U210.11
USB3_TXP1_L: length 16.2
  TOP w0.114: CN5.10 21.45,19.8 21.33,19.68 17.11,19.68 13.36,15.93 13.36,13.24 14.34,12.26 14.64,12.26 v1(14.92,11.98)
  BOTTOM w0.114: C1222.2 15.41,12.18 15.13,12.18 v1(14.92,11.98)
USB3_TXP1_RE: length 5.7
  BOTTOM w0.114: U210.1 19.77,14.53 19.68,14.62 19.48,14.62 19.38,14.52 19.38,13.17 18.47,12.27 16.96,12.27 C1222.1
USB3_TXP2: length 285.2
  TOP w0.102: v1(257.43,48.85) 257.43,49.11 257.55,49.22 258.04,49.22 258.29,48.98 259.35,48.98 261.06,50.69 261.06,52.19 261.48,52.61 262.6,52.61 262.73,52.48 262.73,52.21 C1138.1
  IN4 w0.102: v1(257.43,48.85) 257.43,49.19 257.49,49.25 258.21,49.25 258.44,49.01 258.44,48.71 256.56,46.82 254.49,46.82 243.65,35.99 218.31,35.99 217.08,34.76 186.82,34.76 185.11,33.05 151.05,33.05 149.01,31.01 138.76,31.01 138.48,30.72 130.57,30.72 120.53,40.76 119.12,40.76 116.19,43.68 116.19,47.34 115.51,48.03 115.51,76.26 118.62,79.37 118.62,87.51 111.82,94.31 111.82,102.91 110.6,104.14 110.6,108.91 105.73,113.77 105.73,117.17 104.39,118.51 99.32,118.51 97.73,116.92 93.15,116.92 91.22,118.85 88.58,118.85 87.91,119.52 77.33,119.52 74.91,117.1 73.48,117.1 73.22,117.37 73.22,117.67 v2(73.23,117.68)
  BOTTOM w0.102: U18.AC1 73.25,116.04 73.19,115.98 73.06,115.98 72.95,116.09 72.95,116.57 73.17,116.79 73.17,117.18 73.24,117.25 73.52,117.25 73.65,117.38 73.65,117.56 73.52,117.68 v2(73.23,117.68)
USB3_TXP2_C: length 2.4
  TOP w0.102: C1138.2 263.34,52.35 263.46,52.47 263.96,52.47 264.35,52.87 264.53,52.87 264.62,52.77 U29.11
USB3_TXP2_L: length 13
  TOP w0.102: R1017.1 271.26,50.84 271.93,50.84 272.22,51.13 272.39,51.13 272.6,51.34 272.6,52.11 272.24,52.47 271.65,52.47 271.53,52.59 271.53,52.9 271.6,52.97 271.76,52.97 271.86,52.87 EU1.10 EU1.1 273.16,52.87 273.29,53 273.74,53 273.96,52.77 273.96,49.5 274.37,49.09 275.74,49.09 275.92,48.91 CN8.9
USB3_TXP2_R: length 2.1
  TOP w0.102: R1017.2 270.03,50.75 269.94,50.84 269.47,50.84 269.22,51.09 268.87,51.09 268.71,50.93 C1140.2
USB3_TXP2_RE: length 3.4
  TOP w0.102: U29.1 267.33,52.77 267.45,52.66 267.45,52.38 267.07,52 267.07,51.52 267.45,51.13 267.81,51.13 267.93,51.01 C1140.1
USB3_USB2_N0: length 203.1
  TOP w0.114: v1(35.83,20.87) 35.61,21.09 35.61,21.41 35.2,21.82 29.64,21.82 28.94,22.53 25.69,22.53 24.3,21.13 22.88,21.13 22.71,21.3 CN5.7
  IN3 w0.114: v1(35.83,20.87) 35.62,21.07 35.62,21.37 35.95,21.7 37.2,21.7 37.8,21.1 39.29,21.1 55.06,36.87 85.6,36.87 89.33,40.6 99.23,40.6 100.16,41.53 108.98,41.53 110.2,42.75 110.2,45.7 111.42,46.93 111.42,68.48 108.76,71.14 108.76,84.45 106.81,86.4 106.81,95.12 107.22,95.52 107.22,102.03 106.22,103.03 106.22,109.46 101.9,113.78 97.07,113.78 96.09,114.76 91.85,114.76 89.49,117.12 86.37,117.12 85.77,116.52 81.12,116.52 80.71,116.94 80.71,117.38 80.83,117.5 80.83,117.87 v2(81,118.04)
  BOTTOM w0.102: v2(81,118.04) 80.82,117.86 80.82,117.36 80.75,117.29 80.75,116.42 80.96,116.21 80.96,115.61 U18.AM2
USB3_USB2_N1: length 203.9
  TOP w0.114: v1(33.11,21.09) 33.31,21.09 33.44,20.97 33.44,20.57 33,20.13 32.43,20.13 31.45,21.11 29.7,21.11 29.51,20.92 28.48,20.92 28.02,21.38 26.5,21.38 24.25,19.13 24.25,17.81 23.09,16.66 22.84,16.66 22.7,16.8 CN5.16
  IN3 w0.114: v2(79.21,118.04) 79.43,117.82 79.43,117.71 79.78,117.36 79.78,116.54 80.73,115.6 86.34,115.6 86.94,116.2 89.11,116.2 91.47,113.84 95.7,113.84 96.69,112.84 101.53,112.84 105.3,109.08 105.3,102.65 106.29,101.65 106.29,95.91 105.87,95.48 105.87,85.95 107.82,84 107.82,70.77 110.5,68.09 110.5,47.31 109.27,46.09 109.27,43.22 108.51,42.46 99.73,42.46 98.8,41.53 88.95,41.53 85.22,37.79 54.67,37.79 39.52,22.64 34.27,22.64 33.38,21.75 33.38,21.37 v1(33.11,21.09)
  BOTTOM w0.102: U18.AL1 79.65,116.02 79.71,115.97 79.83,115.97 79.97,116.11 79.97,117.1 79.6,117.47 79.6,117.65 v2(79.21,118.04)
USB3_USB2_N2: length 278.5
  TOP w0.102: U7.2 266.63,43.13 266.68,43.09 266.68,42.67 v1(266.48,42.47)
  IN4 w0.102: v2(78.74,117.18) 78.96,116.96 78.96,116.44 79.73,115.68 86.53,115.68 87.05,116.2 89.06,116.2 90.9,114.36 95.62,114.36 96.67,113.3 102,113.3 107.33,107.97 107.33,103.78 109.26,101.85 109.26,90.89 114.95,85.2 114.95,80.33 112.28,77.66 112.28,69.07 112.94,68.41 112.94,46.96 113.63,46.28 113.63,42.51 117.94,38.19 119.47,38.19 120.94,36.72 120.94,35.06 127.2,28.81 128.73,28.81 129.38,28.16 140.15,28.16 140.31,28.32 149.95,28.32 152.12,30.48 156.91,30.48 158.17,29.22 161.4,29.22 162.13,29.95 184.61,29.95 187.61,32.95 217.83,32.95 219.06,34.18 244.4,34.18 255.24,45.02 260.67,45.02 261.56,44.13 265.53,44.13 266.12,43.54 266.52,43.54 266.72,43.34 266.72,42.71 v1(266.48,42.47)
  BOTTOM w0.102: U18.AL4 79.65,114.1 79.55,114.2 79.27,114.2 78.99,114.48 78.99,114.79 79.17,114.97 79.17,115.22 79.09,115.29 79.09,115.71 79.15,115.77 79.15,116.06 78.97,116.24 78.97,116.96 v2(78.74,117.18)
USB3_USB2_P0: length 203.1
  TOP w0.114: v1(35.06,20.87) 35.26,20.87 35.4,21 35.4,21.32 35.11,21.61 29.55,21.61 28.85,22.31 25.78,22.31 24.39,20.92 22.82,20.92 22.7,20.8 CN5.8
  IN3 w0.114: v1(35.06,20.87) 35.24,20.87 35.41,21.04 35.41,21.46 35.86,21.91 37.29,21.91 37.88,21.32 39.2,21.32 54.97,37.08 85.51,37.08 89.24,40.82 99.14,40.82 100.07,41.75 108.89,41.75 109.98,42.84 109.98,45.79 111.21,47.01 111.21,68.39 108.55,71.05 108.55,84.36 106.6,86.31 106.6,95.21 107,95.61 107,101.94 106.01,102.94 106.01,109.37 101.81,113.57 96.98,113.57 96,114.55 91.76,114.55 89.4,116.91 86.46,116.91 85.86,116.31 81.03,116.31 80.49,116.85 80.49,117.47 80.62,117.59 80.62,117.82 v2(80.4,118.04)
  BOTTOM w0.102: v2(80.4,118.04) 80.53,118.04 80.62,117.95 80.62,117.45 80.55,117.38 80.55,116.34 80.76,116.13 80.76,115.69 80.59,115.52 80.51,115.52 80.45,115.58 U18.AM1
USB3_USB2_P1: length 204.1
  TOP w0.114: v1(33.87,21.09) 33.87,21.09 33.65,20.87 33.65,20.48 33.09,19.91 32.34,19.91 31.36,20.9 29.79,20.9 29.6,20.7 28.39,20.7 27.93,21.16 26.59,21.16 24.47,19.04 24.47,17.72 23.18,16.44 22.84,16.44 22.7,16.3 CN5.17
  IN3 w0.114: v1(33.87,21.09) 33.6,21.35 33.6,21.66 34.36,22.42 39.61,22.42 54.76,37.58 85.31,37.58 89.04,41.31 98.89,41.31 99.82,42.24 108.6,42.24 109.49,43.14 109.49,46 110.71,47.22 110.71,68.18 108.03,70.86 108.03,84.09 107.97,84.15 106.08,86.04 106.08,95.39 106.51,95.82 106.51,101.74 105.51,102.74 105.51,109.16 101.62,113.06 96.78,113.06 95.79,114.05 91.56,114.05 89.2,116.41 86.85,116.41 86.26,115.81 80.82,115.81 80,116.63 80,117.45 79.64,117.8 79.64,117.88 v2(79.8,118.04)
  BOTTOM w0.102: v2(79.8,118.04) 79.8,117.56 80.17,117.18 80.17,116.02 U18.AL2
USB3_USB2_P2: length 278.5
  TOP w0.102: U7.3 267.13,43.19 266.89,42.95 266.89,42.58 266.9,42.58 266.9,42.57 267,42.47 v1(267.24,42.47)
  IN4 w0.102: v2(79.34,117.18) 79.24,117.08 79.24,116.56 79.85,115.96 86.41,115.96 86.93,116.48 89.18,116.48 91.02,114.64 95.73,114.64 96.79,113.58 102.11,113.58 107.61,108.08 107.61,103.89 109.54,101.96 109.54,91.01 115.23,85.32 115.23,80.21 112.56,77.54 112.56,69.18 113.22,68.52 113.22,47.08 113.91,46.39 113.91,42.63 118.06,38.47 119.58,38.47 121.22,36.84 121.22,35.18 127.31,29.09 128.84,29.09 129.49,28.44 140.03,28.44 140.2,28.6 149.84,28.6 152,30.76 157.02,30.76 158.29,29.5 161.28,29.5 162.01,30.23 184.49,30.23 187.5,33.23 217.71,33.23 218.94,34.46 244.29,34.46 255.12,45.3 260.78,45.3 261.68,44.41 265.64,44.41 266.23,43.82 266.64,43.82 267,43.46 267,42.58 267.11,42.47 v1(267.24,42.47)
  BOTTOM w0.102: v2(79.34,117.18) 79.17,117.01 79.17,116.33 79.36,116.15 79.36,115.68 79.29,115.62 79.29,115.38 79.37,115.3 79.37,114.89 79.19,114.71 79.19,114.56 79.35,114.4 79.6,114.4 79.65,114.45 U18.AL3
USB_BACK_EN: length 73.5
  TOP w0.114: U34.31 222.78,12.21 223.83,13.27 223.83,15.16 v1(223.87,15.19) ; v1(269.95,42.93) C490.2 269.38,42.64 269.38,44.12 268.92,44.58 U7.5
  IN1 w0.089: v1(223.87,15.19) 224.5,14.56 229.61,14.56 230.32,15.26 230.32,20.5 232.07,22.26 233.28,22.26 234.33,21.21 240.46,21.21 247.18,27.92 247.18,30.87 257.42,41.1 268.12,41.1 v1(269.95,42.93)
USB_CHG_DET#: length 76.8
  TOP w0.114: v1(273.61,57.16) 274.19,57.16 EC20.1 274.94,57.92 276.52,57.92 CN8.10
  IN1 w0.089: v1(273.61,57.16) 274.05,56.72 274.05,55.99 272.88,54.81 272.88,53.75 269.61,50.48 266.18,50.48 246.95,31.26 246.95,28.02 240.37,21.44 234.43,21.44 233.38,22.48 231.98,22.48 230.09,20.59 230.09,15.65 v1(229.53,15.09)
  BOTTOM w0.114: D16.3 v1(229.38,13.75) 229.57,13.94 R447.2 229.53,14.73 v1(229.53,15.09)
USB_CHG_DET#_EC: length 17.1
  TOP w0.114: U34.67 235.61,12.61 v1(235.22,12.22)
  IN3 w0.127: v1(235.22,12.22) 233.29,12.22 231.1,14.41 225.59,14.41 v1(224.81,15.18)
  BOTTOM w0.114: D16.1 225.51,14.4 225.44,14.47 C728.1 R445.1 224.6,15.18 v1(224.81,15.18)
USB_OC1#: length 281
  TOP w0.114: v2(78.57,122.03) 80.68,119.92 102.77,119.92 110.48,112.21 110.48,93.06 107.1,89.68 107.1,77.38 115.13,69.35 115.13,60.89 v1(116.1,59.93) ; v1(253.81,48.16) 255.89,46.08 v1(256.76,46.08) U7.13
  IN4 w0.089: v1(116.1,59.93) 115.98,59.81 115.98,48.22 116.67,47.54 116.67,43.88 119.31,41.24 120.73,41.24 129.52,32.44 130.41,32.44 130.65,32.2 138.25,32.2 138.71,31.74 145.57,31.74 146.25,32.42 146.25,34.17 147.05,34.97 148.46,34.97 148.83,34.6 149.52,34.6 149.63,34.71 151.9,34.71 152.85,33.75 161.94,33.75 164.12,35.94 217.27,35.94 218.11,36.78 243.19,36.78 253.81,47.4 v1(253.81,48.16)
  BOTTOM w0.114: v2(78.57,122.03) 78.57,121.88 78.26,121.57 78.26,120.97 R549.1 77.85,119.68 77.29,119.68 76.35,118.75 76.35,116.39 U18.AG1
USB_OC2#: length 242.2
  TOP w0.114: v1(23.72,9.28) 23.24,8.8 CN5.32 ; v2(81.54,122.03) 83.17,120.4 102.97,120.4 110.96,112.41 110.96,92.76 107.68,89.48 107.68,77.48 115.66,69.51 115.66,61.98 116.78,60.86 116.78,56.57 118.09,55.25 118.09,49.41 116.11,47.43 116.11,38.13 115.79,37.81 115.79,36.49 111.7,32.39 111.7,27.56 v1(112.39,26.87)
  IN4 w0.089: v1(109.51,16.45) 109.51,16.45 97.48,16.45 97.09,16.84 77.18,16.84 76.25,15.92 52.46,15.92 50.3,13.76 34.91,13.76 32.12,10.97 25.83,10.97 24.14,9.28 v1(23.72,9.28)
  BOTTOM w0.102: 77.47,116.12 77.55,116.04 77.55,115.76 77.25,115.45 U18.AH2
  BOTTOM w0.114: v2(81.54,122.03) 81.53,122.03 81.42,121.91 81.42,120.97 R550.1 ; v1(112.39,26.87) v1(111.56,26.05) 111.56,23.8 108.75,20.98 108.75,17.32 109.51,16.55 v1(109.51,16.45)
  BOTTOM w0.127: R550.1 81.85,119.6 81.15,118.9 77.67,118.9 77,118.23 77,116.79 77.18,116.6 77.18,116.41 77.47,116.12
USB_RIGHT_EN#: length 213.6
  TOP w0.114: v1(221.04,8.69) 221.6,9.25 222.24,9.25 222.37,9.38 U34.33 ; CN5.31 v1(23.07,9.3)
  IN4 w0.089: v1(23.07,9.3) 23.53,8.84 24.05,8.84 25.95,10.74 32.21,10.74 35.01,13.53 50.39,13.53 52.51,15.65 52.69,15.65 52.73,15.69 74.9,15.69 75.63,14.95 77.68,14.95 79.34,16.61 97,16.61 97.48,16.13 107.55,16.13 108.58,15.1 118.62,15.1 118.8,15.28 123.49,15.28 124.51,16.29 140.81,16.29 141.76,15.34 145.01,15.34 146.56,16.89 155.7,16.89 156.2,17.38 172.86,17.38 179.87,10.37 184.67,10.37 189.17,5.87 218.22,5.87 v1(221.04,8.69)
USB_ZVSS: length 1.7
  TOP w0.114: v2(81.45,112.64) 82.26,112.64 R579.2
  BOTTOM w0.102: v2(81.45,112.64) 81.91,113.1 U18.AP5
USBP0_BUS_SW_CB0: length 57.5
  TOP w0.114: v1(232.5,21.8) 231.17,23.13 U34.106 ; U7.6 269.13,45.08 v1(269.76,44.46) 269.98,44.24 C487.2 270.62,43 v1(270.62,42.85)
  IN1 w0.089: v1(270.62,42.85) 268.64,40.87 257.51,40.87 247.41,30.77 247.41,27.83 240.4,20.83 234.39,20.83 233.42,21.8 v1(232.5,21.8)
USBSS_CALRN: length 6.3
  BOTTOM w0.241: U18.AD2 73.62,115.53 73.62,116.37 74.14,116.89 74.14,117.67 74.28,117.81 74.28,119.65 R587.2
USBSS_CALRP: length 6
  BOTTOM w0.241: U18.AD1 74.05,116.31 74.49,116.75 74.49,117.53 74.73,117.78 74.73,119.72 74.35,120.1 R588.2
  BOTTOM w0.254: R1082.2 R588.2
VCLK: length 4.7
  BOTTOM w0.203: PU2.19 147.36,10.92
  BOTTOM w0.254: PC89.1 144.94,13.1 v1(145.43,12.6) 145.67,12.6 PC252.1 147.36,10.92
VGA_AC_BATT: length 24.7
  TOP w0.114: v2(133.76,102.71) 133.76,102.3 133.47,102.01 133.47,101.46 132.91,100.9 132.91,100.56 132.78,100.43 132.78,95.81 133.24,95.36 v1(133.57,95.36) 133.8,95.13 133.8,92.92 133.8,92.92 133.8,86.15 R1014.2 R679.1 135.67,83.02 135.07,83.62 Q45.3
  BOTTOM w0.127: U22.AA34 133.76,102.36 v2(133.76,102.71)
VGA_CTF: length 19.7
  TOP w0.114: R1013.2 v1(119.06,116.57) 119.32,116.57 120.46,115.42 120.46,114.2 122.89,111.77 124.45,111.77 126.64,109.57 128.67,109.57 129.52,108.72 129.52,107.98 131.34,106.16 v2(131.55,106.16)
  BOTTOM w0.127: v2(131.55,106.16) 131.15,105.76 U22.R38
VGA_PWR_LEVEL_EC#: length 189.1
  TOP w0.114: v1(189.08,36.98) 190.75,35.32 190.75,29.06 190.48,28.78 190.48,20.61 199.27,11.82 201.08,11.82 201.26,11.64 205.5,11.64 210.18,6.96 v1(230.24,6.96) 230.54,6.96 231.19,7.61 231.19,8.02 231.97,8.8 U34.57 ; Q45.2 133.13,82.06 131.47,83.72 128.34,83.72 127.7,83.09 v1(127.7,82.63)
  IN1 w0.089: v1(127.7,82.63) 125.89,82.63 124.57,81.3 124.57,73.72 121.72,70.87 121.72,53.2 124.16,50.76 124.16,44.25 125.03,43.39 128.42,43.39 131.04,40.77 142.06,40.77 142.88,41.59 144.65,41.59 147.43,38.81 151.58,38.81 151.58,38.82 160.26,38.82 164.64,43.2 177.36,43.2 181.12,39.43 186.63,39.43 v1(189.08,36.98)
VR_ON: length 431.2
  TOP w0.114: v1(114.23,26.69) 114.06,26.87 114.06,29.89 114.4,30.24 v1(114.57,30.24) 114.31,30.5 114.31,32.94 117.25,35.88 117.25,37.21 117.57,37.52 117.57,45.82 121.2,49.45 121.2,55.45 119.76,56.89 119.76,61.63 118.96,62.43 118.96,70.36 118,71.32 117.15,71.32 110.02,78.45 110.02,88.46 113.3,91.74 113.3,115.74 115.59,118.04 115.59,122.87 114.61,123.86 114.61,130.71 117.41,133.52 120.17,133.52 121.56,134.9 121.56,139.99 v1(121.25,140.29) PR270.1 ; PR318.1 40.6,116.33 40.6,115.55 v1(40.17,115.12) ; v1(218.9,18.14) 219.52,18.14 219.85,17.81 U34.17
  IN1 w0.089: v1(31.02,81.16) 29.67,82.51 29.67,87.94 32.85,91.12 32.85,96.44 31.81,97.47 31.81,114.02 32.39,114.6 32.84,114.6 33.17,114.27 33.17,113.68 34.78,112.08 35.55,112.08 36.28,111.34 37.18,111.34 40.17,114.33 v1(40.17,115.12) ; v1(114.23,26.69) 114.23,26.2 115.75,24.67 117.47,24.67 118.28,25.48 122.87,25.48 123.75,24.6 124.98,24.6 125.43,25.05 128.97,25.05 130.07,23.96 137.48,23.96 138.1,24.58 139.94,24.58 140.39,24.13 146.63,24.13 147.66,25.16 149.76,25.16 151.39,26.8 156.19,26.8 157,25.98 163.96,25.98 164.5,25.44 172.97,25.44 173.98,24.43 184.86,24.43 185.98,23.3 204.2,23.3 208.78,18.72 218.32,18.72 v1(218.9,18.14)
  IN4 w0.089: v1(31.02,81.16) 31.45,81.16 32.72,79.89 32.72,73.16 30.84,71.28 30.84,64.95 30,64.11 30,59.39 30.98,58.41 30.98,36.19 34.58,32.6 37,32.6 37.7,33.3 61.28,33.3 64.25,30.33 95.33,30.33 98.47,33.47 101.83,33.47 102.31,32.99 111.2,32.99 112.65,31.53 113.9,31.53 114.57,30.86 v1(114.57,30.24)
VREFC_A0: length 3.3
  TOP w0.508: R804.2 122.87,133.24 R808.2 C1035.2 123.89,134.08 v1(123.72,133.91)
  vias: v1(123.58,133.28)
VREFC_A1: length 10
  TOP w0.508: R805.2 156.9,137.77 C1036.2 157.21,136.53 157.66,136.09 R809.2 157.66,135.04 157.47,134.85 157.47,133.63 158.29,132.81 v1(158.85,132.81)
  BOTTOM w0.356: VRAM2.J14 155.74,133.27 156.81,133.27
  BOTTOM w0.508: v1(158.85,132.81) 157.27,132.81 156.81,133.27
VREFC_B0: length 5.7
  BOTTOM w0.356: VRAM3.J14 171.12,118.39
  BOTTOM w0.508: R806.2 C1037.2 R810.2 171.12,118.39
VREFC_B1: length 6
  BOTTOM w0.356: VRAM4.J14 171.11,86.75 171.27,86.58 171.27,85.75
  BOTTOM w0.508: R807.2 R811.2 C1038.2 171.9,84.57 171.27,85.19 171.27,85.75
VREFD1_A0: length 4.2
  TOP w0.508: R788.2 C1027.2 R792.2 v1(130.21,140.35) 129.68,140.35 v1(129.55,140.22)
  BOTTOM w0.356: v1(129.55,140.22) VRAM1.A10
VREFD1_A1: length 3.8
  TOP w0.381: R789.2 152.32,127.44 v1(152.77,127.44) 152.75,127.42 R793.2 152.99,126.4 152.99,125.62 C1028.2
  BOTTOM w0.356: VRAM2.A10 v1(152.77,127.44)
VREFD1_B0: length 0.6
  BOTTOM w0.356: VRAM3.A10 v1(177.92,114.54)
VREFD1_B1: length 3.9
  TOP w0.381: R791.2 R795.2 C1030.2 164.77,90.47 165.06,90.18 v1(165.06,89.75)
  BOTTOM w0.356: VRAM4.A10 164.71,90.1 v1(165.06,89.75)
VREFD2_A0: length 3.4
  TOP w0.381: R796.2 R800.2 C1031.2 129.83,127.14 v1(129.55,127.42)
  BOTTOM w0.356: VRAM1.U10 v1(129.55,127.42)
VREFD2_A1: length 4.3
  TOP w0.508: v1(152.77,140.24) 152.76,140.25 v1(152.03,140.25) R801.2 C1032.2 R797.2
  BOTTOM w0.381: VRAM2.U10 v1(152.77,140.24)
VREFD2_B0: length 3.9
  TOP w0.152: v1(165.12,114.54) 165.09,114.57 C1033.2 164.66,114.83 164.66,115.52 164.41,115.78 R802.2
  TOP w0.381: R802.2 164.41,116.31 164.47,116.38 R798.2
  BOTTOM w0.356: VRAM3.U10 v1(165.12,114.54)
VREFD2_B1: length 0.6
  BOTTOM w0.356: VRAM4.U10 v1(177.91,89.75)
VRM_PWRGD: length 302.6
  TOP w0.114: v1(239.46,17.65) 242.4,17.65 244.57,19.82 244.57,22.83 243.92,23.48 R1075.2 ; v1(107.74,139.2) 108.48,138.46 v1(112.46,138.46) 113.66,138.46 114.75,137.36 114.75,131.9 113.87,131.02 113.87,123.55 114.86,122.56 114.86,118.34 112.56,116.05 112.56,92.05 109.28,88.77 109.28,78.14 117.26,70.17 117.26,63.1 119.03,61.32 119.03,56.58 120.46,55.14 120.46,49.75 116.83,46.12 116.83,37.83 116.52,37.51 116.52,36.19 113.58,33.25 113.58,30.46 113.32,30.2 113.32,26.15 113.68,25.78 113.68,24.19 114.58,23.3 118.98,23.3 120.06,24.38 124.87,24.38 125.51,23.74 129.86,23.74 130.96,24.85 135.22,24.85 136.24,23.83 136.94,23.83 138.01,22.76 159.3,22.76 159.64,22.42 166.26,22.42 166.85,21.82 180,21.82 185.36,16.46 189.6,16.46 195.41,10.65 200.97,10.65 201.69,9.94 v1(201.69,9.93)
  TOP w0.254: PR264.1 115.35,149.86 115.06,150.15 v1(114.88,150.15)
  IN4 w0.254: v1(114.88,150.15) 114.3,150.73 110.77,150.73 107.48,147.44 107.48,139.71 107.74,139.45 v1(107.74,139.2)
  BOTTOM w0.114: v1(239.46,17.65) 237.96,19.16 236.02,19.16 235.76,18.89 235.76,16.96 234.82,16.03 234.82,15.18 233.79,14.14 233.79,14.01 231.75,11.97 214.14,11.97 210.87,8.69 203.82,8.69 203.56,8.95 202.67,8.95 v1(201.69,9.93)
  BOTTOM w0.254: PR507.2 PR508.1 107.77,138.86 107.74,138.88 v1(107.74,139.2)
VSUM+: length 44.6
  IN3 w0.254: v1(120.22,138.15) 119.99,137.93 119.14,137.93 117.87,136.65 115.88,136.65 113.02,133.79 108.83,133.79 106.54,131.5 97.83,131.5 v1(93.9,135.44)
  BOTTOM w0.203: PC9134.1 115.9,139.19 115.73,139.36 114.74,139.36 113.7,140.39 PU16.14
  BOTTOM w0.254: v1(93.9,135.44) v1(93.16,135.44) 92.73,135.44 PR291.2 ; v1(120.22,138.15) 119.56,137.49 PR302.1 PR279.1 118.14,137.55 118.72,138.13 PR293.2 118.72,138.65 118.23,139.14 117.59,139.14 PC9135.2 PC9134.1
VSUM+_GFX: length 44.9
  IN1 w0.254: v1(42.98,118.01) 42.65,117.68 40.36,117.68 40.28,117.61 37.94,117.61 37.86,117.53 37.33,117.53 35.79,115.99 35.79,113.53 36.43,112.89 v1(36.43,112.32)
  BOTTOM w0.203: PU17.14 36.18,121.29
  BOTTOM w0.254: 36.18,121.29 36.18,121.29 35.37,120.48 35.37,119.95 34.91,119.49 PC9174.1 34.79,119.18 34.79,117.91 34.15,117.28 PC9175.2 34.01,117.28 33.09,116.36 PR337.2 33.51,116.18 33.74,116.42 34.22,116.42 34.65,115.99 35.18,115.99 35.94,115.23 35.94,115.01 PR317.1 PR341.1 36.04,113.13 36.43,112.74 v1(36.43,112.32) ; v1(42.98,118.01) 43.63,118.01 44.51,118.89 45.57,118.89 47.02,120.33 47.02,123.47 49.6,126.06 54.34,126.06 55.79,127.51 PR335.2
VSUM+_GPU: length 45.4
  IN1 w0.254: v1(126.46,69.72) 125.05,69.72 124.57,69.24 124.57,55.81 125.01,55.37 125.01,53.79 125.6,53.2 126.45,53.2 129.44,50.22 129.44,45.59 131.12,43.91 v1(132.1,43.91)
  BOTTOM w0.203: PU24.14 137.67,49.16 136.98,48.48 136.93,48.48 136.5,48.05
  BOTTOM w0.254: 136.5,48.05 136.5,46.67 136.24,46.41 PC9281.1 PC9282.1 135.99,47.39 135.5,47.88 134.92,47.88 134.73,47.69 PR437.2 133.95,47.69 133.36,47.1 PR440.1 PR417.1 132.87,45.19 v1(132.21,44.53) 132.1,44.42 v1(132.1,43.91) ; PR435.2 v1(126.46,69.72)
VSUM-: length 72.6
  TOP w0.254: PR304.2 80.78,132.48 v1(81.09,132.8) 81.56,133.26 PR285.2
  IN2 w0.254: v1(120.22,138.89) 120.84,138.28 120.84,134.51 118.83,132.49 108.55,132.49 106.82,130.76 98.48,130.76 96.3,132.95 92.72,132.95 91.81,133.86 86.72,133.86 85.86,133 82.97,133 82.72,133.25 81.54,133.25 v1(81.09,132.8)
  IN3 w0.254: v1(115.28,137.05) 117.71,137.05 118.98,138.32 119.65,138.32 v1(120.22,138.89)
  BOTTOM w0.254: PR296.2 86.53,133.46 85.77,132.7 84.76,132.7 83.85,133.6 81.65,133.6 81.09,133.05 v1(81.09,132.8) ; v1(120.22,138.89) 120.22,139.67 120.39,139.84 PC9141.1 119.75,140.08 119.49,139.83 PC9126.2 PC9124.1 ; v1(115.28,137.05) 115.28,137.27 PR298.2 PC9134.2 PC9135.1 116.92,137.68 117.88,138.64 PR293.1
VSUM-_GFX: length 56.9
  TOP w0.254: PR322.2 PR345.2 v1(63.7,132.62)
  IN1 w0.254: v1(43.5,118.6) 42.66,118.6 42.14,118.08 40.2,118.08 40.12,118 37.78,118 37.7,117.92 37.17,117.92 35.24,116 35.24,113.2 v1(35.84,112.6)
  BOTTOM w0.254: PC9174.2 34.13,118.13 PC9175.1 33.95,118.06 PR343.2 33.09,117.08 32.31,116.3 PR337.1 31.94,115.81 PC9177.1 32.08,114.91 33.2,114.91 PC9157.1 PC9163.2 33.91,112.73 35.71,112.73 v1(35.84,112.6) ; v1(43.5,118.6) 44.17,119.27 45.41,119.27 46.64,120.49 46.64,123.63 49.44,126.44 54.19,126.44 55.23,127.49 55.23,130.64 55.47,130.87 PR340.2 55.79,131.61 56.85,132.67 60.17,132.67 61.11,133.61 62.9,133.61 63.7,132.81 v1(63.7,132.62)
VSUM-_GPU: length 68.7
  TOP w0.254: v1(126.34,73.2) 127.91,74.77 132.8,74.77 133.55,74.01 PR444.2 134,73.64 134.71,74.35 139.51,74.35 140.09,73.77 PR419.2
  IN1 w0.254: v1(132.73,43.38) 131.09,43.38 129.04,45.42 129.04,50.06 126.29,52.81 125.43,52.81 124.61,53.63 124.61,55.21 124.17,55.65 124.17,71.59 125.78,73.2 v1(126.34,73.2)
  BOTTOM w0.254: PC9268.1 135.98,43.49 135.41,42.92 PC9284.1 134.91,42.6 134.56,42.96 PC9273.2 ; PC9281.2 PC9282.2 134.74,46.91 PR437.1 133.66,46.42 133.66,44.82 PC9273.2 ; PC9273.2 133.83,43.93 133.38,43.48 PR443.2 133.26,43.38 v1(132.73,43.38) ; PR439.2 125.42,69.71 124.83,70.3 v1(124.83,71.4) 124.83,72.26 125.77,73.2 v1(126.34,73.2)
VSUMG+: length 37.7
  IN2 w0.254: v1(117.86,148.21) 120.03,148.21 120.37,147.87 120.37,145.64 121.18,144.83 121.18,141.31 120.7,140.84 119.43,140.84 116.75,138.16 108.97,138.16 108.24,137.43 v1(108.24,136.91)
  BOTTOM w0.203: PR255.2 PC9101.1 PC9100.2 116.33,147.94 114.9,146.51 PU16.40
  BOTTOM w0.254: v1(108.24,136.91) 108.07,136.91 107.39,136.23 107.39,135.26 106.76,134.63 PR251.2 ; PR261.1 120.77,147.85 v1(119.8,147.85) 119.09,147.85 118.73,148.21 v1(117.86,148.21) 117.86,148.28 PR255.2
VSUMG+_CI: length 50.7
  TOP w0.254: v1(157.6,71.19) 158.97,71.19 162.52,67.64 162.52,55 154.16,46.65 152.53,46.65 151.21,45.33 149.33,45.33 v1(148.85,45.82)
  BOTTOM w0.203: PU24.40 143.77,47.96 143.98,47.75
  BOTTOM w0.254: PR395.2 157.29,71.49 v1(157.6,71.19) ; 143.98,47.75 143.98,47.75 143.98,46.69 v1(144.03,46.64) 144.08,46.59 144.77,46.59 145.57,45.79 145.57,45.27 PC9246.2 146.1,44.44 146.33,44.2 147.39,44.2 PC9245.1 148.16,44.53 148.16,44.36 148.28,44.25 149.02,44.25 149.84,45.07 PR404.1 150.31,45.2 149.88,45.62 149.04,45.62 v1(148.85,45.82) PR399.2
VSUMG-: length 36.7
  TOP w0.254: v1(119.9,150.08) 119.41,149.59 PR259.2
  IN2 w0.254: v1(108.76,136.38) 108.76,137.39 109.13,137.76 116.92,137.76 119.6,140.44 120.87,140.44 121.58,141.15 121.58,144.99 120.77,145.8 120.77,149.22 v1(119.9,150.08)
  BOTTOM w0.203: PC9100.1 116.43,149.61 117.19,149.61 PC9101.2 PR255.1 PC9111.1 119.33,149.51 v1(119.9,150.08) 120.49,149.5 PR263.2
  BOTTOM w0.254: PR258.2 106.32,131.94 106.61,132.24 106.61,133.8 v1(106.95,134.14) 107.77,134.96 107.77,136.07 108.08,136.38 v1(108.76,136.38)
VSUMG-_CI: length 43.9
  TOP w0.254: v1(148.86,46.6) 149.21,46.6 v1(149.63,46.17) 150.09,45.71 151.05,45.71 152.37,47.03 154.01,47.03 162.07,55.1 162.07,67.55 159.08,70.54 v1(157.57,70.54)
  BOTTOM w0.254: PR402.2 157.56,70.53 v1(157.57,70.54) ; PC9245.2 148.72,44.97 148.42,45.27 147.66,45.27 147.14,44.75 PC9246.1 146.88,44.94 146.08,45.74 PR403.2 PC9255.1 147.26,45.82 148.04,46.6 PR399.1 v1(148.86,46.6) 148.87,46.59 PR405.2
VSYNC: length 22.1
  TOP w0.114: v2(133.09,103.93) 132.88,104.12 132.88,104.86 132.54,105.19 131.18,105.19 130.93,105.44 129.03,105.44 128.47,106 124.21,110.26 122.57,110.26 121.57,111.27 v1(121.57,111.7) 120.97,112.3 119.88,112.3 119.25,112.3 119.14,112.19 119.14,111.58 118.18,110.63 R943.2 R942.1
  BOTTOM w0.127: v2(133.09,103.93) 132.75,103.59 U22.W35
WCKA0_0: length 43.3
  IN4 w0.114: v1(134.35,137.82) 133.94,137.82 133.87,137.89 133.87,139.8 134.83,140.76 138.38,140.76 141.08,138.06 141.08,135.36 140.52,134.8 140.52,119.68 135.21,114.37 135.21,113.65 133.73,112.17 133.73,110.99 133.52,110.78 133.39,110.78 133.22,110.94 v1(133.22,111.16)
  BOTTOM w0.127: v1(134.35,137.82) VRAM1.D4 ; U22.D33 133.41,111.35 v1(133.22,111.16)
WCKA0_1: length 20.9
  BOTTOM w0.102: 133.21,115.27 133.21,115.24 133.2,115.23 133.2,114.75 133.1,114.65 133.1,113.72 133.2,113.62 U22.A34
  BOTTOM w0.127: 133.21,115.27 133.21,116.53 131.51,118.23 131.51,124.08 132.36,124.93 132.36,125.21 v1(132.92,125.76) 132.5,125.76 132.36,125.9 132.36,126.73 132.9,127.26 133.22,127.26 133.48,127.53 133.48,128.15 133.22,128.41 132.9,128.41 132.77,128.53 132.77,128.83 132.98,129.04 134.37,129.04 VRAM1.P4
WCKA0B_0: length 44.1
  IN4 w0.114: v1(133.4,137.69) 133.65,137.94 133.65,139.89 134.74,140.97 138.47,140.97 141.29,138.15 141.29,135.27 140.74,134.71 140.74,119.59 135.43,114.28 135.43,113.56 133.95,112.08 133.95,110.9 133.61,110.56 133.35,110.56 v2(133.2,110.41)
  BOTTOM w0.127: v1(133.4,137.69) 133.68,137.69 VRAM1.D5 ; U22.E33 133.34,110.55 v2(133.2,110.41)
WCKA0B_1: length 21.2
  BOTTOM w0.102: U22.B34 133.2,112.65 132.9,112.95 132.9,113.27 133,113.37 133,113.54 132.9,113.64 132.9,114.73 133,114.83 133,115.23 132.99,115.24 132.99,115.27
  BOTTOM w0.127: VRAM1.P5 133.8,129.27 132.89,129.27 132.54,128.93 132.54,128.44 132.8,128.18 133.13,128.18 133.25,128.05 133.25,127.62 133.13,127.49 132.8,127.49 132.14,126.82 132.14,125.9 132,125.76 v1(131.65,125.76) 132.14,125.28 132.14,125.02 131.28,124.17 131.28,118.14 132.99,116.43 132.99,115.27
WCKA1_0: length 27.8
  BOTTOM w0.102: U22.A22 139.78,113.12 139.78,113.86 139.72,113.92 139.72,114.53 139.82,114.64 139.82,115.04 139.81,115.06 139.81,115.08
  BOTTOM w0.127: VRAM2.D4 147.66,129.44 148.04,129.06 148.74,129.06 150.14,130.46 150.32,130.46 150.65,130.14 150.65,129.96 149.13,128.45 149.13,125.24 147.91,124.02 147.06,124.02 146.93,124.14 v1(146.93,124.54) 146.38,123.98 145.13,123.98 139.81,118.66 139.81,115.08
WCKA1_1: length 29.5
  IN4 w0.114: v1(148.1,115.85) 147.9,115.85 147.77,115.98 147.77,116.2 148.3,116.72 148.3,120.92 149.99,122.62 149.99,135.08 150.72,135.8 150.72,137.15 150.27,137.61 149.8,137.61 v1(149.57,137.84)
  BOTTOM w0.102: v1(148.1,115.85) 148.1,115.85 147.79,115.54 147.79,115.36 147.43,115 147.43,114.68 147.59,114.51 147.59,113.78 147.47,113.66 147.47,113.32 147.5,113.29 U22.A8
  BOTTOM w0.127: v1(149.57,137.84) 149.32,137.84 149.28,137.8 147.93,137.8 VRAM2.P4
WCKA1B_0: length 27.8
  BOTTOM w0.102: U22.B21 140.11,112.99 140.11,113.25 139.98,113.37 139.98,113.94 139.92,114.01 139.92,114.45 140.02,114.55 140.02,115.04 140.04,115.06 140.04,115.08
  BOTTOM w0.127: VRAM2.D5 148.52,129.29 148.65,129.29 150.05,130.69 150.42,130.69 150.88,130.23 150.88,129.86 150.81,129.8 149.36,128.35 149.36,125.15 148,123.79 147.06,123.79 146.93,123.66 v1(146.93,123.27) 146.45,123.75 145.23,123.75 140.04,118.56 140.04,115.08
WCKA1B_1: length 29.4
  IN4 w0.114: v1(149.57,137.04) 149.57,137.28 149.68,137.39 150.18,137.39 150.51,137.06 150.51,135.89 149.78,135.16 149.78,122.71 148.08,121.01 148.08,116.81 147.55,116.28 147.55,115.98 147.42,115.85 v1(147.25,115.85)
  BOTTOM w0.102: U22.B9 147.06,112.75 147.19,112.88 147.19,113.24 147.27,113.32 147.27,113.74 147.39,113.86 147.39,114.43 147.22,114.59 147.22,115.08 147.59,115.45 147.59,115.73 147.47,115.85 v1(147.25,115.85)
  BOTTOM w0.127: VRAM2.P5 148.5,137.57 149.18,137.57 149.57,137.18 v1(149.57,137.04)
WCKB0_0: length 30.5
  IN4 w0.114: v1(175.7,110.88) 175.88,111.06 176.24,111.06 176.56,111.38 176.56,111.88 175.98,112.46 174.15,112.46 173.01,111.32 172.06,111.32 171.62,111.76 163.36,111.76 161.5,109.9 154.14,109.9 v1(153.7,109.46)
  BOTTOM w0.102: U22.H1 151.86,109.3 151.92,109.36 153.6,109.36 v1(153.7,109.46)
  BOTTOM w0.127: VRAM3.D4 175.49,109.71 175.49,110.67 v1(175.7,110.88)
WCKB0_1: length 30.6
  BOTTOM w0.102: 154.21,101.63 154.08,101.51 151.97,101.51 151.88,101.6 U22.AB1
  BOTTOM w0.127: VRAM3.P4 166.71,109.75 166.71,110.73 167.48,111.5 169.48,111.5 169.6,111.62 169.6,112.03 169.46,112.17 163.65,112.17 v1(163.13,111.65) 162.62,112.16 162.06,112.16 157.51,107.61 157.51,105.06 155.65,103.19 155.65,102.06 155.22,101.63 154.21,101.63
WCKB0B_0: length 30.5
  IN4 w0.114: v1(175.7,111.53) 175.96,111.27 176.15,111.27 176.35,111.47 176.35,111.79 175.89,112.24 174.24,112.24 173.1,111.1 171.97,111.1 171.53,111.54 163.44,111.54 161.59,109.69 154.42,109.69 154.35,109.61 v1(154.35,109.47)
  BOTTOM w0.102: U22.J2 151.2,108.75 151.52,109.07 151.91,109.07 151.94,109.1 151.94,109.1 152.01,109.16 153.31,109.16 153.42,109.06 154.17,109.06 154.35,109.23 v1(154.35,109.47)
  BOTTOM w0.127: v1(175.7,111.53) 175.25,111.08 175.25,110.27 VRAM3.D5
WCKB0B_1: length 30.6
  BOTTOM w0.102: 154.21,101.86 154.11,101.86 153.95,101.71 152.08,101.71 151.97,101.82 151.55,101.82 U22.AA2
  BOTTOM w0.127: 154.21,101.86 155.12,101.86 155.42,102.16 155.42,103.29 157.28,105.15 157.28,107.7 161.96,112.38 162.59,112.38 v1(163.13,112.92) 163.65,112.4 169.56,112.4 169.83,112.12 169.83,111.53 169.57,111.27 167.57,111.27 166.94,110.63 166.94,110.32 VRAM3.P5
WCKB1_0: length 25
  BOTTOM w0.102: 154.21,95.03 153.57,95.03 153.54,95 153.06,95 152.94,94.88 151.98,94.88 151.89,94.97 151.33,94.97 U22.AP1
  BOTTOM w0.127: 154.21,95.03 154.91,95.03 158.23,91.72 162.29,91.72 v1(162.79,92.23) 163.47,91.56 163.91,91.56 164.35,92 169.04,92 169.28,92.24 169.28,92.57 169.01,92.84 167.6,92.84 166.74,93.7 166.74,94.26 167.11,94.64 VRAM4.D4
WCKB1_1: length 43.6
  IN4 w0.114: v1(149.18,95.02) 148.97,95.23 148.97,95.42 149.04,95.49 149.47,95.49 149.55,95.42 150.31,95.42 151.85,96.97 158.61,96.97 162.59,100.95 177.19,100.95 179,99.14 179,94.66 178.15,93.81 177.08,93.81 176.8,94.09 175.97,94.09 v1(175.51,94.55)
  BOTTOM w0.127: VRAM4.P4 v1(175.51,94.55) ; v1(149.18,95.02) 149.18,95.42 149.3,95.55 U22.AN4
WCKB1B_0: length 25.2
  BOTTOM w0.102: U22.AP2 150.85,95 151.17,94.67 151.39,94.67 151.52,94.77 151.8,94.77 151.9,94.67 153.02,94.67 153.14,94.79 153.62,94.79 153.66,94.83 154.11,94.83 154.12,94.82 154.18,94.82 154.19,94.81 154.21,94.81
  BOTTOM w0.127: VRAM4.D5 166.97,94.01 166.97,93.79 167.69,93.07 169.1,93.07 169.51,92.66 169.51,92.14 169.14,91.77 164.45,91.77 164.01,91.33 163.16,91.33 v1(162.79,90.96) 162.26,91.49 158.13,91.49 154.82,94.81 154.21,94.81
WCKB1B_1: length 44.4
  IN4 w0.114: v2(148.53,95) 148.75,95.22 148.75,95.51 148.95,95.71 149.56,95.71 149.64,95.64 150.22,95.64 151.77,97.19 158.52,97.19 162.5,101.16 177.28,101.16 179.22,99.23 179.22,94.57 178.24,93.59 176.99,93.59 176.72,93.87 175.63,93.87 v1(175.51,93.75)
  BOTTOM w0.127: U22.AN5 148.53,95.33 148.53,95 v2(148.53,95) ; v1(175.51,93.75) VRAM4.P5
WEA0B: length 31
  TOP w0.102: v1(135.4,109.4) 134.94,109.86 134.94,110.92 134.81,111.05 134.81,112.12 134.05,112.88
  TOP w0.14: v1(128.79,132.23) 128.25,131.68 127.7,131.68 126.83,130.81 126.83,128.46 126.37,128 125.74,128 125.56,127.82 v1(125.56,126.54) 125.56,124.67 128.16,122.06 128.16,117.83 131.32,114.67 131.73,114.67 132.11,114.29 132.11,113.91 132.89,113.13 133.3,113.13 133.54,112.88 134.05,112.88
  BOTTOM w0.14: v1(135.4,109.4) 135.6,109.4 U22.G29 ; v1(128.79,132.23) 128.38,131.82 VRAM1.L12
WEA1B: length 27.3
  TOP w0.14: v1(153.57,132.22) 153.57,131.86 153.85,131.58 154.74,131.58 155.16,131.15 155.16,127.73 154.92,127.49 v1(154.92,126.68) 154.92,123.82 149.54,118.45 149.54,116.97 149.77,116.74 149.77,114.16 149.01,113.4 148.1,113.4 v1(146.5,111.8)
  BOTTOM w0.14: VRAM2.G12 153.95,131.84 v1(153.57,132.22) ; U22.D11 146.3,111.8 v1(146.5,111.8)
WEB0B: length 30
  TOP w0.102: 169.22,116.86 169.52,116.56 169.52,115.74 v1(169.92,115.34)
  TOP w0.14: v2(150,108.27) 150.22,108.27 152.3,110.35 152.68,110.35 152.94,110.61 155.37,110.61 156.95,112.19 156.95,115.37 160.63,119.04 v1(164.27,119.04) 167.74,119.04 168.44,118.34 168.44,117.64 169.22,116.86
  BOTTOM w0.14: v2(150,108.27) 149.55,107.82 U22.L4 ; v1(169.92,115.34) 169.52,115.74 VRAM3.L12
WEB1B: length 31
  TOP w0.102: v1(169.92,88.95) 169.92,88.76 169.44,88.28 169.44,87.67 168.6,86.83 168.32,86.83
  TOP w0.14: v2(147.6,97.2) 148.05,96.75 149.29,96.75 149.46,96.57 150.25,96.57 151.92,94.89 151.92,94.53 154.83,91.62 157.7,91.62 162.49,86.83 164.61,86.83 164.74,86.71 164.74,86.05 164.87,85.92 165.53,85.92 165.66,86.05 165.66,86.71 165.78,86.83 168.32,86.83
  BOTTOM w0.14: U22.AJ7 147.6,97.4 v2(147.6,97.2) ; v1(169.92,88.95) 169.52,88.55 VRAM4.G12
WLAN_ON/OFF#: length 265.7
  TOP w0.114: v1(233.77,23.73) 234.37,24.33 U34.98
  IN4 w0.089: v1(233.77,23.73) 234.81,23.73 235.67,22.87 235.67,19.77 235.39,19.49 234.79,19.49 234.13,18.83 234.13,14.79 232.91,13.57 226.28,13.57 222.4,9.69 220.75,9.69 217.61,6.55 189.46,6.55 184.96,11.05 180.18,11.05 173.17,18.06 155.91,18.06 155.42,17.57 141.47,17.57 140.88,16.98 123.69,16.98 123.31,17.36 121.84,17.36 120.44,15.97 118.51,15.97 118.34,15.79 111.96,15.79 110.59,17.16 110.31,17.16 110.13,17.35 108.66,17.35 108.12,17.89 98.87,17.89 98.51,17.52 76.89,17.52 75.97,16.6 52.17,16.6 50.01,14.44 32.4,14.44 31.12,13.16 27.81,13.16 27.47,12.83 26.17,12.83 23.91,10.56 22.9,10.56 22.42,11.05 22.42,14.83 20.74,16.51 18.88,16.51 18.61,16.78 12.26,16.78 10.49,15.01 10.49,15.01 10.23,14.75 10.23,14.75 7.71,14.75 7.05,14.09 v1(5.39,14.09)
  BOTTOM w0.114: v1(5.39,14.09) 5.39,14.12 3.08,16.43 CN10.56
WLAN_WAKE#_R: length 2.3
  TOP w0.114: R235.1 9.87,16.18 v1(10,16.32)
  BOTTOM w0.114: CN10.55 9.86,16.18 v1(10,16.32)
WRST#: length 9.9
  TOP w0.114: v1(222.29,16.79) 221.65,17.43 221.65,18.83 221.47,19.01 U34.14
  BOTTOM w0.114: v1(222.29,16.79) 222.29,16.93 R862.1 C1183.1 221.54,16.57 219.52,16.57 219.43,16.47 Q41.3 219.43,15.13 TP325.1
XTALIN: length 15.1
  BOTTOM w0.114: U22.BA39 130.4,90.22 130.14,89.96 130.14,86.54 129.6,86 129.6,85.04 130.07,84.57 v1(130.07,83.83) 130.07,83.17 129.62,82.73 128.46,82.73 127.91,82.19 127,82.19 126.88,82.31 124.21,82.31 124.15,82.38 R764.1
XTALOUT: length 5.1
  BOTTOM w0.102: 129.5,87.99 129.5,90.01 130.04,90.54 130.04,91.14 U22.AY39
  BOTTOM w0.114: 129.5,87.99 TP321.1
ZQ_A0: length 4.9
  BOTTOM w0.152: R776.2 123.64,134.85 124.77,134.85 125.76,133.86 127.11,133.86 VRAM1.J13
ZQ_A1: length 5.3
  TOP w0.114: R777.2 158.59,133.83 v1(158.92,133.51)
  BOTTOM w0.152: v1(158.92,133.51) 157.39,133.51 157.12,133.78 155.9,133.78 155.81,133.86 155.19,133.86 VRAM2.J13
ZQ_B0: length 6.4
  TOP w0.152: v1(172.79,117.9) 172.79,117.88 v1(173.67,118.76) 174.31,119.4 R778.2
  BOTTOM w0.152: v1(172.79,117.9) 172.31,118.38 171.78,118.38 171.48,118.08 171.48,116.9 VRAM3.J13
ZQ_B1: length 5
  BOTTOM w0.152: VRAM4.J13 171.11,87.68 171.55,87.23 171.55,86.81 171.63,86.73 171.63,86.19 173.04,84.78 R779.2
N2732626: length 13.9
  IN1 w0.508: v1(72.28,14.36) 69.4,14.36 v1(66.23,17.53)
  BOTTOM w0.178: PU15.21 71.14,14.28 71.22,14.36 71.53,14.36
  BOTTOM w0.508: 71.53,14.36 v1(72.28,14.36) v1(73.04,14.36) 73.81,13.59 PR199.1 PC224.1 PR192.2 ; PR191.1 v1(66.23,17.53)
N2734238: length 44.3
  BOTTOM w0.152: PR188.1 71.47,17.35 73.01,17.35 PC79.2 74.58,16.65 PC81.1 75.42,16.44 76.33,16.44 v1(76.6,16.71) 78.25,18.36 105.3,18.36 106.11,17.55 106.11,11.14 106.3,10.95 PR220.2P
