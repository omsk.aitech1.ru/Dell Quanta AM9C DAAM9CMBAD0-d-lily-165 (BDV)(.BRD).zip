# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Nets (continued)
DQB0_21: U22.W2(DQB0_21) VRAM3.U13(DQ17__DQ9)
DQB0_22: U22.Y1(DQB0_22) VRAM3.T11(DQ18__DQ10)
DQB0_23: U22.Y2(DQB0_23) VRAM3.U11(DQ16__DQ8)
DQB0_24: U22.AB2(DQB0_24) VRAM3.U4(DQ24__DQ0)
DQB0_25: U22.AC1(DQB0_25) VRAM3.T4(DQ26__DQ2)
DQB0_26: U22.AC2(DQB0_26) VRAM3.U2(DQ25__DQ1)
DQB0_27: U22.AD1(DQB0_27) VRAM3.T2(DQ27__DQ3)
DQB0_28: U22.AF1(DQB0_28) VRAM3.N4(DQ28__DQ4)
DQB0_29: U22.AF2(DQB0_29) VRAM3.N2(DQ29__DQ5)
DQB0_30: U22.AG1(DQB0_30) VRAM3.M2(DQ31__DQ7)
DQB0_31: U22.AG2(DQB0_31) VRAM3.M4(DQ30__DQ6)
DQB1_0: U22.AH1(DQB1_0) VRAM4.F4(DQ6__DQ30)
DQB1_1: U22.AH2(DQB1_1) VRAM4.F2(DQ7__DQ31)
DQB1_2: U22.AJ2(DQB1_2) VRAM4.E2(DQ5__DQ29)
DQB1_3: U22.AK1(DQB1_3) VRAM4.E4(DQ4__DQ28)
DQB1_4: U22.AL2(DQB1_4) VRAM4.B2(DQ3__DQ27)
DQB1_5: U22.AM1(DQB1_5) VRAM4.A2(DQ1__DQ25)
DQB1_6: U22.AM2(DQB1_6) VRAM4.B4(DQ2__DQ26)
DQB1_7: U22.AN2(DQB1_7) VRAM4.A4(DQ0__DQ24)
DQB1_8: U22.AR1(DQB1_8) VRAM4.A11(DQ8__DQ16)
DQB1_9: U22.AR2(DQB1_9) VRAM4.B11(DQ10__DQ18)
DQB1_10: U22.AT1(DQB1_10) VRAM4.A13(DQ9__DQ17)
DQB1_11: U22.AT2(DQB1_11) VRAM4.B13(DQ11__DQ19)
DQB1_12: U22.AV2(DQB1_12) VRAM4.E11(DQ12__DQ20)
DQB1_13: U22.AW1(DQB1_13) VRAM4.E13(DQ13__DQ21)
DQB1_14: U22.AW2(DQB1_14) VRAM4.F13(DQ15__DQ23)
DQB1_15: U22.AY3(DQB1_15) VRAM4.F11(DQ14__DQ22)
DQB1_16: U22.BA3(DQB1_16) VRAM4.N11(DQ20__DQ12)
DQB1_17: U22.AY4(DQB1_17) VRAM4.M11(DQ22__DQ14)
DQB1_18: U22.BA4(DQB1_18) VRAM4.M13(DQ23__DQ15)
DQB1_19: U22.AY5(DQB1_19) VRAM4.N13(DQ21__DQ13)
DQB1_20: U22.BA7(DQB1_20) VRAM4.U11(DQ16__DQ8)
DQB1_21: U22.AY7(DQB1_21) VRAM4.T11(DQ18__DQ10)
DQB1_22: U22.AY8(DQB1_22) VRAM4.U13(DQ17__DQ9)
DQB1_23: U22.BA8(DQB1_23) VRAM4.T13(DQ19__DQ11)
DQB1_24: U22.AR4(DQB1_24) VRAM4.U2(DQ25__DQ1)
DQB1_25: U22.AR5(DQB1_25) VRAM4.U4(DQ24__DQ0)
DQB1_26: U22.AU4(DQB1_26) VRAM4.T4(DQ26__DQ2)
DQB1_27: U22.AU7(DQB1_27) VRAM4.T2(DQ27__DQ3)
DQB1_28: U22.AN8(DQB1_28) VRAM4.M2(DQ31__DQ7)
DQB1_29: U22.AV11(DQB1_29) VRAM4.N4(DQ28__DQ4)
DQB1_30: U22.AU11(DQB1_30) VRAM4.M4(DQ30__DQ6)
DQB1_31: U22.AP11(DQB1_31) VRAM4.N2(DQ29__DQ5)
DRAM_A_RST: C968.1 R668.1 R669.1
DRAM_B_RST: C969.1 R671.1 R672.1
DRAM_RST_A: R668.2 VRAM1.J2(RESET$) VRAM2.J2(RESET$)
DRAM_RST_A_R: R669.2 R674.1 U22.L32(DRAM_RSTA)
DRAM_RST_B: R671.2 VRAM3.J2(RESET$) VRAM4.J2(RESET$)
DRAM_RST_B_R: R672.2 R675.1 U22.AM11(DRAM_RSTB)
EC_AVSS: C1210.1 L15.1 U34.75(AVSS)
EC_EXT_SCI#: D29.1(OUT) U34.23(ECSCI#/GPD3)
EC_EXT_SMI#: D28.1(OUT) U34.15(ECSMI#/GPD4(3))
EC_PWRBTN#: D42.2(IN) R536.1 U18.AE1(PWR_BTN_L/AGPIO0)
EC_PWROK: D23.1(OUT) Q17.2(G) Q36.5(G2) R263.2 U34.82(EGAD/GPE1)
EC_RCIN#: D30.2(IN) U18.AY15(ESPI_RESET_L/KBRST_L/AGPIO129)
EC_RTC_RST: Q37.2 R622.1 R964.2
EC_RTC_RST_R: R963.2 R964.1 U34.128(CK32K/GPJ6(3))
EC_SPI_CS#: TP292.1 U33.1(CS#) U34.101(FSCE#)
EC_SPI_DIN: TP290.1 U33.5(SPI_SI) U34.102(FMOSI)
EC_SPI_DO: TP291.1 U33.2(SPI_SO) U34.103(FMISO)
EC_SPI_HOLD#: R878.2 TP300.1 U33.7(\\S\P\I\_\H\O\L\D)
EC_SPI_SCK: C1188.1 TP293.1 U33.6(SPI_SCK) U34.105(FSCK)
EC_SPI_WP#: R876.2 TP301.1 U33.3(WP#)
EC_WLAN_RST#: R1111.2 U34.104(FDIO3/DSR0#/GPG6)
EDCA0_0: U22.G38(EDCA0_0) VRAM1.C2(EDC0__EDC3)
EDCA0_1: U22.F41(EDCA0_1) VRAM1.C13(EDC1__EDC2)
EDCA0_2: U22.B37(EDCA0_2) VRAM1.R13(EDC2__EDC1)
EDCA0_3: U22.A31(EDCA0_3) VRAM1.R2(EDC3__EDC0)
EDCA1_0: U22.B24(EDCA1_0) VRAM2.C2(EDC0__EDC3)
EDCA1_1: U22.A18(EDCA1_1) VRAM2.C13(EDC1__EDC2)
EDCA1_2: U22.B12(EDCA1_2) VRAM2.R2(EDC3__EDC0)
EDCA1_3: U22.B6(EDCA1_3) VRAM2.R13(EDC2__EDC1)
EDCB0_0: U22.F2(EDCB0_0) VRAM3.C13(EDC1__EDC2)
EDCB0_1: U22.M2(EDCB0_1) VRAM3.C2(EDC0__EDC3)
EDCB0_2: U22.V1(EDCB0_2) VRAM3.R13(EDC2__EDC1)
EDCB0_3: U22.AD2(EDCB0_3) VRAM3.R2(EDC3__EDC0)
EDCB1_0: U22.AL1(EDCB1_0) VRAM4.C2(EDC0__EDC3)
EDCB1_1: U22.AU2(EDCB1_1) VRAM4.C13(EDC1__EDC2)
EDCB1_2: U22.BA6(EDCB1_2) VRAM4.R13(EDC2__EDC1)
EDCB1_3: U22.AV7(EDCB1_3) VRAM4.R2(EDC3__EDC0)
EDP_AUXN: C676.2 U18.E8(DP0_AUXN)
EDP_AUXN_C: C676.1 CN9.16
EDP_AUXP: C675.2 U18.F8(DP0_AUXP)
EDP_AUXP_C: C675.1 CN9.15
EDP_HPD: CN9.14 R398.1 U18.G8(DP0_HPD)
EDP_TXN0: C667.2 U18.E1(DP0_TXN0)
EDP_TXN0_C: C667.1 R377.1
EDP_TXN0_R: CN9.19 R377.2
EDP_TXN1: C669.2 U18.E4(DP0_TXN1)
EDP_TXN1_C: C669.1 R379.1
EDP_TXN1_R: CN9.22 R379.2
EDP_TXP0: C666.2 U18.E2(DP0_TXP0)
EDP_TXP0_C: C666.1 R376.1
EDP_TXP0_R: CN9.18 R376.2
EDP_TXP1: C668.2 U18.E3(DP0_TXP1)
EDP_TXP1_C: C668.1 R378.1
EDP_TXP1_R: CN9.21 R378.2
EGPIO119: R578.1 U18.AW7(SPI_CS2_L/ESPI_CS_L/EGPIO119)
EN_LCDVCC: D3.3(OUT) R112.1 U206.4(EN)
FAN1_PWM: FAN1.1 U34.28(PWM2/GPA2)
FAN1_TACH: FAN1.2 R55.1 U34.47(TACH0A/GPD6(3))
FAN2_PWM: FAN2.1 U34.25(PWM1/GPA1)
FAN2_TACH: FAN2.2 R75.1 U34.48(TACH1A/TMA1/GPD7(3))
FB_VMEMIO: TP180.1 U22.C3(FB_VMEMIO)
FCH_PC: PC9300.1 PQ65.1 PR458.1 PR460.2 PR462.2 PU30.2(MINUS INPUT) PU30.5(PLUS INPUT)
FPVCC: R720.2 U22.AC40(DIGON)
G9336_DRV: PQ54.3(G) PR369.2 PU20.6(DRV)
G_WAKEB: R711.1 U22.AU40(WAKEB)
GFX_PWRGD: PR509.2 PU17.20(PGOOD) R1076.2
GFX_SVC: PR309.1 R494.2 R501.1 R506.2
GFX_SVC_R: R494.1 U18.B16(SVC1)
GFX_SVD: PR314.1 R495.2 R502.1 R507.2
GFX_SVD_R: R495.1 U18.A18(SVD1)
GFX_SVT: PR316.1 R500.1 U18.B15(SVT1)
GPIO0: TP263.1 U28.17(GPIO0)
GPIO_0: R681.2 R683.1 U22.W40(GPIO_0)
GPIO_1: R922.2 R923.1 U22.AA40(GPIO_1)
GPIO_2: R924.2 R925.1 U22.AA35(GPIO_2)
GPIO_7_BLON: R719.2 U22.AC37(BL_ENABLE)
GPIO_8_ROMSO: R926.2 R927.1 R1086.1 TP289.1 U22.AP25(GPIO_8_ROMSO)
GPIO_9_ROMSI: R1085.1 TP288.1 U22.AM25(GPIO_9_ROMSI)
GPIO_10_ROMSCK: R1084.1 TP287.1 U22.AM27(GPIO_10_ROMSCK)
GPIO_11: R928.2 R929.1 U22.W41(GPIO_11)
GPIO_12: R930.2 R931.1 U22.Y40(GPIO_12)
GPIO_13: R932.2 R933.1 U22.Y41(GPIO_13)
GPIO_15: TP312.1 U22.AA41(GPIO_15)
GPIO_20: R934.1 R935.2 U22.AB40(GPIO_20)
GPIO_21_PCC: TP304.1 U22.AB41(GPIO_21)
GPIO_22_ROMCSB: R936.1 R937.2 R1083.1 TP286.1 U22.AP27(GPIO_22_ROMCSB)
GPIO_29: R938.1 R939.2 U22.W37(GPIO_29)
GPIO_30: TP311.1 U22.W38(GPIO_30)
GPIO_SVC: R697.2 U22.AU17(GPIO_SVC)
GPIO_SVD: R698.2 U22.AV17(GPIO_SVD)
GPIO_SVT: R699.2 U22.AR17(GPIO_SVT)
GPU_DMINUS: TP281.1 U22.N34(DMINUS)
GPU_DPLUS: TP280.1 U22.N35(DPLUS)
GPU_FB_VDDC: PR442.2 U22.AR13(FB_VDDC)
GPU_FB_VDDCI: PR391.2 U22.AV13(FB_VDDCI)
GPU_FB_VSS: PR445.2 U22.AU13(FB_VSS)
GPU_SVC: PR406.2 R697.1 R747.1 R749.2
GPU_SVD: PR410.2 R698.1 R748.1 R750.2
GPU_SVT: PR413.2 R699.1
GPU_VR_HOT: C9378.1 Q64.2(G) U34.96(HSCE#/GPH3/ID3)
GPU_VR_HOT#_IC: C9377.1 Q64.3(D) R1091.1 R1095.2 R1096.2 U22.U35(GPIO_6_TACH)
H_PROCHOT_EC: Q42.2 R872.2 U34.86(PS2DAT0/TMB1/GPF1)
HDA_BITCLK: EC90.2 R234.1 R561.1
HDA_BITCLK_R: CN5.19 EC28.2 R234.2
HDA_RST#: CN5.23 R563.1
HDA_SDIN0: CN5.21 R535.1 U18.AR8(AZ_SDIN0/I2S_DATA_MIC0)
HDA_SDOUT: CN5.20 R558.1
HDA_SYNC: CN5.22 R559.1
HDD_LED_EN#: Q16.2(G) U34.87(PS2CLK1/DTR0#/GPF2)
HDMI_CFG: R345.1 U5.23(CFG/I2C_ADDR1)
HDMI_CLK+: C424.2 U5.9(IN_CKP)
HDMI_CLK+_C: CN7.10(CK+) R336.1 R337.2
HDMI_CLK+_R: R336.2 U5.22(OUT_CKP)
HDMI_CLK-: C425.2 U5.10(IN_CKN)
HDMI_CLK-_C: CN7.12(CK-) R337.1 R340.1
HDMI_CLK-_R: R340.2 U5.21(OUT_CKN)
HDMI_DCIN_EN: R97.1 U5.13(DCIN_EN/SCL_CTL)
HDMI_DDCBUF: R348.1 R349.1 U5.14(DDCBUF/SDA_CTL)
HDMI_EQ: R346.1 R347.1 U5.17(EQ/I2C_ADDR0)
HDMI_HP: CN7.19(HPD) U5.28(HPD_SNK)
HDMI_ISET: R92.1 R94.1 U5.34(ISET)
HDMI_PRE: R95.1 R96.1 U5.16(PRE)
HDMI_SCL: U5.38(SCL_SRC) U18.F7(DP1_AUXP)
HDMI_SCL_SNK: CN7.15(SCL) R84.2 U5.32(SCL_SNK)
HDMI_SDA: U5.39(SDA_SRC) U18.E7(DP1_AUXN)
HDMI_SDA_SNK: CN7.16(SDA) R83.2 U5.33(SDA_SNK)
HDMI_TX0+: C422.2 U5.6(IN_D0P)
HDMI_TX0+_C: CN7.7(D0+) R341.1 R342.2
HDMI_TX0+_R: R341.2 U5.25(OUT_D0P)
HDMI_TX0-: C423.2 U5.7(IN_D0N)
HDMI_TX0-_C: CN7.9(D0-) R342.1 R344.1
HDMI_TX0-_R: R344.2 U5.24(OUT_D0N)
HDMI_TX1+: C420.2 U5.4(IN_D1P)
HDMI_TX1+_C: CN7.4(D1+) R329.1 R330.2
HDMI_TX1+_R: R329.2 U5.27(OUT_D1P)
HDMI_TX1-: C421.2 U5.5(IN_D1N)
HDMI_TX1-_C: CN7.6(D1-) R330.1 R333.1
HDMI_TX1-_R: R333.2 U5.26(OUT_D1N)
HDMI_TX2+: C418.2 U5.1(IN_D2P)
HDMI_TX2+_C: CN7.1(D2+) R320.1 R324.2
HDMI_TX2+_R: R320.2 U5.30(OUT_D2P)
HDMI_TX2-: C419.2 U5.2(IN_D2N)
HDMI_TX2-_C: CN7.3(D2-) R324.1 R325.1
HDMI_TX2-_R: R325.2 U5.29(OUT_D2N)
HDT_APU_TDI: CN13.6(CPU_TDI) R511.2
HDT_DBREQ#: CN13.16(CPU_DBREQ_L) R519.2
HDT_TRST#: CN13.9(CPU_TRST_L) R513.1
HSYNC: R940.1 R941.2 U22.W34(HSYNC)
HVBEN_L: R541.1 U18.BB14(GENINT1_L/AGPIO89)
HWPG: D21.1(OUT) R433.1 U34.109(TXD/SOUT0/GPB1)
I2C_SCL1: R547.1 R556.1 U18.BB7(I2C1_SCL/EGPIO147)
I2C_SCL_TP: Q9.4(S1) R159.2 R554.1 R1009.1 U18.BB10(I2C0_SCL/EGPIO145)
I2C_SDA1: R548.1 R557.1 U18.BC7(I2C1_SDA/EGPIO148)
I2C_SDA_TP: Q9.1(S2) R163.2 R555.1 R1008.1 U18.BB9(I2C0_SDA/EGPIO146)
IINP: PC238.1 PU15.7(IADP) U34.72(ADC6/DSR1#/GPI6(3))
ILIM_HI: R133.2 U7.16(ILIM_HI)
ILIM_LO: R128.2 U7.15(ILIM_LO)
IMON: PC9123.2 PR283.2 PU16.10(IMON)
IMON_CI_GPU: PC9265.2 PR426.2 PU24.2(IMON_NB)
IMON_GFX: PC9156.2 PR328.2 PU17.10(IMON)
IMON_GPU: PC9266.2 PR427.2 PU24.10(IMON)
IMON_NB: PC9122.2 PR282.2 PU16.2(IMON_NB)
IMON_NB_GFX: PR327.1 PU17.2(IMON_NB)
IMVP_PWRGD: R1046.1 U34.79(DAC3/TACH1B/GPJ3(3))
INT_HDMI_HPD: U5.3(HPD_SRC) U18.F5(DP1_HPD)
INT_HDMI_TXCN: C425.1 U18.B5(DP1_TXN3)
INT_HDMI_TXCP: C424.1 U18.A5(DP1_TXP3)
INT_HDMI_TXN0: C423.1 U18.C5(DP1_TXN2)
INT_HDMI_TXN1: C421.1 U18.A4(DP1_TXN1)
INT_HDMI_TXN2: C419.1 U18.A3(DP1_TXN0)
INT_HDMI_TXP0: C422.1 U18.D5(DP1_TXP2)
INT_HDMI_TXP1: C420.1 U18.B4(DP1_TXP1)
INT_HDMI_TXP2: C418.1 U18.A2(DP1_TXP0)
ISEN1: PC9126.1 PR303.2 PU16.13(ISEN1)
ISEN1_GFX: PC9163.1 PR344.2 PU17.13(ISEN1)
ISEN1_GPU: PC9273.1 PR441.2 PU24.13(ISEN1)
ISEN2: PC9124.2 PR284.2 PU16.12(ISEN2)
ISEN2_GFX: PC9157.2 PR319.2 PU17.12(ISEN2)
ISEN2_GPU: PC9268.2 PR418.2 PU24.12(ISEN2)
ISUMN: PR298.1 PU16.15(ISUMN)
ISUMN_CI: PR403.1 PU24.39(ISUMN_NB)
ISUMN_GFX: PR343.1 PU17.15(ISUMN)
ISUMN_GPU: PR443.1 PU24.15(ISUMN)
ISUMN_NB: PR259.1 PU16.39(ISUMN_NB)
JTAG_TCK: TP273.1 U22.AE41(JTAG_TCK)
JTAG_TDI: TP271.1 U22.AD40(JTAG_TDI)
JTAG_TDO: TP270.1 U22.AF41(JTAG_TDO)
JTAG_TESTEN: R645.1 R649.2 TP274.1 U22.AE40(TESTEN)
JTAG_TMS: TP272.1 U22.AD41(JTAG_TMS)
JTAG_TRSTB: R647.2 R650.2 TP275.1 U22.AF40(JTAG_TRSTB)
KB_BACKLITE_EN: Q11.2 U34.30(PWM4/GPA4)
KB_DET#: CN2.30 R994.2 U18.AU12(AGPIO68/SGPIO_CLK)
KB_LED_DET: R178.1 R179.1 R526.2 U18.AT14(AGPIO69/SGPIO_LOAD)
KB_LED_DET_R: J1.2 R179.2
LAD0: R242.2 R1102.1 U18.BB11(LAD0)
LAD0_EC: R1102.2 U34.10(LAD0/GPM0(3))
LAD0_R: CN10.64(RSVD#64) R242.1
LAD1: R236.2 R1103.1 U18.BA11(LAD1)
LAD1_EC: R1103.2 U34.9(LAD1/GPM1(3))
LAD1_R: CN10.66(UIM_SWP) R236.1
LAD2: R233.2 R1104.1 U18.AY11(LAD2)
LAD2_EC: R1104.2 U34.8(LAD2/GPM2(3))
LAD2_R: CN10.68(UIM_POWER_SNK) R233.1
LAD3: R232.2 R1105.1 U18.BA13(LAD3)
LAD3_EC: R1105.2 U34.7(LAD3/GPM3(3))
LAD3_R: CN10.70(UIM_POWER_SRC) R232.1
LAN_ISOLAT#: R73.1 R1003.1 U2.20(ISOLATEB)
LAN_LED0: TP15.1 U2.27(LED0)
LAN_LED1: TP78.1 U2.26(LED1/GPO)
LAN_LED2: TP79.1 U2.25(LED2(LED1))
LAN_MCTG: C593.2 R43.2 R45.2 R53.2 R54.2
LAN_MCTG0: R43.1 U12.15(MCT4)
LAN_MCTG1: R45.1 U12.16(MCT3)
LAN_MCTG2: R53.1 U12.21(MCT2)
LAN_MCTG3: R54.1 U12.22(MCT1)
LAN_MX0+: CN6.1(TX0+) U12.14(MX4+)
LAN_MX0-: CN6.2(TX0-) U12.13(MX4-)
LAN_MX1+: CN6.3(RX0+) U12.18(MX3+)
LAN_MX1-: CN6.6(RX0-) U12.17(MX3-)
LAN_MX2+: CN6.4(TX1+) U12.20(MX2+)
LAN_MX2-: CN6.5(TX1-) U12.19(MX2-)
LAN_MX3+: CN6.7(RX1+) U12.24(MX1+)
LAN_MX3-: CN6.8(RX1-) U12.23(MX1-)
LAN_PWR_EN_EC: C648.1 U34.20(L80LLAT/GPE7) U207.4(EN)
LAN_XTALI: C347.1 U2.28(CKXTAL1) Y1.3(NC)
LAN_XTALO: C345.1 U2.29(CKXTAL2) Y1.1
LATCH: C716.1 D15.2(INB) D16.2(INB) Q30.3(D) Q31.5(G) Q31.6(D) R443.1
LCD_BAK: D4.2(INB) R899.2 U34.35(RTS1#/GPE5)
LCD_BAK_R: CN9.31 D4.3(OUT) R117.1 R899.1
LCD_PWM_EC: D5.2(INB) U34.29(PWM3/GPA3)
LCD_PWM_IN: CN9.30 D5.3(OUT) R110.1
LCD_TST: CN9.13 D3.2(INB) U34.85(PS2CLK0/TMB0/CEC/GPF0)
LDRQ#0: TP146.1 U18.BA1(ESPI_ALERT_L/LDRQ0_L)
LED_BL_ON: C485.2 Q7.2(G) R122.1 R135.2
LED_PWM#: J1.4 Q11.3
LFRAME#: R231.1 R594.2 R604.1 R1106.1 U18.AV14(LFRAME_L)
LFRAME#_EC: R1106.2 U34.6(LFRAME#/GPM5(3))
LGATE_1: PQ47.8(G2) PU16.24(LGATE1)
LGATE_2: PQ46.8(G2) PU16.27(LGATE2)
LGATE_CI: PQ58.4(B) PU24.34(LGATE_NB)
LGATE_GFX1: PQ49.8(G2) PU17.24(LGATE1)
LGATE_GFX2: PQ48.8(G2) PU17.27(LGATE2)
LGATE_GPU1: PQ61.8(G2) PQ62.8(G2) PU24.24(LGATE1)
LGATE_GPU2: PQ59.8(G2) PQ60.8(G2) PU24.27(LGATE2)
LGATE_NB: PQ45.8(G2) PU16.34(LGATE_NB)
LID_SW#: EC165.2 J3.5 R966.1 U34.88(PS2DAT1/RTS0#/GPF3)
LLB#: R552.1 U18.AE2(IR_LED_L/LLB_L/AGPIO12)
LPC_CLK0: R589.2 R592.2 R602.1 U18.AW14(LPCCLK0/EGPIO74)
LPC_CLK1: R590.2 R593.2 R603.1 U18.AY13(LPCCLK1/EGPIO75)
LPC_LFRAME#_R: CN10.73(NC#73) R231.2
LPC_PD#: R591.1 U18.AE9(LPC_PD_L/AGPIO21)
LPC_RST#: C757.2 R521.2 R1072.1 U34.22(LPCRST#/GPD2)
LPC_RST#_R: R521.1 U18.BB12(LPC_RST_L)
M_A0_CS#0: CN16.149(S0#) U18.AH26(MA0_CS_L0)
M_A0_CS#1: CN16.157(S1#) U18.AL29(MA0_CS_L1)
M_A_A0: CN16.144(A0) U18.AE28(MA_ADD0)
M_A_A1: CN16.133(A1) U18.Y27(MA_ADD1)
M_A_A2: CN16.132(A2) U18.Y29(MA_ADD2)
M_A_A3: CN16.131(A3) U18.Y26(MA_ADD3)
M_A_A4: CN16.128(A4) U18.W28(MA_ADD4)
M_A_A5: CN16.126(A5) U18.W29(MA_ADD5)
M_A_A6: CN16.127(A6) U18.W26(MA_ADD6)
M_A_A7: CN16.122(A7) U18.U29(MA_ADD7)
M_A_A8: CN16.125(A8) U18.W25(MA_ADD8)
M_A_A9: CN16.121(A9) U18.U26(MA_ADD9)
M_A_A10: CN16.146(A10/AP) U18.AG29(MA_ADD10)
M_A_A11: CN16.120(A11) U18.U27(MA_ADD11)
M_A_A12: CN16.119(A12) U18.T28(MA_ADD12)
M_A_A13: CN16.158(A13) U18.AK26(MA_ADD13)
M_A_ALERT#: CN16.116(ALERT#) R627.1
M_A_BS#0: CN16.150(BA0) U18.AG26(MA_BANK0)
M_A_BS#1: CN16.145(BA1) U18.AG27(MA_BANK1)
M_A_CAS#: CN16.156(A15/CAS#) U18.AK29(MA_CAS_L/MA_CAS_L_ADD15)
M_A_CKE0: CN16.109(CKE0) U18.P27(MA_CKE0)
M_A_CKE1: CN16.110(CKE1) U18.P29(MA_CKE1)
M_A_CLK0: CN16.137(CK0) U18.AE25(MA_CLK_H0)
M_A_CLK0#: CN16.139(CK0#) U18.AE26(MA_CLK_L0)
M_A_CLK1: CN16.138(CK1) U18.AD26(MA_CLK_H1)
M_A_CLK1#: CN16.140(CK1#) U18.AD27(MA_CLK_L1)
M_A_CLK2: TP104.1 U18.AB28(MA_CLK_H2)
M_A_CLK3: TP105.1 U18.AB25(MA_CLK_H3)
M_A_DM0: CN16.12(DM0) U18.E19(MA_DM0)
M_A_DM1: CN16.33(DM1) U18.D21(MA_DM1)
M_A_DM2: CN16.54(DM2) U18.K21(MA_DM2)
M_A_DM3: CN16.75(DM3) U18.F29(MA_DM3)
M_A_DM4: CN16.178(DM4) U18.AP28(MA_DM4)
M_A_DM5: CN16.199(DM5) U18.AV26(MA_DM5)
M_A_DM6: CN16.220(DM6) U18.AR22(MA_DM6)
M_A_DM7: CN16.241(DM7) U18.BC22(MA_DM7)
M_A_DQ0: CN16.8(DQ0) U18.H17(MA_DATA0)
M_A_DQ1: CN16.4(DQ4) U18.J17(MA_DATA1)
M_A_DQ2: CN16.20(DQ2) U18.F20(MA_DATA2)
M_A_DQ3: CN16.21(DQ3) U18.H20(MA_DATA3)
M_A_DQ4: CN16.3(DQ5) U18.E17(MA_DATA4)
M_A_DQ5: CN16.7(DQ1) U18.F17(MA_DATA5)
M_A_DQ6: CN16.17(DQ7) U18.K18(MA_DATA6)
M_A_DQ7: CN16.16(DQ6) U18.E20(MA_DATA7)
M_A_DQ8: CN16.25(DQ13) U18.A21(MA_DATA8)
M_A_DQ9: CN16.29(DQ9) U18.C21(MA_DATA9)
M_A_DQ10: CN16.41(DQ10) U18.C23(MA_DATA10)
M_A_DQ11: CN16.37(DQ15) U18.D23(MA_DATA11)
M_A_DQ12: CN16.24(DQ12) U18.B20(MA_DATA12)
M_A_DQ13: CN16.28(DQ8) U18.B21(MA_DATA13)
M_A_DQ14: CN16.38(DQ14) U18.B23(MA_DATA14)
M_A_DQ15: CN16.42(DQ11) U18.A23(MA_DATA15)
M_A_DQ16: CN16.50(DQ16) U18.G22(MA_DATA16)
M_A_DQ17: CN16.49(DQ17) U18.H22(MA_DATA17)
M_A_DQ18: CN16.59(DQ23) U18.E25(MA_DATA18)
M_A_DQ19: CN16.63(DQ19) U18.G25(MA_DATA19)
M_A_DQ20: CN16.46(DQ20) U18.J20(MA_DATA20)
M_A_DQ21: CN16.45(DQ21) U18.E22(MA_DATA21)
M_A_DQ22: CN16.58(DQ22) U18.H23(MA_DATA22)
M_A_DQ23: CN16.62(DQ18) U18.J23(MA_DATA23)
M_A_DQ24: CN16.66(DQ28) U18.F26(MA_DATA24)
M_A_DQ25: CN16.67(DQ29) U18.E27(MA_DATA25)
M_A_DQ26: CN16.79(DQ30) U18.J26(MA_DATA26)
M_A_DQ27: CN16.84(DQ27) U18.J27(MA_DATA27)
M_A_DQ28: CN16.71(DQ25) U18.H25(MA_DATA28)
M_A_DQ29: CN16.70(DQ24) U18.E26(MA_DATA29)
M_A_DQ30: CN16.80(DQ31) U18.G28(MA_DATA30)
M_A_DQ31: CN16.83(DQ26) U18.G29(MA_DATA31)
M_A_DQ32: CN16.173(DQ33) U18.AN26(MA_DATA32)
M_A_DQ33: CN16.169(DQ37) U18.AP29(MA_DATA33)
M_A_DQ34: CN16.183(DQ38) U18.AR26(MA_DATA34)
M_A_DQ35: CN16.187(DQ34) U18.AP24(MA_DATA35)
M_A_DQ36: CN16.174(DQ32) U18.AN29(MA_DATA36)
M_A_DQ37: CN16.170(DQ36) U18.AN27(MA_DATA37)
M_A_DQ38: CN16.186(DQ35) U18.AR29(MA_DATA38)
M_A_DQ39: CN16.182(DQ39) U18.AR27(MA_DATA39)
M_A_DQ40: CN16.195(DQ40) U18.AU26(MA_DATA40)
M_A_DQ41: CN16.191(DQ44) U18.AV29(MA_DATA41)
M_A_DQ42: CN16.204(DQ47) U18.AU25(MA_DATA42)
M_A_DQ43: CN16.208(DQ43) U18.AW25(MA_DATA43)
M_A_DQ44: CN16.194(DQ41) U18.AU29(MA_DATA44)
M_A_DQ45: CN16.190(DQ45) U18.AU28(MA_DATA45)
M_A_DQ46: CN16.203(DQ46) U18.AW26(MA_DATA46)
M_A_DQ47: CN16.207(DQ42) U18.AT25(MA_DATA47)
M_A_DQ48: CN16.212(DQ53) U18.AV23(MA_DATA48)
M_A_DQ49: CN16.216(DQ48) U18.AW23(MA_DATA49)
M_A_DQ50: CN16.224(DQ54) U18.AV20(MA_DATA50)
M_A_DQ51: CN16.229(DQ51) U18.AW20(MA_DATA51)
M_A_DQ52: CN16.211(DQ52) U18.AR23(MA_DATA52)
M_A_DQ53: CN16.215(DQ49) U18.AT23(MA_DATA53)
M_A_DQ54: CN16.228(DQ50) U18.AR20(MA_DATA54)
M_A_DQ55: CN16.225(DQ55) U18.AT20(MA_DATA55)
M_A_DQ56: CN16.237(DQ56) U18.BB23(MA_DATA56)
M_A_DQ57: CN16.233(DQ61) U18.BB22(MA_DATA57)
M_A_DQ58: CN16.250(DQ59) U18.BB20(MA_DATA58)
M_A_DQ59: CN16.246(DQ63) U18.AY19(MA_DATA59)
M_A_DQ60: CN16.236(DQ57) U18.BA23(MA_DATA60)
M_A_DQ61: CN16.232(DQ60) U18.BC23(MA_DATA61)
M_A_DQ62: CN16.249(DQ58) U18.BC21(MA_DATA62)
M_A_DQ63: CN16.245(DQ62) U18.BB21(MA_DATA63)
M_A_DQS0: CN16.13(DQS0) U18.H19(MA_DQS_H0)
M_A_DQS1: CN16.34(DQS1) U18.B22(MA_DQS_H1)
M_A_DQS2: CN16.55(DQS2) U18.F23(MA_DQS_H2)
M_A_DQS3: CN16.76(DQS3) U18.G27(MA_DQS_H3)
M_A_DQS4: CN16.179(DQS4) U18.AP25(MA_DQS_H4)
M_A_DQS5: CN16.200(DQS5) U18.AW27(MA_DQS_H5)
M_A_DQS6: CN16.221(DQS6) U18.AV22(MA_DQS_H6)
M_A_DQS7: CN16.242(DQS7) U18.BA21(MA_DQS_H7)
M_A_DQS#0: CN16.11(DQS#0) U18.G19(MA_DQS_L0)
M_A_DQS#1: CN16.32(DQS#1) U18.A22(MA_DQS_L1)
M_A_DQS#2: CN16.53(DQS#2) U18.E23(MA_DQS_L2)
M_A_DQS#3: CN16.74(DQS#3) U18.F27(MA_DQS_L3)
M_A_DQS#4: CN16.177(DQS#4) U18.AP26(MA_DQS_L4)
M_A_DQS#5: CN16.198(DQS#5) U18.AV27(MA_DQS_L5)
M_A_DQS#6: CN16.219(DQS#6) U18.AU22(MA_DQS_L6)
M_A_DQS#7: CN16.240(DQS#7) U18.AY21(MA_DQS_L7)
M_A_EVENT#: CN16.134(EVENT#) R629.2 U18.AE29(MA_EVENT_L)
M_A_ODT0: CN16.155(ODT0) U18.AK27(MA0_ODT0)
M_A_ODT1: CN16.161(ODT1) U18.AL26(MA0_ODT1)
M_A_PARITY: CN16.143(PARITY) R628.1
M_A_RAS#: CN16.152(A16/RAS#) U18.AG24(MA_RAS_L/MA_RAS_L_ADD16)
M_A_RESET#: CN16.108(RESET#) U18.N29(MA_RESET_L)
M_A_WE#: CN16.151(A14/WE#) U18.AH28(MA_WE_L/MA_WE_L_ADD14)
M_B0_CS#0: CN17.149(S0#) U18.AJ33(MB0_CS_L0)
M_B0_CS#1: CN17.157(S1#) U18.AL32(MB0_CS_L1)
M_B0_ODT0: CN17.155(ODT0) U18.AL30(MB0_ODT0)
M_B0_ODT1: CN17.161(ODT1) U18.AM32(MB0_ODT1)
M_B_A0: CN17.144(A0) U18.AG31(MB_ADD0)
M_B_A1: CN17.133(A1) U18.AC30(MB_ADD1)
M_B_A2: CN17.132(A2) U18.AC31(MB_ADD2)
M_B_A3: CN17.131(A3) U18.AB32(MB_ADD3)
M_B_A4: CN17.128(A4) U18.AA32(MB_ADD4)
M_B_A5: CN17.126(A5) U18.AA33(MB_ADD5)
M_B_A6: CN17.127(A6) U18.AA31(MB_ADD6)
M_B_A7: CN17.122(A7) U18.Y33(MB_ADD7)
M_B_A8: CN17.125(A8) U18.AA30(MB_ADD8)
M_B_A9: CN17.121(A9) U18.W32(MB_ADD9)
M_B_A10: CN17.146(A10/AP) U18.AG32(MB_ADD10)
M_B_A11: CN17.120(A11) U18.Y32(MB_ADD11)
M_B_A12: CN17.119(A12) U18.W33(MB_ADD12)
M_B_A13: CN17.158(A13) U18.AL31(MB_ADD13)
M_B_ALERT#: CN17.116(ALERT#) R634.1
M_B_BS#0: CN17.150(BA0) U18.AH32(MB_BANK0)
M_B_BS#1: CN17.145(BA1) U18.AG33(MB_BANK1)
M_B_CAS#: CN17.156(A15/CAS#) U18.AK32(MB_CAS_L/MB_CAS_L_ADD15)
M_B_CKE0: CN17.109(CKE0) U18.U32(MB_CKE0)
M_B_CKE1: CN17.110(CKE1) U18.U33(MB_CKE1)
M_B_CLK0: CN17.137(CK0) U18.AE33(MB_CLK_H0)
M_B_CLK0#: CN17.139(CK0#) U18.AE32(MB_CLK_L0)
M_B_CLK1: CN17.138(CK1) U18.AE30(MB_CLK_H1)
M_B_CLK1#: CN17.140(CK1#) U18.AE31(MB_CLK_L1)
M_B_DM0: CN17.12(DM0) U18.D25(MB_DM0)
M_B_DM1: CN17.33(DM1) U18.D29(MB_DM1)
M_B_DM2: CN17.54(DM2) U18.E33(MB_DM2)
M_B_DM3: CN17.75(DM3) U18.J33(MB_DM3)
M_B_DM4: CN17.178(DM4) U18.AR30(MB_DM4)
M_B_DM5: CN17.199(DM5) U18.AW30(MB_DM5)
M_B_DM6: CN17.220(DM6) U18.BC30(MB_DM6)
M_B_DM7: CN17.241(DM7) U18.BC26(MB_DM7)
M_B_DQ0: CN17.3(DQ5) U18.A25(MB_DATA0)
M_B_DQ1: CN17.8(DQ0) U18.C25(MB_DATA1)
M_B_DQ2: CN17.17(DQ7) U18.C27(MB_DATA2)
M_B_DQ3: CN17.21(DQ3) U18.D27(MB_DATA3)
M_B_DQ4: CN17.4(DQ4) U18.B24(MB_DATA4)
M_B_DQ5: CN17.7(DQ1) U18.B25(MB_DATA5)
M_B_DQ6: CN17.16(DQ6) U18.B27(MB_DATA6)
M_B_DQ7: CN17.20(DQ2) U18.A27(MB_DATA7)
M_B_DQ8: CN17.25(DQ13) U18.A29(MB_DATA8)
M_B_DQ9: CN17.29(DQ9) U18.C29(MB_DATA9)
M_B_DQ10: CN17.42(DQ11) U18.B32(MB_DATA10)
M_B_DQ11: CN17.38(DQ14) U18.D32(MB_DATA11)
M_B_DQ12: CN17.28(DQ8) U18.B28(MB_DATA12)
M_B_DQ13: CN17.24(DQ12) U18.B29(MB_DATA13)
M_B_DQ14: CN17.37(DQ15) U18.A31(MB_DATA14)
M_B_DQ15: CN17.41(DQ10) U18.C31(MB_DATA15)
M_B_DQ16: CN17.46(DQ20) U18.E30(MB_DATA16)
M_B_DQ17: CN17.50(DQ16) U18.E31(MB_DATA17)
M_B_DQ18: CN17.59(DQ23) U18.G33(MB_DATA18)
M_B_DQ19: CN17.63(DQ19) U18.G32(MB_DATA19)
M_B_DQ20: CN17.45(DQ21) U18.C33(MB_DATA20)
M_B_DQ21: CN17.49(DQ17) U18.D33(MB_DATA21)
M_B_DQ22: CN17.62(DQ18) U18.G30(MB_DATA22)
M_B_DQ23: CN17.58(DQ22) U18.G31(MB_DATA23)
M_B_DQ24: CN17.71(DQ25) U18.J30(MB_DATA24)
M_B_DQ25: CN17.70(DQ24) U18.J31(MB_DATA25)
M_B_DQ26: CN17.79(DQ30) U18.L33(MB_DATA26)
M_B_DQ27: CN17.83(DQ26) U18.L32(MB_DATA27)
M_B_DQ28: CN17.66(DQ28) U18.H32(MB_DATA28)
M_B_DQ29: CN17.67(DQ29) U18.H33(MB_DATA29)
M_B_DQ30: CN17.80(DQ31) U18.L30(MB_DATA30)
M_B_DQ31: CN17.84(DQ27) U18.L31(MB_DATA31)
M_B_DQ32: CN17.169(DQ37) U18.AN31(MB_DATA32)
M_B_DQ33: CN17.173(DQ33) U18.AP32(MB_DATA33)
M_B_DQ34: CN17.182(DQ39) U18.AT32(MB_DATA34)
M_B_DQ35: CN17.187(DQ34) U18.AU32(MB_DATA35)
M_B_DQ36: CN17.170(DQ36) U18.AN33(MB_DATA36)
M_B_DQ37: CN17.174(DQ32) U18.AN32(MB_DATA37)
M_B_DQ38: CN17.186(DQ35) U18.AR31(MB_DATA38)
M_B_DQ39: CN17.183(DQ38) U18.AT33(MB_DATA39)
M_B_DQ40: CN17.191(DQ44) U18.AU30(MB_DATA40)
M_B_DQ41: CN17.195(DQ40) U18.AV32(MB_DATA41)
M_B_DQ42: CN17.207(DQ42) U18.BA33(MB_DATA42)
M_B_DQ43: CN17.203(DQ46) U18.AY32(MB_DATA43)
M_B_DQ44: CN17.194(DQ41) U18.AU33(MB_DATA44)
M_B_DQ45: CN17.190(DQ45) U18.AU31(MB_DATA45)
M_B_DQ46: CN17.208(DQ43) U18.AW31(MB_DATA46)
M_B_DQ47: CN17.204(DQ47) U18.AY33(MB_DATA47)
M_B_DQ48: CN17.215(DQ49) U18.BC31(MB_DATA48)
M_B_DQ49: CN17.211(DQ52) U18.BB30(MB_DATA49)
M_B_DQ50: CN17.228(DQ50) U18.BB28(MB_DATA50)
M_B_DQ51: CN17.229(DQ51) U18.AY27(MB_DATA51)
M_B_DQ52: CN17.216(DQ48) U18.BB32(MB_DATA52)
M_B_DQ53: CN17.212(DQ53) U18.BA31(MB_DATA53)
M_B_DQ54: CN17.225(DQ55) U18.BC29(MB_DATA54)
M_B_DQ55: CN17.224(DQ54) U18.BB29(MB_DATA55)
M_B_DQ56: CN17.249(DQ58) U18.BB27(MB_DATA56)
M_B_DQ57: CN17.237(DQ56) U18.BB26(MB_DATA57)
M_B_DQ58: CN17.233(DQ61) U18.BB24(MB_DATA58)
M_B_DQ59: CN17.245(DQ62) U18.AY23(MB_DATA59)
M_B_DQ60: CN17.232(DQ60) U18.BA27(MB_DATA60)
M_B_DQ61: CN17.236(DQ57) U18.BC27(MB_DATA61)
M_B_DQ62: CN17.246(DQ63) U18.BC25(MB_DATA62)
M_B_DQ63: CN17.250(DQ59) U18.BB25(MB_DATA63)
M_B_DQS0: CN17.13(DQS0) U18.B26(MB_DQS_H0)
M_B_DQS1: CN17.34(DQS1) U18.B30(MB_DQS_H1)
M_B_DQS2: CN17.55(DQS2) U18.F32(MB_DQS_H2)
M_B_DQS3: CN17.76(DQS3) U18.K32(MB_DQS_H3)
M_B_DQS4: CN17.179(DQS4) U18.AR32(MB_DQS_H4)
M_B_DQS5: CN17.200(DQS5) U18.AW32(MB_DQS_H5)
M_B_DQS6: CN17.221(DQS6) U18.BA29(MB_DQS_H6)
M_B_DQS7: CN17.242(DQS7) U18.BA25(MB_DQS_H7)
M_B_DQS#0: CN17.11(DQS#0) U18.A26(MB_DQS_L0)
M_B_DQS#1: CN17.32(DQS#1) U18.A30(MB_DQS_L1)
M_B_DQS#2: CN17.53(DQS#2) U18.E32(MB_DQS_L2)
M_B_DQS#3: CN17.74(DQS#3) U18.J32(MB_DQS_L3)
M_B_DQS#4: CN17.177(DQS#4) U18.AR33(MB_DQS_L4)
M_B_DQS#5: CN17.198(DQS#5) U18.AW33(MB_DQS_L5)
M_B_DQS#6: CN17.219(DQS#6) U18.AY29(MB_DQS_L6)
M_B_DQS#7: CN17.240(DQS#7) U18.AY25(MB_DQS_L7)
M_B_EVENT#: CN17.134(EVENT#) R636.2 U18.AG30(MB_EVENT_L)
M_B_PARITY: CN17.143(PARITY) R635.1
M_B_RAS#: CN17.152(A16/RAS#) U18.AH33(MB_RAS_L/MB_RAS_L_ADD16)
M_B_RESET#: CN17.108(RESET#) U18.T33(MB_RESET_L)
M_B_WE#: CN17.151(A14/WE#) U18.AJ31(MB_WE_L/MB_WE_L_ADD14)
M_MA_BG0: CN16.115(BG0) U18.T29(MA_BANK2/MA_BG0)
M_MA_BG1: CN16.113(BG1) U18.T26(MA_ADD14/MA_BG1)
M_MB_BG0: CN17.115(BG0) U18.W31(MB_BANK2/MB_BG0)
M_MB_BG1: CN17.113(BG1) U18.W30(MB_ADD14/MB_BG1)
M_VREF: TP268.1 U18.T32(M_VREF)
MA_ZVDDIO: R463.2 U18.AD29(MA_ZVDDIO_MEM_S)
MAA0_0: U22.G25(MAA0_0) VRAM1.H4(A0_A10__A7_A8)
MAA0_1: U22.H25(MAA0_1) VRAM1.H5(A1_A9__A6_A11)
MAA0_2: U22.E27(MAA0_2) VRAM1.H11(A2_BA0__A4_BA2)
MAA0_3: U22.D27(MAA0_3) VRAM1.H10(A3_BA3__A5_BA1)
MAA0_4: U22.D29(MAA0_4) VRAM1.K11(A4_BA2__A2_BA0)
MAA0_5: U22.H27(MAA0_5) VRAM1.K10(A5_BA1__A3_BA3)
MAA0_6: U22.H23(MAA0_6) VRAM1.K5(A6_A11__A1_A9)
MAA0_7: U22.E23(MAA0_7) VRAM1.K4(A7_A8__A0_A10)
MAA0_8: U22.D25(MAA0_8) VRAM1.J5(RFU_A12_NC)
MAA1_0: U22.E15(MAA1_0) VRAM2.K4(A7_A8__A0_A10)
MAA1_1: U22.H15(MAA1_1) VRAM2.K5(A6_A11__A1_A9)
MAA1_2: U22.G13(MAA1_2) VRAM2.K11(A4_BA2__A2_BA0)
MAA1_3: U22.D13(MAA1_3) VRAM2.K10(A5_BA1__A3_BA3)
MAA1_4: U22.H11(MAA1_4) VRAM2.H11(A2_BA0__A4_BA2)
MAA1_5: U22.H13(MAA1_5) VRAM2.H10(A3_BA3__A5_BA1)
MAA1_6: U22.H17(MAA1_6) VRAM2.H5(A1_A9__A6_A11)
MAA1_7: U22.G17(MAA1_7) VRAM2.H4(A0_A10__A7_A8)
MAA1_8: U22.D15(MAA1_8) VRAM2.J5(RFU_A12_NC)
MAB0_0: U22.R5(MAB0_0) VRAM3.H4(A0_A10__A7_A8)
MAB0_1: U22.R8(MAB0_1) VRAM3.H5(A1_A9__A6_A11)
MAB0_2: U22.N7(MAB0_2) VRAM3.H11(A2_BA0__A4_BA2)
MAB0_3: U22.N4(MAB0_3) VRAM3.H10(A3_BA3__A5_BA1)
MAB0_4: U22.L8(MAB0_4) VRAM3.K11(A4_BA2__A2_BA0)
MAB0_5: U22.N8(MAB0_5) VRAM3.K10(A5_BA1__A3_BA3)
MAB0_6: U22.U8(MAB0_6) VRAM3.K5(A6_A11__A1_A9)
MAB0_7: U22.U7(MAB0_7) VRAM3.K4(A7_A8__A0_A10)
MAB0_8: U22.R4(MAB0_8) VRAM3.J5(RFU_A12_NC)
MAB1_0: U22.AE7(MAB1_0) VRAM4.K4(A7_A8__A0_A10)
MAB1_1: U22.AE8(MAB1_1) VRAM4.K5(A6_A11__A1_A9)
MAB1_2: U22.AG5(MAB1_2) VRAM4.K11(A4_BA2__A2_BA0)
MAB1_3: U22.AG4(MAB1_3) VRAM4.K10(A5_BA1__A3_BA3)
MAB1_4: U22.AJ4(MAB1_4) VRAM4.H11(A2_BA0__A4_BA2)
MAB1_5: U22.AG8(MAB1_5) VRAM4.H10(A3_BA3__A5_BA1)
MAB1_6: U22.AC8(MAB1_6) VRAM4.H5(A1_A9__A6_A11)
MAB1_7: U22.AC5(MAB1_7) VRAM4.H4(A0_A10__A7_A8)
MAB1_8: U22.AE4(MAB1_8) VRAM4.J5(RFU_A12_NC)
MB_ZVDDIO: R464.2 U18.AF32(MB_ZVDDIO_MEM_S)
MDI0+: C215.1 EC12.2 U2.1(MDIP0) U12.11(TD4+)
MDI0-: C199.1 EC11.2 U2.2(MDIN0) U12.12(TD4-)
MDI1+: C287.1 EC14.2 U2.4(MDIP1) U12.7(TD3+)
MDI1-: C254.1 EC13.2 U2.5(MDIN1) U12.8(TD3-)
MDI2+: C310.1 EC16.2 U2.6(MDIP2(NC)) U12.5(TD2+)
MDI2-: C302.1 EC15.2 U2.7(MDIN2(NC)) U12.6(TD2-)
MDI3+: C336.1 EC18.2 U2.9(MDIP3(NC)) U12.1(TD1+)
MDI3-: C323.1 EC17.2 U2.10(MDIN3(NC)) U12.2(TD1-)
MEM_CALRA: R666.2 U22.K15(MEM_CALRA)
MEM_CALRB: R667.2 U22.R10(MEM_CALRB)
MEM_MA1_CS#0: TP108.1 U18.AH29(MA1_CS_L0)
MEM_MA1_CS#1: TP109.1 U18.AL28(MA1_CS_L1)
MEM_MA1_ODT0: TP106.1 U18.AH25(MA1_ODT0)
MEM_MA1_ODT1: TP107.1 U18.AL25(MA1_ODT1)
MEM_MA_ACT#: CN16.114(ACT#) U18.T25(MA_ADD15/MA_ACT_L)
MEM_MB_ACT#: CN17.114(ACT#) U18.V32(MB_ADD15/MB_ACT_L)
MF_A0: R784.1 VRAM1.J1(MF)
MF_A1: R785.1 VRAM2.J1(MF)
MF_B0: R786.1 VRAM3.J1(MF)
MF_B1: R787.1 VRAM4.J1(MF)
MVREFDA: C1231.1 R664.2 R670.1 U22.K17(MVREFDA)
MVREFDB: C1232.1 R665.2 R673.1 U22.U10(MVREFDB)
MX0: CN2.22 EC74.1 U34.58(KSI0/STB#)
MX1: CN2.24 EC76.1 U34.59(KSI1/AFD#)
MX2: CN2.26 EC78.1 U34.60(KSI2/INIT#)
MX3: CN2.23 EC75.1 U34.61(KSI3/SLIN#)
MX4: CN2.27 EC80.1 U34.62(KSI4)
MX5: CN2.25 EC77.1 U34.63(KSI5)
MX6: CN2.28 EC81.1 U34.64(KSI6)
MX7: CN2.29 EC79.1 U34.65(KSI7)
MY0: CN2.13 EC65.1 U34.36(KSO0/PD0)
MY1: CN2.15 EC67.1 U34.37(KSO1/PD1)
MY2: CN2.14 EC66.1 U34.38(KSO2/PD2)
MY3: CN2.16 EC68.1 U34.39(KSO3/PD3)
MY4: CN2.20 EC72.1 U34.40(KSO4/PD4)
MY5: CN2.21 EC73.1 U34.41(KSO5/PD5)
MY6: CN2.18 EC70.1 U34.42(KSO6/PD6)
MY7: CN2.19 EC71.1 U34.43(KSO7/PD7)
MY8: CN2.17 EC69.1 U34.44(KSO8/ACK#)
MY9: CN2.7 EC56.1 U34.45(KSO9/BUSY)
MY10: CN2.5 EC54.1 U34.46(KSO10/PE)
MY11: CN2.6 EC55.1 U34.51(KSO11/ERR#)
MY12: CN2.12 EC62.1 U34.52(KSO12/SLCT)
MY13: CN2.9 EC59.1 U34.53(KSO13)
MY14: CN2.8 EC57.1 U34.54(KSO14)
MY15: CN2.10 EC60.1 U34.55(KSO15)
MY16: CN2.11 EC61.1 U34.56(KSO16/SMOSI/GPC3(3))
NB_MUTE#: CN5.27 U34.84(EGCLK/GPE3)
NTC: PC9372.2 PR277.1 PR278.2 PU16.11(NTC)
NTC_GFX: PC9373.2 PR323.1 PR324.2 PU17.11(NTC)
NTC_GPU: PC9375.2 PR422.1 PR423.2 PU24.11(NTC)
NTC_NB: PC9371.2 PR275.1 PR276.2 PU16.1(NTC_NB)
NTC_NB_GFX: PR325.1 PU17.1(NTC_NB)
NTC_NB_GPU: PC9374.2 PR420.1 PR421.2 PU24.1(NTC_NB)
P_ZVDDP_P_TX_095: R461.1 U18.U7(P_ZVDDP)
P_ZVSS_P_RX_095: R462.2 U18.U6(P_ZVSS/P_RX_ZVDDP)
PBAT_PRES#: ESD1.3 PR221.2 PR222.2 PU15.15(B\A\T\P\R\E\S\) U34.18(RI1#/GPD0(3))
PCI_SERR#_R: TP128.1 U18.AL8(IR_TX1/USB_OC6_L/AGPIO14)
PCIE_CLKREQ_LAN#: R321.1 U2.12(CLKREQB) U18.BB17(CLK_REQ1_L/AGPIO115)
PCIE_CLKREQ_VGA#: Q50.3(D) R1006.1 R1007.1 U18.BB16(CLK_REQG_L/OSCIN/EGPIO132)
PCIE_CLKREQ_WLAN#: CN10.53(CLKREQ#) R241.1 U18.BC15(CLK_REQ0_L/SATA_IS0_L/SATA_ZP0_)
PCIE_EC_WAKE#: Q49.3(D) R1004.1 U34.70(ADC4/GPI4(3))
PCIE_EC_WAKE#_R: Q49.1(S) R303.2 R1004.2 U2.21(LANWAKEB)
PCIE_RST#: R522.1 U18.AN7(PCIE_RST_L/EGPIO26)
PCIE_RXN0_WLAN: CN10.43(PETN0) U18.U9(P_GPP_RXN0)
PCIE_RXN1_LAN: C643.1 U18.T5(P_GPP_RXN1)
PCIE_RXN1_LAN_C: C643.2 U2.18(HSON)
PCIE_RXP0_WLAN: CN10.41(PETP0) U18.U10(P_GPP_RXP0)
PCIE_RXP1_LAN: C642.1 U18.T6(P_GPP_RXP1)
PCIE_RXP1_LAN_C: C642.2 U2.17(HSOP)
PCIE_TXN0_WLAN: C1099.2 CN10.37(PERN0)
PCIE_TXN0_WLAN_C: C1099.1 U18.R2(P_GPP_TXN0)
PCIE_TXN1_LAN: C750.2 U2.14(HSIN)
PCIE_TXN1_LAN_C: C750.1 U18.R3(P_GPP_TXN1)
PCIE_TXP0_WLAN: C1100.2 CN10.35(PERP0)
PCIE_TXP0_WLAN_C: C1100.1 U18.R1(P_GPP_TXP0)
PCIE_TXP1_LAN: C749.2 U2.13(HSIP)
PCIE_TXP1_LAN_C: C749.1 U18.R4(P_GPP_TXP1)
PCIE_WAKE#: C761.2 R539.1 U18.AG2(WAKE_L/AGPIO2)
PCIE_ZVSS: R652.1 U22.AU41(PCIE_ZVSS)
PCIERST#: C758.2 C759.1 C965.1 D17.1 D18.1 R522.2 R1112.2 U2.19(PERSTB) U24.2(I0)
PCLK_DEBUG: C769.2 R590.1 R1069.1
PCLK_DEBUG_R: CN10.71(NC#71) R1069.2
PEG_RXN0: C948.1 U18.P9(P_GFX_RXN0)
PEG_RXN0_C: C948.2 U22.AU35(PCIE_TX0N)
PEG_RXN1: C950.1 U18.N5(P_GFX_RXN1)
PEG_RXN1_C: C950.2 U22.AU39(PCIE_TX1N)
PEG_RXN2: C952.1 U18.N8(P_GFX_RXN2)
PEG_RXN2_C: C952.2 U22.AR38(PCIE_TX2N)
PEG_RXN3: C954.1 U18.L6(P_GFX_RXN3)
PEG_RXN3_C: C954.2 U22.AN38(PCIE_TX3N)
PEG_RXN4: C956.1 U18.L9(P_GFX_RXN4)
PEG_RXN4_C: C956.2 U22.AL38(PCIE_TX4N)
PEG_RXN5: C957.1 U18.K5(P_GFX_RXN5)
PEG_RXN5_C: C957.2 U22.AJ38(PCIE_TX5N)
PEG_RXN6: C960.1 U18.K8(P_GFX_RXN6)
PEG_RXN6_C: C960.2 U22.AG38(PCIE_TX6N)
PEG_RXN7: C962.1 U18.J6(P_GFX_RXN7)
PEG_RXN7_C: C962.2 U22.AE38(PCIE_TX7N)
PEG_RXP0: C947.1 U18.P10(P_GFX_RXP0)
PEG_RXP0_C: C947.2 U22.AV35(PCIE_TX0P)
PEG_RXP1: C949.1 U18.N6(P_GFX_RXP1)
PEG_RXP1_C: C949.2 U22.AU38(PCIE_TX1P)
PEG_RXP2: C951.1 U18.N9(P_GFX_RXP2)
PEG_RXP2_C: C951.2 U22.AR37(PCIE_TX2P)
PEG_RXP3: C953.1 U18.L7(P_GFX_RXP3)
PEG_RXP3_C: C953.2 U22.AN37(PCIE_TX3P)
PEG_RXP4: C955.1 U18.L10(P_GFX_RXP4)
PEG_RXP4_C: C955.2 U22.AL37(PCIE_TX4P)
PEG_RXP5: C958.1 U18.K6(P_GFX_RXP5)
PEG_RXP5_C: C958.2 U22.AJ37(PCIE_TX5P)
PEG_RXP6: C959.1 U18.K9(P_GFX_RXP6)
PEG_RXP6_C: C959.2 U22.AG37(PCIE_TX6P)
PEG_RXP7: C961.1 U18.J7(P_GFX_RXP7)
PEG_RXP7_C: C961.2 U22.AE37(PCIE_TX7P)
PEG_TXN0: C9.1 U22.AT40(PCIE_RX0N)
PEG_TXN0_C: C9.2 U18.M1(P_GFX_TXN0)
PEG_TXN1: C11.1 U22.AR40(PCIE_RX1N)
PEG_TXN1_C: C11.2 U18.L2(P_GFX_TXN1)
PEG_TXN2: C13.1 U22.AP40(PCIE_RX2N)
PEG_TXN2_C: C13.2 U18.L3(P_GFX_TXN2)
PEG_TXN3: C15.1 U22.AM40(PCIE_RX3N)
PEG_TXN3_C: C15.2 U18.J2(P_GFX_TXN3)
PEG_TXN4: C17.1 U22.AL40(PCIE_RX4N)
PEG_TXN4_C: C17.2 U18.J3(P_GFX_TXN4)
PEG_TXN5: C19.1 U22.AK40(PCIE_RX5N)
PEG_TXN5_C: C19.2 U18.H1(P_GFX_TXN5)
PEG_TXN6: C21.1 U22.AJ40(PCIE_RX6N)
PEG_TXN6_C: C21.2 U18.G2(P_GFX_TXN6)
PEG_TXN7: C23.1 U22.AH40(PCIE_RX7N)
PEG_TXN7_C: C23.2 U18.G3(P_GFX_TXN7)
PEG_TXP0: C8.1 U22.AT41(PCIE_RX0P)
PEG_TXP0_C: C8.2 U18.M2(P_GFX_TXP0)
PEG_TXP1: C10.1 U22.AR41(PCIE_RX1P)
PEG_TXP1_C: C10.2 U18.L1(P_GFX_TXP1)
PEG_TXP2: C12.1 U22.AP41(PCIE_RX2P)
PEG_TXP2_C: C12.2 U18.L4(P_GFX_TXP2)
PEG_TXP3: C14.1 U22.AM41(PCIE_RX3P)
PEG_TXP3_C: C14.2 U18.J1(P_GFX_TXP3)
PEG_TXP4: C16.1 U22.AL41(PCIE_RX4P)
PEG_TXP4_C: C16.2 U18.J4(P_GFX_TXP4)
PEG_TXP5: C18.1 U22.AK41(PCIE_RX5P)
PEG_TXP5_C: C18.2 U18.H2(P_GFX_TXP5)
PEG_TXP6: C20.1 U22.AJ41(PCIE_RX6P)
PEG_TXP6_C: C20.2 U18.G1(P_GFX_TXP6)
PEG_TXP7: C22.1 U22.AH41(PCIE_RX7P)
PEG_TXP7_C: C22.2 U18.G4(P_GFX_TXP7)
PEGX_RST#: R648.2 R658.1 R1015.2 R1067.1 U24.4(O)
PEGX_RST#_R: R648.1 U22.AV41(PERSTB)
PHASE_1: PC9132.2 PC9137.1 PL20.1 PQ47.5(S1/D2-1) PQ47.6(S1/D2-2) PQ47.7(S1/D2-3) PU16.23(PHASE1)
PHASE_2: PC9114.2 PC9115.1 PL19.1 PQ46.5(S1/D2-1) PQ46.6(S1/D2-2) PQ46.7(S1/D2-3) PU16.28(PHASE2)
PHASE_CI: PC9241.2 PC9243.1 PL26.2 PQ57.1(S1) PQ57.2(S2) PQ57.3(S3) PQ58.5(C1) PQ58.6(C2) PQ58.7(C3) PQ58.8(C4) PU24.33(PHASE_NB) SJ18.1(A)
PHASE_GFX1: PC9161.2 PC9165.1 PL22.1 PQ49.5(S1/D2-1) PQ49.6(S1/D2-2) PQ49.7(S1/D2-3) PU17.23(PHASE1)
PHASE_GFX2: PC9149.2 PC9150.1 PL21.1 PQ48.5(S1/D2-1) PQ48.6(S1/D2-2) PQ48.7(S1/D2-3) PU17.28(PHASE2)
PHASE_GPU1: PC9272.2 PC9276.1 PL28.1 PQ61.5(S1/D2-1) PQ61.6(S1/D2-2) PQ61.7(S1/D2-3) PQ62.5(S1/D2-1) PQ62.6(S1/D2-2) PQ62.7(S1/D2-3) PU24.23(PHASE1)
PHASE_GPU2: PC9259.2 PC9260.1 PL27.1 PQ59.5(S1/D2-1) PQ59.6(S1/D2-2) PQ59.7(S1/D2-3) PQ60.5(S1/D2-1) PQ60.6(S1/D2-2) PQ60.7(S1/D2-3) PU24.28(PHASE2)
PHASE_NB: PC9098.2 PC9103.1 PL18.1 PQ45.5(S1/D2-1) PQ45.6(S1/D2-2) PQ45.7(S1/D2-3) PU16.33(PHASE_NB)
PLLCHARZ_H: TP179.1 U22.AU15(PLLCHARZ_H)
PLLCHARZ_L: TP178.1 U22.AV15(PLLCHARZ_L)
POWER_ SW_IN0#: C714.1 D15.3(OUT) EC163.2 J2.4 R435.2
POWER_LED: Q12.2(G) R1002.1 U34.24(PWM0/GPA0)
POWERLED: EC162.2 Q12.3(D) R1110.2
PS_ID: PD1.3 PR202.2 PR203.2 U34.123(CTX0/TMA0/GPB2(3))
PTP_DISABLE#: CN4.3 R170.1 U34.78(DAC2/TACH0B/GPJ2(3))
PX_EN: R651.1 TP279.1 U22.AC41(PX_EN)
RASA0B: U22.D21(RASA0B) VRAM1.G3(RAS$__CAS$)
RASA1B: U22.D19(RASA1B) VRAM2.L3(CAS$__RAS$)
RASB0B: U22.W4(RASB0B) VRAM3.G3(RAS$__CAS$)
RASB1B: U22.AA4(RASB1B) VRAM4.L3(CAS$__RAS$)
RCIN#: D30.1(OUT) U34.4(KBRST#/GPB6(3))
REG_OUT: C352.2 R962.1 U2.24(REGOUT(NC))
REM_DIODE1_N: C225.2 C574.2 Q4.1(EMITTER) U9.3(DN)
REM_DIODE1_P: C225.1 C574.1 Q4.2(BASE) Q4.3(COLLECTOR) U9.2(DP)
ROMCSB: R1083.2 U208.1(CE#)
ROMSCK: R1084.2 U208.6(SCK)
ROMSI: R1085.2 U208.5(SI)
ROMSO: R1086.2 U208.2(SO)
RREF: R821.1 U28.1(RREF)
RSMRST#: D19.1 U34.80(DAC4/DCD0#/GPJ4(3))
RSMRST#_R: C760.2 D19.2 R523.2 U18.AE4(RSMRST_L)
RTC_CLK: R596.2 R606.2 U18.AG7(RTCCLK)
RTL8111G_REST: R58.1 U2.31(RSET)
RUN_ON: CN5.33 PR501.2 PR502.2 PR504.2 PR506.2 Q6.2(G) R1048.2 R1055.1 U34.119(CRX0/GPC0)
S3_RESUME: R530.1 R551.2 U18.AG8(AGPIO40)
SATA_CALRN: R581.1 U18.AW1(SATA_ZVSS)
SATA_CALRP: R576.1 U18.AW2(SATA_ZVDDP)
SATA_DEVSLP0: R580.1 R886.1 U18.AT17(DEVSLP0/EGPIO67)
SATA_DEVSLP0_R: CON1.38(DEVSLP) R886.2
SATA_DEVSLP1: R582.1 U18.AT12(DEVSLP1/EGPIO70)
SATA_RXN0: C1106.2 U18.AV1(SATA_RX0N)
SATA_RXN0_C: C1106.1 CON1.43(SATA-B-)
SATA_RXN1: C740.2 U18.AW4(SATA_RX1N)
SATA_RXN1_C: C740.1 CN12.16(TXN)
SATA_RXP0: C1105.2 U18.AV2(SATA_RX0P)
SATA_RXP0_C: C1105.1 CON1.41(SATA-B+)
SATA_RXP1: C739.2 U18.AW3(SATA_RX1P)
SATA_RXP1_C: C739.1 CN12.15(TXP)
SATA_TXN0: C1103.2 U18.AU4(SATA_TX0N)
SATA_TXN0_C: C1103.1 CON1.47(SATA-A-)
SATA_TXN1: C741.2 U18.AY1(SATA_TX1N)
SATA_TXN1_C: C741.1 CN12.18(RXN)
SATA_TXP0: C1104.2 U18.AU3(SATA_TX0P)
SATA_TXP0_C: C1104.1 CON1.49(SATA-A+)
SATA_TXP1: C742.2 U18.AY2(SATA_TX1P)
SATA_TXP1_C: C742.1 CN12.19(RXP)
SATALED#: Q16.5(G) Q16.6(D) R238.2 R239.1 U18.BB15(SATA_ACT_L/AGPIO130)
SCL: R688.1 U22.AC35(SCL)
SD_CD#: JCARD1.4(C/D) U28.13(SP6)
SD_CLK: C1236.2 JCARD1.7(CLK) R1036.1
SD_CLK_R: R1036.2 U28.15(SP8)
SD_CMD: JCARD1.3(CMD) U28.18(SP10)
SD_D0: JCARD1.9(DAT0) U28.11(SP4)
SD_D1: JCARD1.10(DAT1) U28.10(SP3)
SD_D2: JCARD1.1(DAT2) U28.21(SP13)
SD_D3: JCARD1.2(DAT3) U28.20(SP12)
SD_D4: TP267.1 U28.19(SP11)
SD_D5: TP266.1 U28.16(SP9)
SD_D6: TP265.1 U28.14(SP7)
SD_D7: TP264.1 U28.12(SP5)
SD_WP: JCARD1.11(W/P) U28.8(SP1)
SDA: R690.1 U22.AC34(SDA)
SDREG: C1135.2 U28.6(SDREG)
SEN_A0: R780.1 VRAM1.J10(SEN)
SEN_A1: R781.1 VRAM2.J10(SEN)
SEN_B0: R782.1 VRAM3.J10(SEN)
SEN_B1: R783.1 VRAM4.J10(SEN)
SENSOR_HUB_INT1#: R1011.2 U18.AW15(AGPIO64)
SERIRQ: U18.BC14(SERIRQ/AGPIO87) U34.5(SERIRQ/GPM6(3))
SI_SS_SEL: R765.1 R766.2 U27.5(SSON_N)
SI_VDD: R763.1 U27.1(VDD)
SI_XTALIN: C978.1 R762.1 U27.2(XIN) Y6.1
SI_XTALOUT: C977.1 R762.2 U27.3(XOUT) Y6.3(NC)
SIO_A20GATE: D46.2(IN) R965.1 U18.BC19(GA20IN/AGPIO126)
SIO_A20GATE_R: D46.1(OUT) U34.126(GA20/GPB5(3))
SIO_EXT_SCI#: D29.2(IN) U18.AD7(LPC_PME_L/AGPIO22)
SIO_SLP_S3#: PR480.1 PR499.2 PR500.2 PR503.2 PR505.2 R1049.2 U18.AK7(SLP_S3_L) U34.124(TMRI1/GPC6(3))
SIO_SLP_S5#: D52.1(OUT) PR481.1 U18.AH5(SLP_S5_L) U34.118(SMDAT2/GPF7(3))
SL_CLK_100M: R764.2 U27.4(CLKOUT1)
SMB_ALW_CLK: R532.2 U18.AG5(SCL1/I2C3_SCL/AGPIO19)
SMB_ALW_DAT: R533.2 U18.AG4(SDA1/I2C3_SDA/AGPIO20)
SMB_RUN_CLK: CN16.253(SCL) CN17.253(SCL) R524.2 U18.BA15(SCL0/I2C2_SCL/EGPIO113)
SMB_RUN_DAT: CN16.254(SDA) CN17.254(SDA) R525.2 U18.AY17(SDA0/I2C2_SDA/EGPIO114)
SMBCLK0: ESD1.6 PR200.1 PR223.2 R863.2 U34.110(SMCLK0/GPB3)
SMBCLK0_B: JBAT1.8(SMB_CLK) PR223.1
SMBCLK0_P: PR200.2 PU15.12(SCL)
SMBCLK1: Q33.3(D1) R865.2 U34.115(SMCLK1/GPC1)
SMBCLK3: Q40.6(D) R867.2 U9.8(SCL) U34.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
SMBDAT0: ESD1.4 PR211.1 PR224.2 R864.2 U34.111(SMDAT0/GPB4)
SMBDAT0_B: JBAT1.7(SMB_DAT) PR224.1
SMBDAT0_P: PR211.2 PU15.11(SDA)
SMBDAT1: Q33.6(D2) R866.2 U34.116(SMDAT1/GPC2)
SMBDAT3: Q40.3(D) R868.2 U9.7(SDA) U34.95(CTX1/SOUT1/GPH2/SMDAT3/ID2)
SMC_EXT_SMI#: D28.2(IN) R1107.2 U18.AK5(AGPIO9)
SSD_LED#: CON1.10(LED#1) R238.1
SUB_MUTE#: CN5.26 U34.108(RXD/SIN0/GPB0)
SUS_ON: PR353.1 PR368.1 PR463.1 PR465.1 PR511.2 R1064.1 U34.100(SSCE0#/GPG2)
SVC: R477.1 R484.1 R493.2 U18.D17(SVC0)
SVD: R479.1 R486.1 R492.2 U18.D19(SVD0)
SYS_PWR_SW#: C712.1 D15.1(INA) R436.1 U34.125(PWRSW/GPE4(3))
SYS_PWRGD: R562.2 U18.BC9(PWR_GOOD)
SYS_RST#: D22.1(OUT) R531.2 R598.2 R608.2 U18.AF2(SYS_RESET_L/AGPIO1)
SYS_SHDN#: Q17.1(S) R264.2 U9.4(SYS_SHDN#)
SYSTEM_SUS_PG: R1044.1 U34.19(L80HLAT/BAO/GPE0)
T_DDR: R397.1 RT1.2 U34.66(ADC0/GPI0(3))
T_SSD: R446.1 RT2.2 U34.73(ADC7/CTS1#/GPI7(3))
TEST_PG: C971.2 R705.1 U22.AY13(TEST_PG)
TEST_PG_BACO: C973.2 R709.1 U22.BA13(TEST_PG_BACO)
THERM_ALERT#: R262.2 U9.6(ALERT#)
THERM_STP#: Q17.3(D) Q41.2(G1) R226.1
TP_I2C_CLK: CN4.6 Q9.3(D1) R159.1 R172.2
TP_I2C_DAT: CN4.7 Q9.6(D2) R163.1 R173.2
TP_INTR#: CN4.4 D6.1(OUT) R171.1 R460.1 U34.69(ADC3/GPI3(3))
TP_PWR_EN: C689.1 Q25.3(D) Q26.2 R417.2
TP_PWR_EN#: Q25.2(G) Q25.5(G) U34.16(PWUREQ#/BBO/SMCLK2ALT/GPC7(3))
TPCLK: R150.1 R161.2 U34.89(PS2CLK2/GPF4)
TPCLK-1: CN4.1 EC24.2 R161.1
TPDATA: R151.1 R162.2 U34.90(PS2DAT2/GPF5)
TPDATA-1: CN4.2 EC25.2 R162.1
TPS51225_FB1: PR209.1 SJ11.2(B)
TPS51225_FB2: PR207.2 SJ13.2(B)
TPS51225_VFB1: PR209.2 PR210.2 PU2.2(VFB1)
TPS51225_VFB2: PR206.1 PR207.1 PU2.4(VFB2)
TPS51225_VO1: PU2.14(VO1) SJ12.2(B)
TRA_V_DAC: C228.1 U12.3(TCT1) U12.4(TCT2) U12.9(TCT3) U12.10(TCT4)
UART0_CTS: TP313.1 U18.AY9(UART0_CTS_L/EGPIO135)
UART0_RTS: TP315.1 U18.AV5(UART0_RTS_L/EGPIO137)
UART0_RXD: TP314.1 U18.AW8(UART0_RXD/EGPIO136)
UART0_TXD: TP316.1 U18.AV8(UART0_TXD/EGPIO138)
UART1_CTS: TP317.1 U18.AV11(UART1_CTS_L/BT_I2S_BCLK/EGPIO14)
UART1_RTS: TP320.1 U18.AT11(UART1_RTS_L/EGPIO142)
UART1_RXD: TP318.1 U18.AU7(UART1_RXD/BT_I2S_SDI/EGPIO141)
UART1_TXD: TP319.1 U18.AR11(UART1_TXD/BT_I2S_SDO/EGPIO143)
UGATE_1: PQ47.1(G1) PU16.22(UGATE1)
UGATE_2: PQ46.1(G1) PU16.29(UGATE2)
UGATE_CI: PQ57.4(G) PU24.32(UGATE_NB)
UGATE_GFX1: PQ49.1(G1) PU17.22(UGATE1)
UGATE_GFX2: PQ48.1(G1) PU17.29(UGATE2)
UGATE_GPU1: PQ61.1(G1) PQ62.1(G1) PU24.22(UGATE1)
UGATE_GPU2: PQ59.1(G1) PQ60.1(G1) PU24.29(UGATE2)
UGATE_NB: PQ45.1(G1) PU16.32(UGATE_NB)
USB2_N1_L: CN8.2(D-) EL3.2
USB2_N1_R: EL3.1 U7.11(DM_IN)
USB2_P1_L: CN8.3(D+) EL3.3
USB2_P1_R: EL3.4 U7.10(DP_IN)
USB2N0: TP308.1 U18.AR1(USB_HSD0N)
USB2N1_BT: R453.2 U18.AR4(USB_HSD1N)
USB2N1_BT_R: CN10.5(USB_D_N) R453.1
USB2N2_CAM: R359.1 U18.AN1(USB_HSD2N)
USB2N2_CAM_R: CN9.2 R359.2
USB2N3_CR: R910.2 U18.AN4(USB_HSD3N)
USB2N3_CR_R: R910.1 U28.2(DM)
USB2P0: TP309.1 U18.AR2(USB_HSD0P)
USB2P1_BT: R452.2 U18.AR3(USB_HSD1P)
USB2P1_BT_R: CN10.3(USB_D_P) R452.1
USB2P2_CAM: R358.1 U18.AN2(USB_HSD2P)
USB2P2_CAM_R: CN9.1 R358.2
USB2P3_CR: R909.2 U18.AN3(USB_HSD3P)
USB2P3_CR_R: R909.1 U28.3(DP)
USB3_CTL2: R132.1 U7.7(CTL2) U7.8(CTL3)
USB3_RXN0: C1212.1 U18.W8(USB_SS_0RXN)
USB3_RXN0_C: C1212.2 U209.7(BOUT-)
USB3_RXN0_L: CN5.5 U209.5(BIN-)
USB3_RXN1: C1214.1 U18.W6(USB_SS_1RXN)
USB3_RXN1_C: C1214.2 U210.7(BOUT-)
USB3_RXN1_L: CN5.14 U210.5(BIN-)
USB3_RXN2: C1143.1 U18.Y7(USB_SS_2RXN)
USB3_RXN2_C: C1143.2 U29.7(BOUT-)
USB3_RXN2_L: CN8.5(SSRX-) EU1.5(2+) EU1.6(NC4) R832.1
USB3_RXN2_RE: R832.2 U29.5(BIN-)
USB3_RXP0: C1213.1 U18.W9(USB_SS_0RXP)
USB3_RXP0_C: C1213.2 U209.8(BOUT+)
USB3_RXP0_L: CN5.4 U209.4(BIN+)
USB3_RXP1: C1215.1 U18.W5(USB_SS_1RXP)
USB3_RXP1_C: C1215.2 U210.8(BOUT+)
USB3_RXP1_L: CN5.13 U210.4(BIN+)
USB3_RXP2: C1142.1 U18.Y6(USB_SS_2RXP)
USB3_RXP2_C: C1142.2 U29.8(BOUT+)
USB3_RXP2_L: CN8.6(SSRX+) EU1.4(2-) EU1.7(NC3) R831.1
USB3_RXP2_RE: R831.2 U29.4(BIN+)
USB3_TXN0: C1216.1 U18.AA4(USB_SS_0TXN)
USB3_TXN0_C: C1216.2 U209.10(AIN-)
USB3_TXN0_L: C1221.2 CN5.2
USB3_TXN0_RE: C1221.1 U209.2(AOUT-)
USB3_TXN1: C1219.1 U18.AA1(USB_SS_1TXN)
USB3_TXN1_C: C1219.2 U210.10(AIN-)
USB3_TXN1_L: C1223.2 CN5.11
USB3_TXN1_RE: C1223.1 U210.2(AOUT-)
USB3_TXN2: C1139.1 U18.AC2(USB_SS_2TXN)
USB3_TXN2_C: C1139.2 U29.10(AIN-)
USB3_TXN2_L: CN8.8(SSTX-) EU1.2(1+) EU1.9(NC2) R1018.1
USB3_TXN2_R: C1141.2 R1018.2
USB3_TXN2_RE: C1141.1 U29.2(AOUT-)
USB3_TXP0: C1217.1 U18.AA3(USB_SS_0TXP)
USB3_TXP0_C: C1217.2 U209.11(AIN+)
USB3_TXP0_L: C1220.2 CN5.1
USB3_TXP0_RE: C1220.1 U209.1(AOUT+)
USB3_TXP1: C1218.1 U18.AA2(USB_SS_1TXP)
USB3_TXP1_C: C1218.2 U210.11(AIN+)
USB3_TXP1_L: C1222.2 CN5.10
USB3_TXP1_RE: C1222.1 U210.1(AOUT+)
USB3_TXP2: C1138.1 U18.AC1(USB_SS_2TXP)
USB3_TXP2_C: C1138.2 U29.11(AIN+)
USB3_TXP2_L: CN8.9(SSTX+) EU1.1(1-) EU1.10(NC1) R1017.1
USB3_TXP2_R: C1140.2 R1017.2
USB3_TXP2_RE: C1140.1 U29.1(AOUT+)
USB3_USB2_N0: CN5.7 U18.AM2(USB_HSD4N)
USB3_USB2_N1: CN5.16 U18.AL1(USB_HSD5N)
USB3_USB2_N2: U7.2(DM_OUT) U18.AL4(USB_HSD6N)
USB3_USB2_P0: CN5.8 U18.AM1(USB_HSD4P)
USB3_USB2_P1: CN5.17 U18.AL2(USB_HSD5P)
USB3_USB2_P2: U7.3(DP_OUT) U18.AL3(USB_HSD6P)
USB_BACK_EN: C490.2 U7.5(EN) U34.31(PWM5/GPA5)
USB_CHG_DET#: CN8.10(D1) D16.3(OUT) EC20.1 R447.2
USB_CHG_DET#_EC: C728.1 D16.1(INA) R445.1 U34.67(ADC1/GPI1(3))
USB_OC1#: R549.1 U7.13(F\A\U\L\T\) U18.AG1(USB_OC1_L/TDI/AGPIO17)
USB_OC2#: CN5.32 R550.1 U18.AH2(USB_OC2_L/TCK/AGPIO18)
USB_RIGHT_EN#: CN5.31 U34.33(GINT/CTS0#/GPD5)
USB_ZVSS: R579.2 U18.AP5(USB_ZVSS)
USBP0_BUS_SW_CB0: C487.2 U7.6(CTL1) U34.106(SSCE1#/GPG0(UP))
USBSS_CALRN: R587.2 U18.AD2(USB_SS_ZVSS)
USBSS_CALRP: R588.2 R1082.2 U18.AD1(USB_SS_ZVDDP)
VCLK: PC89.1 PC252.1 PU2.19(VCLK)
VGA_AC_BATT: Q45.3(D) R679.1 R1014.2 U22.AA34(GPIO_5_REG_HOT_AC_BATT)
VGA_CTF: R1013.2 U22.R38(GPIO_19_CTF)
VGA_PWR_LEVEL_EC#: Q45.2(G) U34.57(KSO17/SMISO/GPC5(3))
VR_ON: PR270.1 PR318.1 U34.17(LPCPD#/GPE6)
VREFC_A0: C1035.2 R804.2 R808.2 VRAM1.J14(VREFC)
VREFC_A1: C1036.2 R805.2 R809.2 VRAM2.J14(VREFC)
VREFC_B0: C1037.2 R806.2 R810.2 VRAM3.J14(VREFC)
VREFC_B1: C1038.2 R807.2 R811.2 VRAM4.J14(VREFC)
VREFD1_A0: C1027.2 R788.2 R792.2 VRAM1.A10(VREFD1)
VREFD1_A1: C1028.2 R789.2 R793.2 VRAM2.A10(VREFD1)
VREFD1_B0: C1029.2 R790.2 R794.2 VRAM3.A10(VREFD1)
VREFD1_B1: C1030.2 R791.2 R795.2 VRAM4.A10(VREFD1)
VREFD2_A0: C1031.2 R796.2 R800.2 VRAM1.U10(VREFD2)
VREFD2_A1: C1032.2 R797.2 R801.2 VRAM2.U10(VREFD2)
VREFD2_B0: C1033.2 R798.2 R802.2 VRAM3.U10(VREFD2)
VREFD2_B1: C1034.2 R799.2 R803.2 VRAM4.U10(VREFD2)
VRM_PWRGD: PR264.1 PR507.2 PR508.1 R1075.2
VSUM+: PC9134.1 PC9135.2 PR279.1 PR291.2 PR293.2 PR302.1 PU16.14(ISUMP)
VSUM+_GFX: PC9174.1 PC9175.2 PR317.1 PR335.2 PR337.2 PR341.1 PU17.14(ISUMP)
VSUM+_GPU: PC9281.1 PC9282.1 PR417.1 PR435.2 PR437.2 PR440.1 PU24.14(ISUMP)
VSUM-: PC9124.1 PC9126.2 PC9134.2 PC9135.1 PC9141.1 PR285.2 PR293.1 PR296.2 PR298.2 PR304.2
VSUM-_GFX: PC9157.1 PC9163.2 PC9174.2 PC9175.1 PC9177.1 PR322.2 PR337.1 PR340.2 PR343.2 PR345.2
VSUM-_GPU: PC9268.1 PC9273.2 PC9281.2 PC9282.2 PC9284.1 PR419.2 PR437.1 PR439.2 PR443.2 PR444.2
VSUMG+: PC9100.2 PC9101.1 PR251.2 PR255.2 PR261.1 PU16.40(ISUMP_NB)
VSUMG+_CI: PC9245.1 PC9246.2 PR395.2 PR399.2 PR404.1 PU24.40(ISUMP_NB)
VSUMG-: PC9100.1 PC9101.2 PC9111.1 PR255.1 PR258.2 PR259.2 PR263.2
VSUMG-_CI: PC9245.2 PC9246.1 PC9255.1 PR399.1 PR402.2 PR403.2 PR405.2
VSYNC: R942.1 R943.2 U22.W35(VSYNC)
WCKA0_0: U22.D33(WCKA0_0) VRAM1.D4(WCK01__WCK23)
WCKA0_1: U22.A34(WCKA0_1) VRAM1.P4(WCK23__WCK01)
WCKA0B_0: U22.E33(WCKA0B_0) VRAM1.D5(WCK01$__WCK23$)
WCKA0B_1: U22.B34(WCKA0B_1) VRAM1.P5(WCK23$__WCK01$)
WCKA1_0: U22.A22(WCKA1_0) VRAM2.D4(WCK01__WCK23)
WCKA1_1: U22.A8(WCKA1_1) VRAM2.P4(WCK23__WCK01)
WCKA1B_0: U22.B21(WCKA1B_0) VRAM2.D5(WCK01$__WCK23$)
WCKA1B_1: U22.B9(WCKA1B_1) VRAM2.P5(WCK23$__WCK01$)
WCKB0_0: U22.H1(WCKB0_0) VRAM3.D4(WCK01__WCK23)
WCKB0_1: U22.AB1(WCKB0_1) VRAM3.P4(WCK23__WCK01)
WCKB0B_0: U22.J2(WCKB0B_0) VRAM3.D5(WCK01$__WCK23$)
WCKB0B_1: U22.AA2(WCKB0B_1) VRAM3.P5(WCK23$__WCK01$)
WCKB1_0: U22.AP1(WCKB1_0) VRAM4.D4(WCK01__WCK23)
WCKB1_1: U22.AN4(WCKB1_1) VRAM4.P4(WCK23__WCK01)
WCKB1B_0: U22.AP2(WCKB1B_0) VRAM4.D5(WCK01$__WCK23$)
WCKB1B_1: U22.AN5(WCKB1B_1) VRAM4.P5(WCK23$__WCK01$)
WEA0B: U22.G29(WEA0B) VRAM1.L12(WE$__CS$)
WEA1B: U22.D11(WEA1B) VRAM2.G12(CS$__WE$)
WEB0B: U22.L4(WEB0B) VRAM3.L12(WE$__CS$)
WEB1B: U22.AJ7(WEB1B) VRAM4.G12(CS$__WE$)
WLAN_ON/OFF#: CN10.56(WLAN_DISABLE#) U34.98(HMISO/GPH5/ID5)
WLAN_WAKE#_R: CN10.55(PEWAKE#) R235.1
WRST#: C1183.1 Q41.3(D2) R862.1 TP325.1 U34.14(WRST#)
XTALIN: R764.1 U22.BA39(XTALIN)
XTALOUT: TP321.1 U22.AY39(XTALOUT)
ZQ_A0: R776.2 VRAM1.J13(ZQ)
ZQ_A1: R777.2 VRAM2.J13(ZQ)
ZQ_B0: R778.2 VRAM3.J13(ZQ)
ZQ_B1: R779.2 VRAM4.J13(ZQ)
N2732626: PC224.1 PR191.1 PR192.2 PR199.1 PU15.21(ILIM)
N2734238: PC79.2 PC81.1 PR188.1 PR220.2P
N2734263: PC79.1 PC82.1 PR189.1 PR220.1P
N2837902: Q23.5(G) Q23.6(D) R399.2
N2837932: Q23.3(D) R393.2 R394.1
N2837976: C681.1 PQ72.3(G) R394.2
N2875473: CN10.52(PERST#) R1111.1 R1112.1
N4259362: PC88.1 PR61.2
N4908051: PR205.2 PU2.20(EN1)
N5524290: PQ41.5(D1) PQ41.6(D2) PQ41.7(D3) PQ41.8(D4) PR232.1
N6840049: Q25.6(D) R416.1
N8721558: R749.1 R750.1
N8974652: PC253.1 PQ43.6(D) PR245.2
N8974664: PC253.2 PQ43.5(G) PR242.1
N8974676: PD7.2 PQ44.2(BASE)
N8974680: PQ44.1(EMITTER) PR243.2
N8974688: PQ43.2(G) PQ44.3(COLLECTOR) PR244.1
N9111136: R642.1 R643.2
N9111150: R641.1 R644.2
N17675684: C9370.1 CN5.36 R1087.2 R1088.2
N20819839: CN13.15(CPU_DBRDY1) R518.2
N20819841: CN13.13(CPU_DBRDY2) R517.2
N20819843: CN13.11(CPU_DBRDY3) R515.2
N20932838: TP137.1 U18.AL9(USB_OC3_L/TDO/AGPIO24)
N20935118: C764.1 D21.2(IN) D22.2(IN) D23.2(IN) Q36.6(D1) R560.2 R562.1
N20935208: Q36.2(G1) Q36.3(D2) R570.1
N21204781: TP80.1 U5.36(PD#)
N21204898: R93.2 U5.18(REXT)
N21318962: PC9133.2 PR292.1
N21318970: PL19.3 PR279.2 PR284.1
N21318972: PL19.4 PR285.1
N21319071: PC9137.2 PR299.1
N21319138: PR291.1 PR296.1
N21319203: PC9127.2 PR288.1
N21319230: PL18.4 PR263.1
N21319232: PL18.3 PR261.2
N21319271: PC9095.2 PR250.1
N21319291: PC9099.2 PR253.1
N21319308: PC9102.2 PR257.1
N21319358: PR275.2 PR276.1 PR280.2
N21319374: PR277.2 PR278.1 PR281.2
N21319396: PC9131.2 PR289.1
N21319416: PR264.2 PU16.35(PGOOD_NB)
N21319424: PC9105.1 PR254.1 PU16.25(VDD)
N21319498: PR251.1 PR258.1
N21319549: PC9115.2 PR274.1
N21319655: PL20.3 PR302.2 PR303.1
N21319657: PL20.4 PR304.1
N21319706: PC9103.2 PR260.1
N21319821: PC9114.1 PR271.2
N21319902: PC9132.1 PR290.2
N21320002: PC9098.1 PR252.2
N21323214: PL21.3 PR317.2 PR319.1
N21323223: PL21.4 PR322.1
N21323248: PL22.4 PR345.1
N21323250: PL22.3 PR341.2 PR344.1
N21323457: PR312.1 PU17.31(BOOT_NB)
N21323459: PR310.2 PU17.32(UGATE_NB) PU17.33(PHASE_NB)
N21323488: PR307.2 PU17.34(LGATE_NB)
N21323581: PU17.39(ISUMN_NB) PU17.40(ISUMP_NB)
N21323587: PU17.36(COMP_NB) PU17.37(FB_NB) PU17.38(VSEN_NB)
N21323694: PC9145.1 PR305.1 PU17.25(VDD)
N21323895: PR335.1 PR340.1
N21323983: PC9170.2 PR336.1
N21323993: PC9164.2 PR332.1
N21324209: PR323.2 PR324.1 PR326.2
N21324276: PC9166.2 PR333.1
N21324680: PC9149.1 PR308.2
N21324706: PC9150.2 PR313.1
N21324846: PC9161.1 PR330.2
N21324850: PC9165.2 PR334.1
N21327684: PC9208.1 PR368.2 PR510.1 PU20.4(EN)
N21327720: PR366.1 PR370.2 PU20.5(ADJ)
N21327736: PC9209.2 PR369.1
N21328285: PC9201.1 PU19.23(SS)
N21328291: PR360.1 PU19.6(TON)
N21328299: PR362.2 PR364.1 PU19.5(FB)
N21328309: PR362.1 SJ15.2(B)
N21328315: PC9202.1 PR363.1 PU19.21(VCC)
N21328341: PC9194.2 PR361.1
N21328349: PC9193.2 PC9194.1 PL24.2 PU19.10(LX1) PU19.11(LX2) PU19.16(LX3) PU19.17(LX4) PU19.18(LX5)
N21328385: PC9193.1 PR359.2
N21328393: PR359.1 PU19.20(BST)
N21328924: PR374.2 PR375.1 PU21.7(ADJ)
N21328930: PC9212.1 PR373.1 PU21.2(VEN)
N21330723: PR387.2 PR388.1 PU23.7(ADJ)
N21330729: PC9235.1 PR386.2 PR481.2 PU23.2(VEN)
N21336998: PL27.3 PR417.2 PR418.1
N21337000: PL27.4 PR419.1
N21337006: PC9259.1 PR408.2
N21337030: PC9260.2 PR412.1
N21337211: PL28.3 PR440.2 PR441.1
N21337215: PL28.4 PR444.1
N21337239: PR395.1 PR402.1
N21337282: PC9272.1 PR429.2
N21337322: PR405.1 SJ19.2(B)
N21337324: PR404.2 SJ18.2(B)
N21337361: PC9243.2 PR398.1
N21337426: PC9241.1 PR392.2
N21337478: PC9242.2 PR394.1
N21337492: PC9244.2 PR396.1
N21337509: PC9251.2 PR401.1
N21337833: PR435.1 PR439.1
N21337892: PC9278.2 PR433.1
N21337910: PC9274.2 PR431.1
N21338013: PR422.2 PR423.1 PR425.2
N21338031: PR420.2 PR421.1 PR424.2
N21338063: PC9275.2 PR432.1
N21338079: PC9253.1 PR397.1 PU24.25(VDD)
N21339343: PC9296.1 PR450.2 PU25.2(EN)
N21339361: PC9297.1 PU25.23(SS)
N21339367: PR449.2 PU25.6(TON)
N21339375: PR452.2 PR454.1 PU25.5(FB)
N21339385: PR452.1 SJ20.2(B)
N21339393: PC9298.1 PR453.1 PU25.21(VCC)
N21339411: PC9290.2 PR451.1
N21339426: PC9289.2 PC9290.1 PL29.2 PU25.10(LX1) PU25.11(LX2) PU25.16(LX3) PU25.17(LX4) PU25.18(LX5)
N21339465: PC9289.1 PR447.2
N21339473: PR447.1 PU25.20(BST)
N21342284: PC9323.1 PU27.12(CT1)
N21342286: PC9324.1 PU27.10(CT2)
N21342302: PC9320.1 PR500.1 PR501.1 PU27.5(ON2)
N21342308: PC9319.1 PR465.2 PU27.3(ON1)
N21342378: PC9325.1 PU28.12(CT1)
N21342380: PC9326.1 PU28.10(CT2)
N21342398: PC9322.1 PR499.1 PR502.1 PU28.5(ON2)
N21342406: PC9321.1 PR463.2 PU28.3(ON1)
N21417994: Q40.2(G) Q40.5(G) R1015.1 R1016.2
N22904348: PR115.2 PU9.7(TON)
N22908658: PC9219.2 PR382.1
N23370488: PC9186.1 PR353.2 PU18.2(EN)
N23370512: PR477.2 PU18.6(TON)
N23370520: PR474.1 PR478.2 PU18.5(FB)
N23370528: PR478.1 PR493.1 PR494.1
N23370536: PC9346.1 PR471.1 PU18.21(VCC)
N23370587: PC9343.1 PC9344.2 PL31.2 PU18.10(LX1) PU18.11(LX2) PU18.16(LX3) PU18.17(LX4) PU18.18(LX5)
N23379083: PC9350.1 PU18.23(SS)
N23379108: PC9343.2 PR472.1
N23379126: PC9344.1 PR475.2
N23379130: PR475.1 PU18.20(BST)
N23650304: C486.1 Q8.2 R138.1
N23650397: Q6.3(D) R122.2 R138.2
N23657334: PC9363.1 PQ71.2(G) PR505.1 PR506.1
N23657362: PC9362.1 PQ70.2(G) PR503.1 PR504.1
N23726703: PC9276.2 PR434.1
N23908431: Q41.5(G2) Q41.6(D1) R861.1
N23910724: C1190.1 U34.12(VCORE)
N23910978: D43.2(IN) U34.21(RI2#/GPD1)
N23911170: D42.1(OUT) U34.81(DAC5/RIG0#/GPJ5(3))
N23911426: C1182.2 R1071.2 U34.3(VBAT)
N23998288: PQ70.5(G) PQ70.6(D) PR175.2
N23998293: PC188.1 PQ52.4(B) PQ70.3(D) PQ73.4(B) PR178.2
N24059824: PQ71.5(G) PQ71.6(D) PR484.2
N24059826: PC9354.1 PQ53.3(G) PQ71.3(D) PR485.2
N24355958: R1021.2 U202.2(A)
N24355962: R1022.1 R1023.2 U202.1(B)
N24356422: R1024.1 R1026.2 U203.1(B)
N24356510: R1020.1 U203.2(A)
N24357397: C1239.1 R1028.2 R1029.2 U203.5(VCC)
