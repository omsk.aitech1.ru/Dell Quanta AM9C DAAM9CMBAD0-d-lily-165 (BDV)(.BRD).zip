# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V18: length 2.3
  BOTTOM w0.305: U28.24 252.18,13.13
  BOTTOM w0.508: 252.18,13.13 v1(252.18,12.58) 252.18,12.07 C1132.2
VDD10: length 4
  TOP w0.203: U2.30 274.17,89 v1(274.23,89.06) ; v1(271.59,85.4) 271.68,85.48 U2.22 ; U2.3 v1(271.68,91.42) ; v1(269.44,91.41) 269.68,91.17 U2.8
  vias: v1(273.88,90.61) v1(274.66,82.24) v1(275.06,81.37) v1(275.2,82.6)
VDDC_VMEM_EN: length 48.6
  BOTTOM w0.254: 146.69,40.85 144.2,40.85 143.37,41.68 140.21,41.68 PR414.2 ; 146.69,40.85 151.37,40.85 152.43,41.92 154.75,41.92 164.29,51.45 164.29,54.68 166.82,57.21 171.06,57.21 v1(171.34,57.5) 172.07,58.22 PR450.1 ; 146.69,40.85 146.69,39.66 147.04,39.3 R1035.1 147.82,39.23 149.21,37.84 U205.4
VSS_SENSE: length 23.2
  IN1 w0.089: v1(61.06,110.3) 60.71,110.64 57.81,110.64 56.97,111.48 54.43,111.48 52.15,113.76 v1(52.15,115.24)
  BOTTOM w0.102: v1(61.06,110.3) 60.75,109.99 60.75,107.44 61.15,107.04 U18.H12
  BOTTOM w0.114: R505.2 R503.2 R1066.2 47.52,115.82 v1(47.68,115.66) 51.73,115.66 v1(52.15,115.24)
32K_X1: length 25.2
  TOP w0.114: Y3.1 102.95,116.38 103.07,116.49 C762.1 R553.1 102.13,118.19 v1(101.37,118.95) 101.26,119.06 93.22,119.06 85.28,119.06 84.67,118.45 84.67,117.56 v2(84.6,117.48)
  BOTTOM w0.114: v2(84.6,117.48) 84.76,117.32 84.76,117.11 84.71,117.06 84.28,117.06 83.86,116.64 83.86,116.11 U18.AT1
32K_X2: length 24.1
  TOP w0.114: v2(85.19,117.48) 85.19,118.09 85.54,118.44 92.96,118.44 v1(99.51,118.44) 101,118.44 101.51,117.93 101.51,117.34 101.35,117.18 R553.2 C763.1 100.41,116.46 100.45,116.42 Y3.2
  BOTTOM w0.114: v2(85.19,117.48) 84.98,117.27 84.98,117.02 84.8,116.85 84.37,116.85 84.07,116.55 84.07,115.66 83.65,115.24 U18.AT2
48M_X1: length 9.1
  BOTTOM w0.114: Y4.1 69.31,121.56 C766.2 68.78,121.03 R586.2 68.5,120.22 68.5,117.39 67.9,116.78 67.9,116.09 67.96,116.02 67.96,115.77 67.65,115.46 U18.T2
48M_X2: length 10.8
  BOTTOM w0.114: Y4.3 68.3,124.11 68.3,122.27 C767.2 68,121.07 R586.1 68.26,120.24 68.26,117.5 67.65,116.89 U18.T1
5388_S3: length 6.1
  BOTTOM w0.114: PU9.5 21.22,43.03 21.37,43.19 21.37,43.94 PC144.1 20.33,44.99 20.33,45.58 20.77,46.02 PR479.2 PR480.2
5388_S5: length 15.6
  BOTTOM w0.114: D50.2 27.87,42.57 28.08,42.78 28.08,44.3 27.89,44.5 D52.2 26.54,44.5 26.38,44.66 v1(26.38,45.83) 26.38,46.39 25.16,47.61 24.35,47.61 PC9361.1 23.83,47.09 PR111.1 22.35,46.48 22.35,44.99 PR120.2 21.62,44.26 PU9.6
5388BST: length 2.8
  BOTTOM w0.203: v1(17.97,39.3) 18.1,39.43 18.45,39.43 18.67,39.64 PU9.27
  BOTTOM w0.508: v1(17.97,39.3) 17.15,39.3 PR469.1
5388BST_S:
  vias: v1(14.39,39.86)
5388CS: length 3.5
  BOTTOM w0.203: v1(23.99,41.56) 23.79,41.56 23.47,41.24 PU9.10
  BOTTOM w0.508: PR103.1 PC138.1 24.5,42.06 24,41.56 v1(23.99,41.56)
5388FB: length 7.3
  BOTTOM w0.203: PU9.3 20.42,42.92
  BOTTOM w0.254: PR121.1 19.4,47.58 18.83,47.58 PR113.2 18.82,47.15 18.94,47.15 19.11,46.97 19.11,44.79 19.35,44.55 PC151.1 20.31,43.86 v1(20.31,43.52) 20.31,43.46 20.42,43.35 20.42,42.92
5388FB_S: length 26.1
  TOP w0.254: v1(20.01,45.94) 21.14,44.81 v1(23.15,44.81) 24.67,44.81 28.87,40.62 28.87,31.29 27.96,30.39 26.61,30.39 26.3,30.08 26.3,29.82 SJ6.2
  BOTTOM w0.254: PC151.2 19.5,45.45 19.5,46.45 PR121.2 20.01,46.19 v1(20.01,45.94)
5388PHASE: length 9.4
  TOP w0.508: v1(22.75,36.53) 22.75,35.59 PC9219.1 ; v1(21.6,37.53) 20.83,38.31 17.89,38.31 v1(17.59,38)
  BOTTOM w0.203: PU9.25 18.76,38.84 18.58,38.67 18.25,38.67
  BOTTOM w0.508: v1(17.59,38) 17,38 PC9338.2 16.8,38.67 18.25,38.67
  vias: v1(22.87,37.22)
36001_C1: length 4
  TOP w0.114: U29.12 266,51.92 265.81,51.73 v1(264.8,51.73) 264.47,51.4 R833.2 R834.1
36001_C2: length 4.2
  TOP w0.114: R835.2 R836.1 265.01,56 v1(265.01,55.71) 265.7,55.71 266,55.4 U29.6
62771_COMP: length 5.1
  BOTTOM w0.203: PU16.19 111.7,140.64
  BOTTOM w0.254: PR287.2 PC9127.1 PC9125.1 v1(110.82,139.35) 110.82,139.76 111.7,140.64
62771_COMP_CI: length 5.8
  TOP w0.254: v1(145.47,50) 145.27,50.21 145.27,50.64 v1(145.33,50.7) 145.44,50.82 PR400.2 PC9251.1
  BOTTOM w0.203: PU24.36 144.32,49.56
  BOTTOM w0.254: PC9252.1 145.77,50 v1(145.47,50) 145.04,49.56 144.32,49.56
62771_COMP_GFX: length 7.9
  BOTTOM w0.203: PU17.19 36.37,123.29
  BOTTOM w0.254: 36.37,123.29 36.21,123.45 36.21,124.02 36.17,124.06 36.17,124.2 35.35,125.02 v1(35.35,125.5) 34.54,126.32 34.54,127.1 34.09,127.55 PR331.2 PC9162.1 33,127.82 33.31,128.12 PC9164.1
62771_COMP_GPU: length 7.2
  TOP w0.254: v1(136.41,51.77) 136.79,51.77 136.97,51.59 v1(136.97,51.41) 136.82,51.26 136.06,51.26 135.78,50.98 PC9271.1
  BOTTOM w0.203: 137.39,51.51 137.4,51.51 137.74,51.16 PU24.19
  BOTTOM w0.254: 137.39,51.51 136.11,52.79 PR430.2 PC9274.1 v1(136.41,51.77)
62771_COMP_NB: length 5.3
  TOP w0.254: PC9104.1 PC9102.1 113.31,148.17 v1(113.23,148.09)
  BOTTOM w0.203: PU16.36 113.3,146.91
  BOTTOM w0.254: 113.3,146.91 113.74,147.35 113.74,148.48 113.5,148.73 PR256.2 113.23,148.5 113.23,148.09 v1(113.23,148.09)
62771_EN: length 5.4
  TOP w0.254: PR270.2 119.06,140.7 118.04,140.7 117.78,140.95 PC9364.1 117.78,141.28 117.78,141.72 v1(117.02,142.49)
  BOTTOM w0.203: PU16.8 116.42,142.66 116.58,142.49 v1(117.02,142.49)
62771_EN_GFX: length 5.5
  TOP w0.254: v1(38.31,118.52) v1(40.2,118.52) PC9366.1 PR318.2
  BOTTOM w0.203: v1(38.31,118.52) 38.4,118.6 PU17.8
62771_EN_GPU: length 5
  BOTTOM w0.203: 139.51,46.17 139.78,46.44 PU24.8
  BOTTOM w0.254: 139.51,46.17 PC9369.2 138.84,45.2 139.06,44.98 139.06,43.62 PR414.1
62771_FB: length 12
  TOP w0.254: v1(114.05,136.99) v1(112.13,136.99) 111.32,136.99 v1(110.36,136.02)
  BOTTOM w0.203: PU16.18 112.1,140.54
  BOTTOM w0.254: v1(114.05,136.99) 113.7,136.64 PR292.2 113.47,137.29 PR295.2 ; v1(110.36,136.02) 110.59,136.25 PR288.2 110.59,137.45 PC9125.2 110.99,137.68 111.77,138.46 PR289.2 111.83,140.27 112.1,140.54
62771_FB_CI: length 7.6
  TOP w0.254: v1(145.25,48.9) 145.44,48.71 PR401.2
  BOTTOM w0.203: 144.52,49.04 144.4,49.16 PU24.37
  BOTTOM w0.254: 144.52,49.04 145.07,49.04 145.2,48.9 v1(145.25,48.9) 145.25,48.85 145.65,48.45 PR393.2 PC9252.2 146.27,49.53 147.05,50.3 PR394.2 PR396.2
62771_FB_GFX: length 9
  BOTTOM w0.203: PU17.18 36.21,122.89
  BOTTOM w0.254: PR336.2 33,126.19 PC9162.2 ; PR336.2 33.41,125.7 32.82,125.11 32.72,125.11 PR332.2 32.53,124.63 33.06,124.1 PR333.2 ; PR336.2 33.73,125.7 33.85,125.58 PR339.2 34.55,125.58 34.97,125.15 34.97,124.68 v1(35.61,124.04) 35.83,123.82 35.83,123.27 36.21,122.89
62771_FB_GPU: length 9
  TOP w0.254: PC9271.2 PR432.2 134.73,51.77 v1(134.37,51.41)
  BOTTOM w0.203: v1(136.89,51.26) 137.39,50.76 PU24.18
  BOTTOM w0.254: PR431.2 132.97,52.33 132.7,52.06 PR433.2 PR436.2 134.12,51.67 v1(134.37,51.41) 134.53,51.26 v1(136.89,51.26)
62771_FB_NB: length 9.4
  TOP w0.254: v1(115.85,148.23) 115.85,150.3 PR249.2 115.23,150.53 115.09,150.66 PR257.2 PC9104.2
  BOTTOM w0.203: PU16.37 113.7,146.74
  BOTTOM w0.254: 113.7,146.74 113.7,146.81 114.12,147.22 114.12,148.01 114.41,148.3 PR253.2 PR250.2 115.37,148.7 v1(115.85,148.23)
62771_PWROK: length 6.1
  TOP w0.254: PR273.2 119.3,140.32 117.95,140.32 117.78,140.15 PC9365.2 117.38,140.21 117.38,140.78 v1(116.9,141.25) 116.65,141.51 v1(116.65,141.96)
  BOTTOM w0.203: PU16.9 116.35,142.26 v1(116.65,141.96)
62771_PWROK_GFX: length 4.3
  TOP w0.254: PR321.2 38.91,117.66 v1(38.34,117.66) 38.03,117.66 37.76,117.39 PC9367.2 37.43,117.89 37.65,118.11 37.65,118.41 v1(37.58,118.48)
  BOTTOM w0.203: v1(37.58,118.48) 37.58,118.49 38,118.91 PU17.9
62771_PWROK_GPU: length 6.4
  BOTTOM w0.203: PU24.9 139.38,46.68
  BOTTOM w0.254: PR416.1 PC9264.2 137.41,44.21 v1(137.41,44.97) 138.23,45.79 138.6,45.79 139.38,46.57 139.38,46.68
62771_RTN: length 8.9
  BOTTOM w0.114: PR300.2 113.38,133.44 113.41,133.47
  BOTTOM w0.203: PU16.17 112.5,140.33
  BOTTOM w0.254: 112.5,140.33 112.34,140.17 112.34,137.15 112.15,136.96 112.15,136.35 112.38,136.13 113.19,136.13 113.41,135.91 PC9144.2 PR301.1 113.41,133.47
62771_RTN_GFX: length 6.2
  BOTTOM w0.203: PU17.17 36.16,122.49
  BOTTOM w0.254: 36.16,122.49 35.76,122.49 35.17,121.9 34.97,121.9 v1(34.96,121.89) 34.96,121.9 PC9178.2 33.89,121.9 32.84,120.85 PR347.1 32.73,120.92 32.3,121.36 32.2,121.36 31.95,121.61 PR346.2
62771_RTN_GPU: length 5.6
  TOP w0.254: v1(136.41,50.75) 136.87,50.29 v1(136.87,50.04) 136.55,49.72 PC9285.2 PR445.1
  BOTTOM w0.203: PU24.17 137.48,50.36
  BOTTOM w0.254: PR446.1 v1(136.41,50.75) 136.8,50.36 137.48,50.36
62771_SVC: length 4.2
  BOTTOM w0.203: 116.51,145.02 116.48,145.02 116.11,144.66 PU16.3
  BOTTOM w0.254: 116.51,145.02 116.69,145.2 116.69,145.58 116.95,145.83 116.95,146.39 v1(116.98,146.42) 118.49,146.42 PR265.2
62771_SVC_GFX: length 2.4
  BOTTOM w0.203: PU17.3 40.4,118.7
  BOTTOM w0.254: PR309.2 41.36,117.66 41.25,117.77 41.25,117.77 40.4,118.63 40.4,118.7
62771_SVC_GPU: length 4.2
  BOTTOM w0.114: PU24.3 141.78,46.3 142.09,45.99 142.81,45.99 142.85,46.03 v1(142.91,46.03) 142.94,46.03 143.15,45.82 143.97,45.82 PR406.1
62771_SVD: length 3.8
  BOTTOM w0.203: PU16.5 116.18,143.86 116.39,144.07 116.83,144.07
  BOTTOM w0.254: 116.83,144.07 116.85,144.07 117.11,144.32 117.11,144.78 v1(117.67,145.33) 117.67,145.33 117.7,145.37 PR267.2
62771_SVD_GFX: length 2.2
  BOTTOM w0.203: PU17.5 39.6,118.63
  BOTTOM w0.254: PR314.2 40.15,117.66 39.6,118.21 39.6,118.63
62771_SVD_GPU: length 2.3
  BOTTOM w0.114: PR410.1 141.54,45.55 140.98,46.11 PU24.5
62771_SVT: length 3.5
  BOTTOM w0.203: PU16.7 116.52,143.06 116.58,143.11 116.83,143.11
  BOTTOM w0.254: PR269.2 118.07,144.38 v1(117.74,144.05) 117.74,144.02 116.83,143.11
62771_SVT_GFX: length 3
  BOTTOM w0.203: PU17.7 38.8,118.84
  BOTTOM w0.254: PR316.2 37.98,117.91 v1(38.29,117.91) 38.62,117.91 38.87,118.16 38.87,118.77 38.8,118.84
62771_SVT_GPU: length 2.3
  BOTTOM w0.114: PR413.1 139.56,45.52 v1(140.07,46.03) 140.18,46.14 PU24.7
62771_VDDIO: length 2.6
  TOP w0.254: v1(116.62,143.58) 116.85,143.36 v1(117.23,143.36) PR268.2
  BOTTOM w0.203: v1(116.62,143.58) 116.49,143.46 PU16.6
62771_VDDIO_GPU: length 2.1
  BOTTOM w0.114: PU24.6 140.58,45.23 PR411.1
62771_VRHOT: length 2.9
  TOP w0.254: v1(116.63,144.52) 116.97,144.86 v1(117.23,144.86) 117.56,144.86 PR266.2
  BOTTOM w0.203: v1(116.63,144.52) 116.41,144.52 116.14,144.26 PU16.4
62771_VRHOT_GFX: length 6
  BOTTOM w0.203: PR311.2 41.01,114.47 v1(40.85,114.63) 40.76,114.73 40.76,117.71 40,118.47 PU17.4
62771_VRHOT_GPU: length 3.6
  BOTTOM w0.114: PR409.2 R1095.1 141.38,46.32 PU24.4
62771_VRHOT_GPU#_R: length 111.9
  TOP w0.114: U34.97 234.77,26.83 235.31,27.38 235.31,31.15 R1089.1 234.39,33.76 197.9,33.76 195.45,36.21 v1(195.45,36.93)
  IN1 w0.089: v1(195.45,36.93) 194.07,38.31 189.14,38.31 186.17,41.28 180.53,41.28 177.66,44.15 161.91,44.15 155.61,50.45 150.33,50.45 147.36,47.48 147.36,45.67 145.43,43.74 v1(143.57,43.74)
  BOTTOM w0.114: PR409.1 v1(143.57,43.74)
62771_VSEN: length 9.3
  BOTTOM w0.114: PR297.2 114.36,133.45 114.37,133.47
  BOTTOM w0.203: PU16.16 112.9,140.47
  BOTTOM w0.254: 112.9,140.47 v1(112.9,139.61) 112.85,139.56 PC9133.1 PR295.1 114.16,138.46 114.37,138.25 114.37,137.4 114.56,137.21 114.56,136.78 114.37,136.59 PC9136.2 PR294.2 114.37,133.47
62771_VSEN_CI: length 7.1
  TOP w0.254: v1(145.44,47.67) 145.47,47.7 PC9240.2
  BOTTOM w0.203: PU24.38 144.04,48.76 144.19,48.61
  BOTTOM w0.254: PR391.1 PR390.2 PC9242.1 PR393.1 v1(145.44,47.67) v1(144.81,48.31) 144.5,48.61 144.19,48.61
62771_VSEN_GFX: length 19.2
  BOTTOM w0.203: 35.93,122.09 PU17.16
  BOTTOM w0.254: 35.93,122.09 35.9,122.09 33.99,120.18 33.68,120.18 33.25,119.75 33.25,118.69 32.96,118.39 32.96,118.39 32.66,118.1 32.66,118.1 32.27,117.71 31.57,117.71 PC9176.2 31.19,117.88 30.41,118.65 PR338.2 v1(30.41,120.01) 31.46,121.06 31.46,122.22 32.07,122.84 32.28,122.84 PR342.2 32.28,122.92 32.27,122.92 32.27,123.08 32.53,123.34 34.29,123.34 34.78,123.84 PC9170.1 34.78,124.21 34.47,124.52 PR339.1
62771_VSEN_GPU: length 7.4
  BOTTOM w0.203: PU24.16 136.87,49.96 v1(136.68,49.77) 135.81,49.77 PR438.2
  BOTTOM w0.254: PR436.1 133.72,49.77 PC9278.1 PR442.1 134.98,48.7 PC9283.2 135.01,48.86 135.79,49.64 PR438.2
62771_VSEN_NB: length 14.3
  TOP w0.254: v1(115.2,147.91) 115.3,147.91 115.53,147.68 116.24,147.68 v1(116.36,147.81) PC9094.2 PR246.2 PR247.2 118.66,148.73 118.91,148.97 v1(118.91,150.11) 118.91,150.36 118.64,150.64 116.51,150.64 PR249.1
  BOTTOM w0.203: v1(115.2,147.91) 114.77,147.91 114.47,147.61 114.47,147.03 114.1,146.66 PU16.38
  BOTTOM w0.254: v1(118.91,150.11) 118.91,150.36 118.63,150.64 116.54,150.64 PC9095.1
+APU_VDD_33: length 10.3
  TOP w0.381: R623.2 C882.1 87.88,98.63 v1(86.02,98.63) 83.02,98.63 v2(82.58,99.07)
  BOTTOM w0.381: U18.AP19 U18.AP21 82.05,99.99 82.58,99.47 v2(82.58,99.07)
+APU_VDD_33_S5:
  vias: v1(82.6,105.27) v1(83.25,105.27) v1(83.83,105.8)
+APU_VDDIO_AZ: length 11.1
  TOP w0.381: R618.2 89.12,101.73 C830.1 C832.1 88.61,101.16 87.94,100.49 87.34,100.49 86.93,100.07 C831.1 v1(84.47,99.86) 83.18,99.86 82.82,100.21 82.82,101.01 82.6,101.23 v2(82.6,101.43)
  BOTTOM w0.381: U18.AR19 82.6,101.85 v2(82.6,101.43)
+CARD_3V:
  vias: v1(249.87,17.63) v1(250.23,19.08) v1(250.2,18.34) v1(257.24,19.83) v1(257.24,19.07)
+DC_IN: length 59.5
  TOP w0.254: v1(39.55,17.34) 38.9,16.7 38.9,14.71 39.68,13.94 PR243.1 50.19,13.94 50.82,13.31 50.82,11.32 50.81,11.32 50.81,10.89 50.82,10.89 50.82,10.47 52.78,8.5 v1(53.01,8.5)
  TOP w0.381: v1(66.56,6.94) 66.25,6.94 65.75,6.44 65.75,4.79
  TOP w0.508: PC84.1 56.35,8.08 PR61.1 ; v1(81.34,5.95) 81.34,5.42 80.72,4.79 63.95,4.79 63.69,5.06 PR515.1 61.53,5.06 61.27,4.79 56.87,4.79 56.35,5.31 PR61.1 ; PR61.1 v1(53.53,6.71)
  BOTTOM w0.254: v1(39.55,17.34) 39.42,17.47 PR185.1 PR194.1
  BOTTOM w0.381: PR228.1 v1(66.56,6.94)
  BOTTOM w0.508: PD4.2 v1(81.34,5.95)
  vias: v1(53.38,4.81)
+DC_IN_SS: length 11.8
  TOP w0.508: v1(57.24,7.9) 57.3,7.9 PC85.1
  BOTTOM w0.508: PR218.1 63.76,12.14 64.29,12.67 PR201.2 64.25,13.4 PQ30.1 62.82,13.4 62.42,13.8 62.42,14.49 62.11,14.8 61.1,14.8 60.67,14.37 60.67,14 60.14,13.46 60.14,12.12 59.02,11
  vias: v1(54.45,10.27)
+DCIN_JACK:
  vias: v3(49.31,6.84) v3(49.34,5.82)
+DOCK_PSID: length 8.4
  BOTTOM w0.114: CN11.B5 CN11.A5 49.23,8.9 v1(49.84,9.51) EL14.1
+KB_LED_PWR: length 4
  TOP w0.508: J1.1 105.45,36.91 v1(105.45,36.91) 105.96,36.4 C502.1 106.4,35.7 106.49,35.62 FS1.2
+LCDVCC:
  vias: v1(171.67,51.9) v3(171.33,52.71) v3(172.25,52.41) v3(172.56,51.66)
+LED_BL:
  vias: v1(183,49.33) v1(184.52,48.47) v1(184.52,47.82) v1(184.52,47.17)
+PWR_SRC: length 115.8
  TOP w0.381: v3(104.28,142.78) 103.75,143.31 EC140.1 102.47,143.31 EC139.1
  TOP w0.508: PC9376.2 63.57,9.38 v3(63.99,8.96)
  IN1 w0.254: v1(19.33,37.17) 19.33,37.89 19.66,38.22 19.66,41.97 18.68,42.94 18.68,44.23 19.47,45.02 22.63,45.02 23.05,45.44 v1(23.05,45.95)
  IN1 w1.524: 20.9,62 24.22,65.33 24.22,73.67 27.9,77.34 27.9,88.98 30.82,91.91 30.82,95.06 29.74,96.14 29.74,118.65 31.68,120.59 31.68,122.41 29.74,124.35 29.74,127.83 30.62,128.71 34,128.71 34.7,128.01 36.21,128.01 36.94,128.73 39.13,128.73
  BOTTOM w0.203: 150.2,7.95 150.07,8.08 PU2.12
  BOTTOM w0.254: v1(23.05,45.95) PR115.1
  BOTTOM w0.508: v3(20.01,3.16) 20.25,3.4 C9398.1 ; CS6.2 183.15,34.27 v1(183.04,34.39) ; 150.2,7.95 PC247.1 150.78,7.39 151.44,6.73 153.28,6.73 155.41,8.86 PC240.1 ; v3(47.36,127.83) 47.36,127.24 v3(46.96,126.84) 46.27,127.52 v3(46.27,127.67) 46.27,127.92 47,128.65 v3(47,128.77) 46.29,129.47 C9404.1
  vias: v1(16.09,32.4) v1(16.08,31.75) v1(16.08,31.09) v1(16.15,30.45) v1(16.73,32.4) v1(16.73,31.75) v1(16.73,31.09) v1(16.8,30.44) v1(17.34,32.14) v1(17.34,31.49) v1(17.34,30.83) v1(17.55,35.61) v1(17.97,32.98) v1(17.97,32.33) v1(17.97,31.67) v1(17.97,31.01) v1(18.2,35.61) v1(18.48,37.47) v1(19.98,37.17) v1(39.1,108.11) v1(39.66,111.13) v1(80.38,9.38) v1(80.63,144.61) v1(98.44,145.88) v1(139.14,9.82) v1(139.79,9.82) v1(140.44,9.82) v1(141.08,9.82) v1(141.73,9.82) v1(142.25,8.9) v1(144.9,31.65) v1(150.99,57.05) v1(159.88,65.38) v1(161.56,9) v1(165.4,63.82) v1(165.88,61.42) v1(166.05,63.82) v1(166.7,63.82) v1(166.92,61.59) v1(166.92,60.94) v1(167.57,61.57) v1(167.58,60.92) v1(180.68,42.91) v1(181.33,42.91) v1(181.98,42.91) v3(8.34,26.75) v3(9.25,26.75) v3(10.18,26.75) v3(11.59,5.42) v3(16.52,4.65) v3(16.54,3.17) v3(18.17,3.13) v3(19.94,4.4) v3(21.12,58.68) v3(22.82,60.51) v3(22.82,58.68) v3(38.29,106.82) v3(38.45,107.63) v3(39.31,111.82) v3(40.07,111.82) v3(40.83,111.82) v3(60.48,144.4) v3(61.23,144.41) v3(61.98,144.4) v3(63.99,8.2) v3(63.99,7.45) v3(63.99,6.7) v3(63.99,5.95) v3(64.74,8.96) v3(64.74,8.2) v3(64.74,7.45) v3(64.74,6.7) v3(64.74,5.95) v3(65.74,144.96) v3(66.49,145.52) v3(67.25,145.52) v3(68.01,145.52) v3(68.91,144.14) v3(69.72,144.15) v3(70.47,144.14) v3(71.28,144.46) v3(78.42,145.27) v3(78.42,144.51) v3(79.19,145.27) v3(79.19,144.51) v3(84.83,5.57) v3(85.2,4.91) v3(85.59,5.57) v3(86.36,5.57) v3(87.12,5.57) v3(91.86,141.94) v3(92.14,142.73) v3(92.63,141.94) v3(92.9,142.73) v3(93.39,141.94) v3(94.15,141.94) v3(102.65,14.13) v3(102.65,13.37) v3(102.65,12.61) v3(103.4,14.13) v3(103.4,13.37) v3(103.4,12.61) v3(104.15,14.16) v3(104.15,13.4) v3(104.9,14.11) v3(104.9,13.35) v3(128.78,58.02) v3(130.92,57.94) v3(131.81,57.9) v3(132.75,57.9) v3(133.64,57.9) v3(142.12,16.21) v3(142.89,16.21) v3(143.65,16.21) v3(144.41,16.21) v3(144.66,32.72) v3(144.94,33.43) v3(146.46,57.85) v3(147.38,57.84) v3(147.95,33.25) v3(147.97,32.42) v3(148.24,57.85) v3(148.79,33.22) v3(149.16,57.82) v3(149.98,57.76) v3(154.5,55.73) v3(154.5,54.84) v3(154.5,54.08) v3(155.26,55.73) v3(155.26,54.84) v3(155.26,54.08) v3(156.4,13.82) v3(156.83,13.19) v3(157.42,57.24) v3(157.59,13.94) v3(157.59,13.18) v3(157.89,58.13) v3(158.04,66.67) v3(158.31,57.24) v3(158.8,66.67) v3(159.56,66.67) v3(159.85,63.02) v3(159.88,62.08) v3(159.88,61.29) v3(159.88,60.45) v3(159.87,59.62) v3(164.51,59.84) v3(164.53,59.09) v3(165.41,58.77) v3(166.16,58.77)
+RTC_1: length 2.9
  TOP w0.508: RTCR1.1 274.79,4.3 v1(275.35,3.74)
  BOTTOM w0.508: RTCBT1.1 v1(275.35,3.74)
+SMDDR_VREF: length 2.7
  BOTTOM w0.203: PU9.1 19.62,42.97
  BOTTOM w0.254: 19.62,42.97 v1(18.9,43.69) 18.61,43.98 PC147.1
+SMDDR_VTT: length 68.5
  TOP w0.762: v1(17.76,45.5) 17.76,46.69 18.28,47.22 24.44,47.22 30.14,41.52 30.14,36.2 34.9,31.43 55.7,31.43 58.48,34.22 65.98,34.22 v1(66.76,33.43)
  BOTTOM w0.203: PU9.29 18.11,40.44 17.95,40.6 17.79,40.75 17.79,41.2 ; PU9.31 18.67,41.24 18.36,41.55
  BOTTOM w0.254: v1(106.54,55.69) 105.94,55.69 105.48,56.15 CN17.258 ; v1(105.8,46.56) 105.8,46.26 105.48,45.93 CN16.258
  vias: v1(16.47,45.27) v1(17.78,44.78) v1(67.68,33.46) v1(107.97,45.1) v1(107.98,44.45) v1(108.48,55.7) v1(108.48,55.04)
+USB_RE_PWR: length 1.7
  TOP w0.508: v1(268.23,56.84) 267.67,57.39 R835.1
  vias: v1(265.82,49.36) v1(266.1,50.63) v1(266.21,49.89) v1(266.59,49.36) v1(268.08,53.68) v1(268.77,53.7)
+USB_SIDE3_PWR: length 7.5
  IN1 w0.762: 274.89,49.18 277.09,49.18 CN8.1
  IN4 w0.762: CN8.1 277.1,49.17 274.73,49.17
  BOTTOM w0.762: CN8.1 277.08,49.19 274.67,49.19
  vias: v1(264.42,46.71) v1(265.05,47.37) v1(265.1,46.72) v1(266.03,47.88) v1(270.31,47.04) v1(271.41,47.88) v1(272.27,47.92)
+V_VDDQ: length 120.1
  TOP w0.508: CS3.1 80.83,26.55 v1(80.63,26.76)
  BOTTOM w0.203: v1(75.59,89.95) 75.65,90.01 U18.AF33
  BOTTOM w0.25: v1(78.95,89.84) 78.95,89.87 78.85,89.97 U18.AK33 ; v1(71.87,93.95) 71.87,93.47 72.06,93.28 72.07,93.28 U18.AB30 ; U18.AB33 72.46,90.89 v1(72.46,89.97) ; v1(80.16,92.17) 80.45,92.46 U18.AM30 ; U18.V33 69.27,90.88 69.27,90.01 v1(69.14,89.88) ; U18.AF30 75.65,93.04 v1(75.37,93.32) ; U18.AK30 v1(78.85,92.28) ; U18.AD30 v1(74.05,92.3)
  BOTTOM w0.254: CN17.153 79.23,64.51 v1(79.08,64.37) ; v1(67.29,59.48) 67.08,59.48 66.79,59.19 66.79,58.6 66.97,58.41 CN17.112 ; CN16.148 77.98,46.35 v1(77.46,46.87) ; v1(71.29,54.37) 70.06,54.37 69.73,54.04 CN16.123 ; v1(80.26,56.1) 80.62,56.1 80.97,56.46 CN17.160 ; U18.Y30 71.04,92.9 71.42,93.27 71.43,93.27 71.6,93.44 71.9,93.44 ; v1(80.73,51.78) CN16.159 ; CN17.148 77.97,59.11 78.3,59.44 v1(78.47,59.44) ; CN17.147 77.73,63.94 76.69,62.9 75.48,62.9 v1(75.47,62.89) ; CN16.118 68.48,46.48 68.85,46.84 v1(68.97,46.84) ; CN16.141 74.23,50.63 73.17,49.56 v1(72.76,49.56) ; CN17.163 81.73,63.69 v1(80.22,62.18) ; CN17.159 80.73,64.08 80.3,63.66 v1(80.21,63.66) ; CN16.154 79.48,46.57 79.13,46.92 v1(78.98,46.92) ; CN17.124 69.97,59.17 70.22,59.42 v1(70.47,59.42) ; CN17.136 72.97,58.72 v1(73.04,58.78) ; CN17.135 72.73,64.55 72.54,64.36 72.54,62.89 73.15,62.29 v1(74.23,62.29) ; CN16.153 79.23,52.07 v1(78.93,51.77) ; v1(80.98,46.18) CN16.160 ; v1(80.79,50.45) 81.73,51.39 CN16.163 ; CN16.124 69.98,46.19 v1(69.94,46.23) ; v1(74.94,59.57) 74.48,59.1 CN17.142 ; CN17.117 68.23,64.56 v1(67.78,64.11) ; CN16.111 66.73,51.94 66.46,51.67 64.88,51.67 v1(64.28,51.06) ; v1(74.48,47.73) CN16.142 ; CN17.118 68.48,59.15 68.82,59.49 v1(68.97,59.49) ; v1(71.72,63.54) 71.6,63.54 71.23,63.92 CN17.129 ; CN17.141 v1(74.23,64.37) ; CN16.129 71.23,51.78 v1(71.23,51.77) ; CN17.111 66.73,64.69 66.41,64.37 v1(66.41,64.19) ; v1(71.71,58.87) 71.48,58.64 CN17.130 ; v1(72.98,46.18) CN16.136 ; CN16.117 68.23,51.53 65.95,49.26 v1(65.44,49.26) ; v1(80.2,59.43) 79.73,59.43 79.48,59.17 CN17.154 ; CN17.123 69.73,64.41 v1(69.58,64.27) ; v1(76.52,50.78) 77.73,51.99 CN16.147 ; CN16.112 66.98,46.58 66.64,46.92 v1(66.43,46.92) ; CN16.130 71.48,46.37 71.03,46.82 v1(70.96,46.82) ; CN16.135 v1(72.73,51.77)
  BOTTOM w0.279: U18.AH30 76.66,93.49 v1(76.66,93.95)
  BOTTOM w0.305: v1(76.66,93.95) 76.6,93.95 U18.AG28 ; U18.AH27 76.66,94.71 v1(76.66,94.64) ; U18.AD25 74.04,97.29 v1(74.44,97.29) 74.85,97.7 U18.AE24 ; U18.AD28 73.92,94.5 v1(74.33,94.92)
  BOTTOM w0.356: v1(69.63,93.34) 69.25,92.96 U18.V30 ; v1(77.53,97.47) 77.25,97.75 U18.AH24
  BOTTOM w0.38: v1(71.82,97.35) 72.45,97.98 U18.AB24 ; v1(70.65,94.54) 70.66,94.53 71.22,94.53 U18.Y28 ; v1(65.9,94.28) 66.06,94.28 66.28,94.5 U18.P28 ; v1(75.53,96.6) 75.78,96.6 76.05,96.87 U18.AG25 ; v1(67.05,95) 67.35,95.3 U18.T27 ; v1(69.69,97.32) 70.05,97.68 U18.W24 ; U18.U25 68.85,97.22 v1(69.05,97.42) ; U18.W27 70.05,95.29 v1(69.66,94.9) ; v1(74.33,94.92) 74.47,94.92 U18.AE27 ; U18.AL27 79.57,95.3 v1(79.15,94.88) ; v1(71.88,95.38) 72.37,95.38 U18.AB27 ; U18.T24 67.24,97.59 v1(67.24,97.39) ; v1(70.65,96.68) 71.03,96.68 U18.Y25 ; v1(65.92,96.33) 65.92,96.37 U18.P25
  BOTTOM w0.381: v1(79.15,94.88) 78.83,94.88 U18.AK28 ; R464.1 77.38,85.65 v1(77.81,86.08) ; v1(77.53,97.47) 77.88,97.47 U18.AK25 ; v1(68.42,94.9) 68.81,94.5 U18.U28
  vias: v1(23.07,29.7) v1(23.07,29.05) v1(23.07,28.4) v1(23.72,29.7) v1(23.73,29.05) v1(23.72,28.4) v1(27.7,29.09) v1(30.72,32.87) v1(65.27,88.63) v1(66.38,87.64) v1(68.32,87.74) v1(69.05,85.39) v1(69.9,88.27) v1(69.94,86.63) v1(71.39,85.21) v1(72.49,87.99) v1(73.71,90.26) v1(73.74,88.31) v1(73.75,86.33) v1(75.55,87.99) v1(75.58,86.53) v1(76.68,87.2) v1(77.6,89.19) v1(78.99,87.82) v1(80.48,89.81) v1(80.48,87.7) v3(25.67,34.8) v3(25.67,34.04) v3(25.67,33.28) v3(26.41,34.81) v3(26.41,34.05) v3(26.41,33.28) v3(27.16,34.82) v3(27.16,34.06) v3(27.16,33.3) v3(65.57,43.52) v3(67.06,43.55) v3(68.47,43.55) v3(69.76,43.51) v3(71.09,43.52) v3(72.28,43.51) v3(73.55,43.52) v3(74.76,43.54) v3(75.97,43.53) v3(77.15,43.52) v3(78.23,43.52) v3(79.32,43.52) v3(80.39,43.53)
+VCHGR: length 31.4
  TOP w0.508: v1(81.34,6.86) 86.24,6.86 86.67,6.43 90.54,6.43 92.93,8.82 107.33,8.82 108.33,9.82 v3(108.33,10.89)
  BOTTOM w0.508: PD3.2 81,7.88 81.34,7.54 v1(81.34,6.86)
  vias: v1(108.8,10.11) v3(109.26,10.89) v3(110.35,10.86) v3(111.24,10.86)
+VCHGR_P: length 30.2
  TOP w0.508: v1(95.98,14.51) 95.98,14.53 93.64,16.87 68.51,16.87 v1(67.86,17.53)
  BOTTOM w0.508: PR190.2 v1(67.86,17.53)
  vias: v1(100.57,10.29) v3(95.14,12.41) v3(95.15,10.49) v3(98.23,11.7) v3(98.26,10.21) v3(102.97,11.27) v3(103.01,9.88) v3(104.16,11.28) v3(104.16,9.87)
+VGPU_CORE: length 152.2
  IN3 w0.254: v1(134.37,50.09) 134.3,50.09 132.4,51.99 130.24,51.99 123.71,58.52 123.71,70.62 124.31,71.22 124.31,75.98 125.19,76.87 126.25,76.87 v3(126.84,77.45)
  BOTTOM w0.254: v1(135.85,102.65) U22.W31 ; v1(134.37,50.09) 134.73,49.74 PR438.1 ; 139.85,102.65 U22.W21 139.85,103.65
  BOTTOM w0.3: U22.R21 v1(139.85,105.65) U22.N21 ; U22.R21 v1(139.85,104.65) U22.U21 ; U22.R21 140.51,104.99 140.51,104.31 U22.U21 ; U22.U21 139.85,103.65
  BOTTOM w0.305: v1(135.85,101.65) U22.AC31
  BOTTOM w0.356: U22.AC31 v1(135.85,100.65) U22.AE29 136.59,99.91 136.59,99.39 U22.AG29 ; U22.AG29 v1(135.85,99.65) U22.AE31 ; U22.AG29 v1(135.85,98.65) ; v1(135.85,98.65) U22.AJ31 v1(135.85,97.65) ; v1(135.85,98.65) U22.AG31 ; U22.AC21 v1(139.85,101.65) U22.AA21 139.85,102.65 ; U22.W29 v1(135.85,103.65)
  BOTTOM w0.381: U22.AJ15 143.3,98.15 v1(142.85,97.7) ; U22.AJ15 U22.AG13 ; U22.AJ15 143.78,97.72 ; 143.87,99.63 144.02,99.78 144.02,99.82 U22.AE13 v1(143.85,100.65) ; 138.87,97.63 U22.AL23 ; 138.87,97.63 138.87,97.67 U22.AJ23 ; 138.87,97.63 138.83,97.63 U22.AL25 138.35,96.9 v1(138.7,96.55) ; U22.U29 v1(136.77,103.73) 136.77,103.57 U22.W29 v1(135.85,102.65) ; U22.R31 135.29,105.15 v1(134.86,104.72) 135.35,104.23 U22.U31 ; v1(143.85,100.65) U22.AE15 ; v1(143.85,100.65) U22.AC13 ; U22.AE21 U22.AC21 U22.AE23 U22.AE21 ; U22.AE21 U22.AG21 ; 136.85,97.65 U22.AL27 137.84,97.64 137.86,97.64 137.86,97.66 U22.AJ25 ; U22.N15 143.84,105.66 v1(144.1,105.66) ; U22.N13 144.1,105.89 v1(144.1,105.66) ; v1(144.1,105.66) 144.1,105.4 U22.R13 ; U22.W13 v1(143.85,102.65) U22.AA15
  BOTTOM w0.4: 143.82,97.62 U22.AL15 v1(142.85,97.7) ; 143.82,97.62 144.25,97.19 144.31,97.19 U22.AL13 ; 143.82,97.62 U22.AJ13 ; 143.82,97.62 143.82,97.68 143.78,97.72 ; U22.AC15 v1(142.85,100.65) 142.91,100.59 U22.AE15 143.87,99.63 U22.AG13 ; U22.AC15 143.85,101.65 ; U22.AC15 143.41,101.09 v1(143.85,100.65) ; U22.R23 139.14,105.36 139.14,105.94 U22.N23 v1(139.85,105.65) U22.R23 ; U22.R23 v1(139.85,104.65) U22.U23 139.85,103.65 U22.W23 139.85,102.65 U22.AA23 138.97,101.77 v1(138.97,101.69) 138.97,101.53 U22.AC23 ; U22.AC23 U22.AE23 U22.AG23 ; U22.AC23 v1(139.85,101.65) ; v1(140.85,97.7) U22.AJ19 141.61,98.41 142.09,98.41 U22.AJ17 ; v1(140.85,97.7) 140.42,98.09 U22.AJ21 ; v1(140.85,97.7) U22.AL19 U22.AJ17 ; v1(140.85,97.7) U22.AL21 139.93,97.61 v1(139.85,97.7) ; v1(139.85,97.7) U22.AL23 139.3,97.15 v1(138.7,96.55) ; v1(139.85,97.7) U22.AJ23 ; v1(139.85,97.7) U22.AJ21 ; U22.AJ27 136.88,98.62 ; U22.AJ27 U22.AL25 ; U22.AJ27 136.85,97.65 ; U22.AJ27 v1(137.85,98.65) U22.AJ25 v1(138.85,98.65) ; 136.88,98.62 136.82,98.62 U22.AJ29 ; 136.88,98.62 U22.AG29 ; U22.N29 135.85,105.65 ; 135.85,105.65 U22.R29 ; 135.85,105.65 135.82,105.65 135.35,105.17 U22.R31 135.38,105.15 135.85,104.67 135.85,104.65 ; 135.85,105.65 U22.N31 ; U22.AA13 144.3,102.1 144.25,102.1 143.85,101.7 143.85,101.65 ; 136.85,97.65 U22.AJ29 ; 136.85,97.65 U22.AL29 v1(135.85,97.65) ; U22.AJ29 v1(135.85,97.65) ; U22.AA29 v1(135.85,101.65) ; U22.AA29 136.6,101.9 136.6,101.4 U22.AC29 ; U22.AA29 v1(135.85,102.65) U22.AA31 v1(135.85,101.65) ; v1(135.85,101.65) U22.AC29 ; U22.AJ15 143.35,98.17 142.86,98.66 ; U22.AJ23 v1(139.85,98.65) U22.AG21 v1(140.85,98.65) U22.AJ21 ; U22.AJ23 v1(138.85,98.65) ; 142.86,98.66 U22.AG15 ; 142.86,98.66 U22.AJ17 ; U22.AJ17 v1(142.85,97.7) ; U22.R15 143.13,105.37 143.13,105.93 U22.N15 ; U22.R15 v1(143.85,104.65) ; U22.R15 v1(142.85,104.65) U22.U15 ; 143.85,101.65 U22.AA15 v1(142.85,102.65) U22.W15 ; 143.85,101.65 U22.AC13 ; 135.85,104.65 U22.U29 ; 135.85,104.65 U22.R29 ; 135.85,104.65 U22.U31 135.38,104.15 135.85,103.68 v1(135.85,103.65) ; v1(138.85,98.65) U22.AG23 ; v1(143.85,104.65) 143.85,104.67 144.33,105.15 U22.R13 ; v1(143.85,104.65) U22.U13 U22.W15 ; v1(143.85,104.65) U22.U15 ; U22.W15 142.85,103.65 U22.U15 ; U22.W15 v1(143.85,102.65) ; U22.AC29 v1(136.85,100.65) U22.AE29 v1(135.85,99.65) U22.AG31 ; U22.AC29 v1(135.85,100.65) U22.AE31 ; U22.U29 v1(135.85,103.65) ; U22.U29 v1(136.85,104.65) U22.R29 ; U22.AE21 U22.AG23 ; v1(135.85,103.65) U22.W31 ; v1(135.85,97.65) U22.AL31 ; v1(142.85,97.7) U22.AL17
  vias: v1(141.62,77.83) v3(126.84,78.21) v3(126.84,76.51) v3(126.84,75.75) v3(127.15,79.29) v3(127.6,78.21) v3(127.6,77.45) v3(127.6,76.51) v3(127.6,75.75) v3(127.91,79.29) v3(128.51,75.62) v3(128.69,79.3) v3(129.45,79.3) v3(129.48,75.66) v3(131.88,79.69) v3(132.65,79.69) v3(133.41,79.69) v3(134.19,79.69) v3(134.56,78.8) v3(134.56,78.03) v3(134.56,77.09) v3(134.56,76.33) v3(134.53,75.54) v3(134.97,79.66) v3(135.29,75.54) v3(135.32,78.8) v3(135.32,78.03) v3(135.32,77.09) v3(135.32,76.33) v3(136.08,75.11) v3(136.11,75.87) v3(136.88,75.87) v3(136.87,75.11) v3(137.64,75.87) v3(137.67,75.11) v3(138.4,75.87) v3(138.43,75.11) v3(139.26,80.5) v3(139.26,79.74) v3(139.2,78.96) v3(139.24,78.21) v3(139.24,77.44) v3(139.26,76.68) v3(139.29,75.89) v3(139.25,75.11) v3(140.02,80.5) v3(140.02,79.74) v3(140.01,78.98) v3(140.01,78.21) v3(140.01,77.44) v3(140.03,76.68) v3(140.05,75.89) v3(140.09,75.09) v3(140.78,80.5) v3(140.78,79.74) v3(141.54,80.49) v3(141.57,79.73) v3(142.34,80.5) v3(142.34,79.74) v3(143.1,80.5) v3(143.1,79.74) v3(143.87,80.5) v3(143.87,79.74) v3(144.63,80.5) v3(144.63,79.74)
+VREF_CA_A0: length 1.3
  BOTTOM w0.254: CN16.164 81.98,46.18 v1(81.98,46.18)
  vias: v1(86.53,52.81)
+VREF_CA_B0: length 3.2
  BOTTOM w0.254: v1(80.25,55.38) 80.89,55.38 81.97,56.47 CN17.164
  vias: v1(86.42,56.49)
AC_PRESENT: length 292.2
  TOP w0.114: v1(229.05,24.69) 228.77,24.97 U34.112 228.77,28.42 R1005.1 ; v2(80.95,122.03) 82.81,120.16 102.87,120.16 110.72,112.31 110.72,92.86 107.38,89.52 107.38,77.44 115.38,69.45 115.38,61.92 116.54,60.76 116.54,56.47 117.85,55.15 117.85,49.51 115.87,47.53 115.87,38.23 115.55,37.91 115.55,36.59 111.46,32.49 111.46,26.94 112.96,25.44 112.96,23.79 115.97,20.78 125.33,20.78 127.57,23.02 130.16,23.02 131.26,24.12 134.92,24.12 135.53,23.51 135.53,22.71 136.89,21.36 158.52,21.36 159.79,20.08 180.59,20.08 185.43,15.25 189.65,15.25 195.67,9.23 202.39,9.23 v1(203.09,9.93)
  BOTTOM w0.102: 77.42,118.97 76.78,118.32 76.78,116.7 76.97,116.51 76.97,116.09 76.82,115.93 76.82,115.07 U18.AG3
  BOTTOM w0.114: v1(203.09,9.93) 203.16,9.93 204.39,11.16 204.39,19.74 212.99,28.35 217.6,28.35 218.73,29.47 v1(219.22,29.47) 219.22,29.96 220.4,31.15 220.75,31.15 221.04,30.86 221.04,25.74 222.66,24.12 228.47,24.12 v1(229.05,24.69) ; v2(80.95,122.03) 81.17,121.81 81.17,119.97 80.32,119.12 77.57,119.12 77.42,118.97
ACAV_IN: length 209.8
  TOP w0.254: D43.1 v1(214.36,16.74)
  IN3 w0.254: v1(66.49,6.3) 66.79,6.3 69.17,3.91 88.81,3.91 92.92,8.02 99.4,8.02 103.26,4.16 150.48,4.16 153.14,6.82 154.22,6.82 156.36,8.96 180.65,8.96 185.49,13.8 190.89,13.8 195.68,18.59 212.52,18.59 v1(214.36,16.74)
  IN4 w0.254: v1(39.13,10.01) 50.75,10.01 51.5,10.76 64.81,10.76 66.04,9.53 66.04,6.73 66.47,6.3 v1(66.49,6.3) ; v1(225.64,16.69) 224.73,15.78 223.76,15.78 223.46,16.08 222.26,16.08 221.25,15.07 216.04,15.07 v1(214.36,16.74)
  BOTTOM w0.254: PR230.1 69.61,7.22 68.75,6.36 PR236.1 PR237.2 67.36,6.3 v1(66.49,6.3) ; v1(225.64,16.69) 226.04,16.29 Q30.2 ; PQ36.2 v1(39.13,10.01)
ACCEL_INTH#_R: length 1.4
  TOP w0.114: TP254.1 87.81,101.98 87.68,102.11 v2(87.35,102.11)
  BOTTOM w0.102: v2(87.35,102.11) 87.35,102.12 87.67,101.8 U18.BA19
ACZ_BCLK_R: length 3.9
  TOP w0.114: v2(85.22,112.73) 85.45,112.73 86.21,113.48 R534.1 86.09,113.9 86.09,114.82 R561.2
  BOTTOM w0.102: U18.AU6 84.88,112.73 v2(85.22,112.73)
ACZ_RST#_R: length 8.1
  TOP w0.114: R563.2 88.91,113.49 88.85,113.43 R540.1 89.26,112.18 89.26,111.45 89.09,111.28 88.14,111.28 87.38,110.52 86.31,110.52 85.83,110.03 v2(85.38,110.03)
  BOTTOM w0.102: v2(85.38,110.03) 84.75,109.4 U18.AU9
ACZ_SDIN1: length 1.7
  TOP w0.114: v2(81.58,112.06) 82.15,112.06 82.33,111.87 R537.1
  BOTTOM w0.102: v2(81.58,112.06) 81.81,112.06 U18.AP6
ACZ_SDIN2: length 1.3
  TOP w0.114: v2(82.7,113.11) 82.63,113.18 R538.1
  BOTTOM w0.102: v2(82.7,113.11) 82.71,113.12 83.23,113.12 U18.AR5
ACZ_SDOUT_R: length 6.4
  TOP w0.114: v2(83.89,111.69) 83.89,112.33 84.49,112.93 84.49,114.63 R544.1 84.51,116.2 R558.2
  BOTTOM w0.102: 83.41,111.66 83.45,111.69 v2(83.89,111.69)
  BOTTOM w0.114: U18.AR7 83.41,111.66
ACZ_SPKR: length 4.8
  TOP w0.114: CN5.24 22.7,12.8 23.03,12.47 24.64,12.47 24.89,12.73 v1(24.89,13.57) 25.27,13.95 R1052.2
ACZ_SPKR_R: length 193.9
  TOP w0.114: v1(27.6,15) 27.6,14.08 27.6,14.08 v1(27.6,13.97) 27.58,13.95 R1052.1 ; v1(107.26,94.93) 105.02,92.68 105.02,76.37 111.04,70.35 111.04,69.65 113.05,67.64 113.05,59.08 113.79,58.35 113.79,39.09 113.47,38.77 113.47,37.45 109.36,33.34 109.36,29.29 108.84,28.77 108.84,20.96 v1(109.18,20.61)
  IN4 w0.089: v1(109.18,20.61) 108.94,20.85 63.13,20.85 61.28,19 55.9,19 55.16,18.27 52.22,18.27 49.62,15.67 32.01,15.67 30.64,14.3 28.3,14.3 v1(27.6,15)
  BOTTOM w0.102: 97.37,102.72 97.36,102.72 93.86,102.72 93.45,103.13 90.53,103.13 90.3,102.89 89.14,102.89 88.98,103.05 88.1,103.05 U18.BA17
  BOTTOM w0.114: 97.37,102.72 98.14,102.72 98.69,102.17 98.69,101.17 99.13,100.73 105.23,100.73 107.26,98.7 v1(107.26,94.93)
ACZ_SYNC_R: length 9.5
  TOP w0.114: v2(84.78,109.98) 85.14,109.62 86.79,109.62 88.07,110.9 89.02,110.9 89.48,111.36 89.48,112.15 R542.1 89.87,112.62 R559.2
  BOTTOM w0.102: v2(84.78,109.98) 84.78,109.98 84.62,109.98 84.03,109.4 U18.AT9
ADBIA0: length 30.8
  TOP w0.102: 139.3,112.76 139.3,112.45 139.25,112.4 139.25,108.88 139.4,108.73 v1(139.81,108.73) ; v1(135.1,133.02) 135.53,132.59 135.53,131.86
  TOP w0.14: 139.3,112.76 139.3,117.99 137.39,119.9 137.39,121.36 137.53,121.5 138.26,121.5 138.39,121.63 138.39,121.94 138.26,122.06 137.53,122.06 137.39,122.2 137.39,122.48 137.53,122.62 138.36,122.62 138.5,122.76 138.5,126.11 v1(138.12,126.49) 137.24,127.37 137.24,129.81 136.43,130.61 136.43,130.95 135.53,131.86
  BOTTOM w0.14: v1(139.81,108.73) 140.13,108.73 U22.H21 ; v1(135.1,133.02) 134.75,133.37 VRAM1.J4
ADBIA1: length 29.3
  TOP w0.102: v1(147.18,133.04) 146.78,132.63 146.78,131.99 146.62,131.83 145.37,131.83 ; 142.45,112.65 142.61,112.49 142.61,109.96 v1(142.09,109.44)
  TOP w0.14: 142.45,112.65 142.09,113.01 142.09,119.1 143.11,120.12 v1(143.11,128.93) 143.11,131.25 143.57,131.7 144.87,131.7 144.99,131.83 145.37,131.83
  BOTTOM w0.14: v1(142.09,109.44) 141.6,108.95 U22.H19 ; v1(147.18,133.04) 147.18,133.07 147.55,133.44 VRAM2.J4
ADBIB0: length 32.8
  TOP w0.102: 169.31,107.97 169.31,108.25 169.59,108.52 170.26,108.52 v1(170.72,108.99)
  TOP w0.11: v2(147.6,103.75) 148.31,104.45 149.46,104.45 149.7,104.21 150.44,104.21 150.8,103.85
  TOP w0.14: 150.8,103.85 151.88,102.78 156.16,102.78 156.24,102.86 165.44,102.86 v1(166.43,103.85) 166.43,104.89 166.28,105.04 165.16,105.04 164.9,105.3 164.9,106.75 165.22,107.06 168.82,107.06 169.31,107.55 169.31,107.97
  BOTTOM w0.14: v2(147.6,103.75) 147.6,103.7 U22.W8 ; VRAM3.J4 171.07,109.34 v1(170.72,108.99)
ADBIB1: length 32.1
  TOP w0.102: 168.45,98.21 168.45,97.63 168.2,97.37 168.2,97.22 168.48,96.94 169.84,96.94 169.95,96.83 169.95,96.67 169.84,96.56 169.21,96.56 169.09,96.43 169.09,95.88 169.21,95.75 170.31,95.75 v1(170.71,95.35) ; v2(146.8,101.67) 146.8,101.15 146.97,100.98 150.24,100.98 150.65,100.57 151.02,100.57
  TOP w0.14: 168.45,98.21 168.45,99.89 168.27,100.06 v1(159.87,100.06) 153.06,100.06 152.68,100.45 151.54,100.45 151.41,100.57 151.02,100.57
  BOTTOM w0.14: v2(146.8,101.67) 146.8,101.8 U22.AA8 ; VRAM4.J4 v1(170.71,95.35)
AGPIO3: length 3.8
  TOP w0.114: R595.2 79.71,114.54 R605.1 79.71,113.71 v2(80.32,113.1)
  BOTTOM w0.102: U18.AL5 v2(80.32,113.1)
AGPIO5: length 13.4
  BOTTOM w0.102: 82.19,118.45 82.72,118.45 83.63,119.36 84.9,119.36 85.54,119.99 ; 77.85,118.45 82.07,118.45 82.08,118.45
  BOTTOM w0.114: R545.2 R1092.1 85.66,120.77 85.66,120.12 85.54,119.99 ; 82.19,118.45 82.08,118.45 ; U18.AJ1 78.05,116.38 77.45,116.98 77.45,118.04 77.85,118.45
AGPIO8: length 13.9
  BOTTOM w0.102: U18.AJ4 77.64,114.31 77.64,115.55 77.76,115.67 77.76,116.16 77.41,116.51
  BOTTOM w0.114: R1093.1 R546.2
  BOTTOM w0.127: R1093.1 83.13,121.27 TP322.1 82.74,120.88 82.74,120.13 81.28,118.67 77.76,118.67 77.22,118.13 77.22,116.89 77.41,116.7 77.41,116.51
AGPIO10: length 8.7
  TOP w0.114: R543.1 71.09,115.88 72.92,115.88 73.41,115.39 74.17,115.39 75.03,114.52 75.03,112.18 v2(75.26,111.95)
  BOTTOM w0.102: v2(75.26,111.95) 75.26,111.41 75.17,111.32 75.17,111.02 U18.AE8
AGPIO11: length 6.2
  TOP w0.114: R597.2 81.84,115.42 R607.2 82.73,114.7 v1(81.45,113.42) 80.47,112.44 v2(80.21,112.44)
  BOTTOM w0.102: U18.AN5 80.85,112.95 80.34,112.44 v2(80.21,112.44)
AGPIO65: length 18.1
  IN3 w0.127: v1(99.32,104.75) 98.63,104.06 96.32,104.06 95.59,104.79 90.71,104.79 90.41,105.1 89.13,105.1 88.79,104.76 85.32,104.76 v2(84.61,104.05)
  BOTTOM w0.102: U18.AU15 84.55,104.1 v2(84.61,104.05)
  BOTTOM w0.114: v1(99.32,104.75) v1(99.96,104.75) 100.28,104.75 R527.2
AGPIO66: length 1.4
  TOP w0.114: TP249.1 83.65,104.27 v2(83.96,103.96)
  BOTTOM w0.114: v2(83.96,103.96) 83.96,104.39 U18.AT15
AGPIO76: length 4.3
  TOP w0.114: v2(85.52,106.5) 85.64,106.38 86.54,106.38 87.28,107.12 87.75,107.12 88.15,107.52 R583.1
  BOTTOM w0.114: U18.AW12 86.02,107 v2(85.52,106.5)
AGPIO86: length 17.8
  BOTTOM w0.102: 91.95,106.3 90.35,106.3 90.35,106.3 89.22,106.3 88.92,106.6 U18.BB13
  BOTTOM w0.114: TP324.1 104.71,107.44 104.16,107.99 99.94,107.99 99.87,107.92 98.38,107.92 98.34,107.97 93.61,107.97 91.95,106.3
ALW_ON: length 111
  TOP w0.203: v1(235.07,18.82) 235.26,19.01 U34.83
  IN4 w0.254: v1(235.07,18.82) 236.11,17.78 236.11,14.76 233.9,12.55 226.35,12.55 223.91,10.12 223.91,8.64 220.58,5.31 188.97,5.31 184.45,9.83 176.7,9.83 175.07,11.46 175.07,13.13 172.27,15.94 156.79,15.94 156.3,15.45 149.49,15.45 v1(148.96,14.91)
  BOTTOM w0.114: PR205.1 145.66,14.24
  BOTTOM w0.254: v1(235.07,18.82) v1(235.07,17.81) 235.07,16.98 234.58,16.49 Q31.2 ; 145.66,14.24 145.66,14.49 146.54,15.37 148.5,15.37 v1(148.96,14.91)
ANALOGIO: length 6.6
  BOTTOM w0.127: R767.2 130.79,86.37 v1(130.79,86.75) 130.79,89.75 131.09,90.06 131.09,90.84 131.35,91.1 131.35,91.3 131,91.65 U22.AY38
APU_ALERT#: length 5.6
  BOTTOM w0.114: U18.B17 55.99,103.4 55.68,103.71 53.36,103.71 52.34,104.73 R473.2
APU_AN30: length 2
  TOP w0.114: v1(82.02,92.2) 82.4,92.58 TP155.1
  BOTTOM w0.178: v1(82.02,92.2) 81.33,92.9 U18.AN30
APU_DBRDY: length 112.7
  TOP w0.114: CN13.14 47.61,21.57 47.97,21.93 v1(47.97,22.36)
  IN1 w0.089: v1(57.54,106.12) 57.2,105.77 51.79,105.77 50.25,104.23 49.03,104.23 48.63,103.83 48.63,101.27 45.45,98.09 43.93,98.09 40.52,94.69 40.52,93.47 38.64,91.59 38.64,90.73 37.06,89.15 36,89.15 33.59,86.74 33.59,81.98 34.89,80.68 34.89,76.92 36,75.81 36,66.75 31.9,62.65 31.9,42.32 33.12,41.09 33.12,35.38 35.06,33.44 37.18,33.44 47.97,22.66 v1(47.97,22.36)
  BOTTOM w0.102: U18.C13 57.15,106.51 v1(57.54,106.12)
APU_DBREQ#: length 117.9
  TOP w0.114: R519.1 C756.1 49.86,20.97 R520.1 49.34,22.01 49.34,22.6 v1(49.22,22.72) 49.02,22.72 v1(48.68,22.38)
  IN1 w0.089: v1(54.64,108.63) 54.13,108.13 51.15,108.13 47.95,104.92 47.95,102.06 46.58,100.69 45.56,100.69 39.84,94.97 39.84,93.76 37.95,91.87 37.95,91.01 36.78,89.83 35.71,89.83 32.91,87.03 32.91,81.69 34.2,80.4 34.2,76.64 35.29,75.55 35.29,67.38 31.44,63.53 30.43,62.52 30.43,57.7 30.85,57.27 30.85,42.39 32.43,40.81 32.43,35.09 34.77,32.75 36.9,32.75 39.48,30.18 39.48,29.03 39.38,28.94 39.38,28.16 40.11,27.44 41.11,27.44 46.63,21.92 48.22,21.92 v1(48.68,22.38)
  BOTTOM w0.114: U18.A11 55.29,108.46 54.81,108.46 v1(54.64,108.63)
APU_DISP_BLEN: length 346.4
  TOP w0.114: v1(193.93,36.93) 198.31,32.54 215.68,32.54 218.49,29.73 220.5,29.73 221.32,30.56 222.37,30.56 223.46,29.47 223.46,28.9 225.57,26.8 U34.120 ; D4.1 176.05,47.46 175.78,47.73 174.52,47.73 174.03,47.24 171.03,47.24 170.53,46.73 170.53,45.67 v1(175.81,40.39) 175.63,40.21 175.63,28.89 172.22,25.48 155.07,25.48 154.85,25.7 153.24,25.7 152.49,24.94 140.02,24.94 138.69,26.27 138.69,26.82 137.26,28.25 127.87,28.25 127.26,28.86 121.17,28.86 120.31,28.01 119.58,28.01 v1(119.3,27.73)
  IN1 w0.089: v1(31.02,83.8) 30.58,84.23 30.58,87.56 34.87,91.84 34.87,93.33 33.3,94.89 33.3,96.63 32.27,97.66 32.27,109.14 32.85,109.72 35.02,109.72 35.65,110.35 37.14,110.35 37.52,109.97 41.8,109.97 42.11,109.66 42.11,109.09 v1(41.89,108.87)
  IN4 w0.089: v1(119.3,27.73) 118.11,27.73 115.58,30.25 115.58,30.5 112.41,33.67 104.44,33.67 102.95,35.17 98.8,35.17 94.88,31.24 64.63,31.24 61.66,34.21 37.32,34.21 36.62,33.51 34.96,33.51 31.9,36.57 31.9,68.83 31.76,68.97 31.76,70.89 33.18,72.31 34.73,72.31 35.35,72.94 35.35,79.75 31.3,83.8 v1(31.02,83.8)
  BOTTOM w0.114: v1(41.89,108.87) 41.74,108.71 41.74,106.85 v1(41.34,106.46) 40.9,106.02 40.9,103.24 41.01,103.13 41.01,102.13 R470.2 41.53,101.7 41.9,101.33 41.9,99.01 41.78,98.9 Q32.3 40.46,98.9 40.32,98.76 40.32,98.23 40.96,97.59 D18.2 ; v1(193.93,36.93) 193.31,37.55 191.48,37.55 189.27,39.76 176.44,39.76 v1(175.81,40.39)
APU_DISP_ON: length 281.3
  TOP w0.114: D3.1 174.38,49.95 173.95,49.51 172.34,49.51 171.69,48.86 171.69,48.62 170.05,46.98 170.05,45.46 174.44,41.07 174.44,37.01 175.39,36.06 175.39,28.99 172.12,25.72 169.39,25.72 168.67,26.44 167.04,26.44 166.33,25.73 155.16,25.73 154.95,25.94 153.1,25.94 152.35,25.19 140.12,25.19 138.93,26.37 138.93,26.92 137.36,28.49 127.97,28.49 127.36,29.1 120.79,29.1 v1(120.13,28.45)
  IN1 w0.089: v1(41.62,109.53) 41.62,109.3 39.31,106.99 39.31,103.59 38.51,102.78 38.51,101.71 38,101.21 38,94.9 37.14,94.04 36.35,94.04 36.19,94.2 35.64,94.2 35.39,93.95 35.39,92.04 30.81,87.46 30.81,84.65 v1(31.02,84.44)
  IN4 w0.089: v1(31.02,84.44) 35.59,79.88 35.59,72.85 34.82,72.09 33.27,72.09 31.98,70.8 31.98,69.06 32.13,68.92 32.13,36.67 35.05,33.74 36.53,33.74 37.22,34.44 61.75,34.44 64.72,31.47 94.75,31.47 98.67,35.39 103.04,35.39 104.54,33.9 112.57,33.9 113.93,32.54 113.93,32.47 115.84,30.57 115.84,30.33 116.82,29.34 119.85,29.34 120.13,29.07 v1(120.13,28.45)
  BOTTOM w0.114: v1(41.62,109.53) 41.62,109.26 41.21,108.86 41.21,106.99 40.66,106.44 40.66,103.93 v1(40.44,103.71) 40.4,103.67 39.86,103.67 39.18,102.98 39.18,101.78 39.27,101.7 R469.2 39.76,101.55 39.76,100.36 39.6,100.2 Q32.6 38.26,100.2 38.09,100.03 38.09,98.35 38.34,98.1 38.8,98.1 39.05,97.85 D17.2
APU_DISP_ON_R: length 35.9
  IN4 w0.089: v1(40.22,100.72) 40.44,100.72 42.35,102.63 42.35,103.05 43.53,104.23 43.53,104.68 44.97,106.13 45.55,106.13 47.63,108.22 50.23,108.22 50.49,107.96 54.96,107.96 56.16,106.76 61.75,106.76 62.09,107.1 62.09,108.18 60.28,109.99 60.28,111.35 v1(61.11,112.18)
  BOTTOM w0.102: U18.G6 60.6,112.15 61.09,112.15 v1(61.11,112.18)
  BOTTOM w0.114: v1(40.22,100.72) 40.55,101.05 v1(41.39,101.05) 41.62,100.82 41.62,100.31 41.51,100.2 Q32.1
APU_DPST_PWM: length 225.2
  TOP w0.114: Q44.6 45.04,99.66 44.45,99.07 R482.2 44.45,98.12 42.89,96.57 42.89,71.54 36.84,65.48 36.84,59.23 37.68,58.39 37.68,51.73 36.89,50.94 36.89,48 42.35,42.54 55.88,42.54 61.54,36.89 68.19,36.89 68.99,36.08 v1(91.48,36.08) v1(92.2,36.08) ; v1(122.16,27.9) 122.89,28.62 127.16,28.62 127.77,28.01 137.16,28.01 138.45,26.72 138.45,26.17 139.92,24.7 152.59,24.7 153.34,25.46 154.75,25.46 154.97,25.24 172.34,25.24 175.87,28.77 175.87,38 177.59,39.71 177.59,41.39 R1038.2
  IN4 w0.089: v1(92.2,36.08) 94.86,38.74 111.24,38.74 118.48,31.5 119.83,31.5 122.16,29.17 v1(122.16,27.9)
APU_DPST_PWM_R: length 20.8
  TOP w0.114: Q44.1 45.04,103.09 v1(45.77,103.82) 45.77,104.88 v1(45.3,105.35)
  IN1 w0.089: v1(59.16,107.56) 58.61,107.01 56.88,107.01 54.82,109.07 53.73,109.07 53.07,108.41 51.11,108.41 47.94,105.24 45.71,105.24 45.6,105.35 v1(45.3,105.35)
  BOTTOM w0.102: U18.F11 59.16,107.81 v1(59.16,107.56)
APU_I2C_INT#: length 184.7
  TOP w0.114: D6.2 166.82,41.14 R460.2 166.93,41.95 166.94,41.96 164.84,41.96 162.43,39.55 162.43,34.55 158.44,30.56 152.31,30.56 149.4,27.66 138.54,27.66 137.46,28.73 128.07,28.73 127.46,29.34 119.23,29.34 118.35,28.47 v1(118.35,28.18)
  IN1 w0.089: v1(94.54,34.26) 94.64,34.16 98.93,34.16 98.93,34.16 99.12,34.16 106.63,26.65 110.07,26.65 111.82,28.4 113.16,28.4 113.23,28.47 118.06,28.47 v1(118.35,28.18)
  BOTTOM w0.102: 99.3,100.36 99.06,100.36 R1012.2 97.2,100.31 95.36,100.31 v1(94.74,100.93) 93.76,101.91 93.52,101.91 93.11,102.32 90.87,102.32 90.63,102.08 90.06,102.08 89.48,101.5 89.22,101.5 88.92,101.8 U18.BB19
  BOTTOM w0.114: v1(94.54,34.26) 95.81,34.26 103.78,42.23 105.89,42.23 106.82,43.16 106.82,47 108.75,48.93 108.75,50.65 106.98,52.42 106.98,57.87 107.99,58.88 107.99,72.87 105.27,75.59 105.27,92.27 106.49,93.49 106.49,98.94 105.07,100.36 99.3,100.36
APU_LVDS_BLON_R: length 37.2
  IN4 w0.089: v1(61.03,112.82) 60.05,111.84 60.05,109.9 61.86,108.08 61.86,107.2 61.65,106.99 56.25,106.99 55.06,108.18 50.58,108.18 50.32,108.44 47.54,108.44 45.45,106.36 44.88,106.36 43.17,104.65 43.17,104.29 42.1,103.22 42.1,102.7 40.59,101.2 40.07,101.2 39.78,100.91 39.78,100.01 39.5,99.73 39.5,99.3 v1(39.91,98.9)
  BOTTOM w0.102: v1(61.03,112.82) 60.75,113.1 U18.G5
  BOTTOM w0.114: Q32.4 v1(39.91,98.9)
APU_MA_VREFDQ: length 5.6
  BOTTOM w0.102: U18.B19 56,101.45 55.47,101.45 55.33,101.59 53.36,101.59 53.07,101.31 52.45,101.31
  BOTTOM w0.114: TP110.1 51.87,101.31 52.45,101.31
APU_MB_VREFDQ: length 5.9
  BOTTOM w0.114: U18.A19 51.09,101.8 TP111.1
APU_PROCHOT#_R: length 19.8
  TOP w0.114: v1(43.14,103.23) 43.14,103.1 43.37,102.88 43.37,101.79 43.74,101.42 Q44.4
  IN4 w0.089: v1(43.14,103.23) 43.87,103.96 43.87,104.54 45.12,105.79 45.69,105.79 47.37,107.47 v1(47.54,107.47)
  BOTTOM w0.114: v1(47.54,107.47) 47.54,107.78 v1(47.87,108.11) 48.4,108.11 49.16,107.34 50.82,107.34 R471.2 53.92,105.12 55.43,105.12 U18.A15
APU_PWRGD: length 355.6
  TOP w0.114: v1(114.57,24.02) 114.64,24.08 114.64,25.35 113.69,26.3 113.69,30.04 113.95,30.3 113.95,33.1 116.89,36.04 116.89,37.36 117.2,37.68 117.2,45.97 120.83,49.6 120.83,55.3 119.39,56.73 119.39,61.48 118.59,62.28 118.59,70.2 117.85,70.95 116.99,70.95 109.65,78.3 109.65,88.61 112.93,91.89 112.93,115.9 115.23,118.19 115.23,122.72 114.24,123.71 114.24,130.87 117.26,133.89 120.02,133.89 121.19,135.06 121.19,139.21 PR273.1 ; v1(55.24,24.36) U19.3 ; PR321.1 39.2,116.07 v1(38.75,115.63)
  IN1 w0.089: v1(37.79,94.03) 37.79,93.76 36.51,92.47 36.51,91.61 36.18,91.28 35.11,91.28 31.46,87.63 31.46,81.09 32.75,79.8 32.75,66.89 28.98,63.12 28.98,57.1 29.4,56.67 29.4,41.79 30.99,40.21 30.99,34.49 35.37,30.11 36.3,30.11 39.4,27.01 39.4,26.63 39.97,26.07 40.52,26.07 47.96,18.62 48.99,18.62 53.03,22.65 53.53,22.65 v1(55.24,24.36)
  IN2 w0.127: v1(37.79,94.03) 37.79,95.9 39.26,97.37 39.26,99.63 39.7,100.08 40.52,100.08 41.47,101.02 41.47,105.36 42.35,106.24 42.35,109.45 41.79,110.01 41.23,110.01 40.58,110.65 38.96,110.65 36.38,113.23 36.38,115.05 36.96,115.63 v1(38.75,115.63)
  IN4 w0.089: v1(55.24,24.36) 56.4,25.53 57.37,25.53 57.82,25.98 80.31,25.98 80.31,25.98 80.96,25.98 81.39,25.98 81.39,25.98 82.04,25.98 82.04,25.98 99.67,25.98 99.96,26.27 102.29,26.27 106.06,30.03 109.34,30.03 110.08,29.29 110.08,26.88 111.68,25.28 112.71,25.28 113.98,24.02 v1(114.57,24.02)
  BOTTOM w0.114: v1(37.79,94.03) 38.35,93.48 44.67,93.48 46.14,94.95 v1(46.14,98.61) 46.68,99.15 R478.1 R468.2 47.42,101.28 47.58,101.44 R491.2 48.71,101.97 50.76,101.97 C752.1 52.48,102.46 52.82,102.11 56.51,102.11 56.82,101.8 U18.C19
APU_PWROK_BUF: length 8.2
  TOP w0.114: U19.4 53.01,23.49 52.67,23.83 50.69,23.83 49.99,24.52 49.55,24.52 R514.2 48.58,25 v1(48.12,24.54) 47.69,24.11 CN13.10
APU_RST#: length 123.6
  TOP w0.114: U19.1 55.54,22.19 56.74,23.39 v1(56.74,24.36) ; 56.88,104.81 v1(57.52,105.45) ; 56.88,104.81 C751.1 ; 56.88,104.81 56.88,105.68 TP121.1 56.14,105.71 R467.2
  IN1 w0.089: v1(57.52,105.45) 57.43,105.54 51.88,105.54 50.34,104 49.55,104 49.19,103.64 49.19,102.83 48.93,102.58 48.93,101.25 45.55,97.86 44.03,97.86 40.75,94.59 40.75,93.38 38.87,91.49 38.87,90.63 37.16,88.92 36.09,88.92 33.82,86.65 33.82,82.07 35.11,80.78 35.11,77.02 36.23,75.9 36.23,66.65 32.13,62.55 32.13,42.41 33.35,41.19 33.35,35.47 35.15,33.67 37.28,33.67 46.01,24.94 50.76,24.94 51.46,25.65 55.45,25.65 v1(56.74,24.36)
  BOTTOM w0.102: v1(57.52,105.45) 57.95,105.02 U18.D15
APU_RST_L_BUF: length 8.3
  TOP w0.114: U19.6 52.83,22.19 52.7,22.06 51.14,22.06 v1(50.57,22.64) 50.17,22.64 R516.2 48.53,23.73 47.64,22.84 CN13.12
APU_S5_MUX_CTRL: length 106.4
  IN1 w0.089: v2(77.99,110.96) 77.45,110.42 77.45,109.31 78.07,108.69 83.18,108.69 83.45,108.41 84.96,108.41 85.38,108.83 86.69,108.83 87.57,109.71 89.57,109.71 90.92,111.06 91.75,111.06 92.16,110.64 96.03,110.64 98.69,107.98 99.89,107.98 100.44,107.43 100.44,105.1 101.06,104.48 103.09,104.48 105.18,102.4 105.18,99.16 108.96,95.38 108.96,91.62 112.28,88.3 112.28,87.75 115.35,84.67 115.35,80.42 112.37,77.43 112.37,69.49 112.61,69.25 112.61,46.01 v1(112.87,45.75)
  BOTTOM w0.102: v2(77.99,110.96) 77.51,110.96 U18.AH8
  BOTTOM w0.114: PQ66.2 118.45,47.28 117.89,46.72 PR456.1 v1(116.5,46.18) 113.3,46.18 v1(112.87,45.75)
APU_SIC: length 24
  TOP w0.114: Q33.4 40.97,101.09 40.55,101.51 40.55,103.1 41.04,103.59 v1(41.04,104.55) 41.04,105.29 41.6,105.85 45.6,105.85 46.19,105.26 46.19,104.06 46.8,103.45 v1(47.51,103.45)
  BOTTOM w0.114: v1(47.51,103.45) R474.2 48.19,103.49 48.58,103.88 52.06,103.88 53.21,102.74 55.65,102.74 55.82,102.91 56.08,102.91 56.39,102.6 U18.B18
APU_SID: length 18.6
  TOP w0.114: Q33.1 42.27,103.04 42.39,103.16 42.48,103.16 42.86,102.78 v1(42.86,102.54)
  BOTTOM w0.114: v1(42.86,102.54) 42.67,102.74 42.67,103.43 43.09,103.86 v1(43.52,103.86) 44.28,103.86 44.95,103.18 46.19,103.18 R475.2 47.11,104.1 52.15,104.1 53.21,103.04 55.65,103.04 55.73,103.12 56.17,103.12 56.26,103.03 56.78,103.03 U18.C17
APU_SPI_CLK: length 64.5
  TOP w0.114: R610.1 EC91.2 EC26.1 123.19,149.59 121.86,148.26 121.86,146.09 v1(122.22,145.73)
  IN4 w0.089: v1(122.22,145.73) 122.58,145.37 122.58,145.2 122.41,145.04 121.98,145.04 121.9,144.95 121.9,144.53 121.98,144.44 122.31,144.44 122.67,144.09 122.67,141.12 121.54,139.99 121.54,135.07 119.37,132.9 117.58,132.9 114.5,129.82 114.5,124.99 v1(112.5,122.99)
  BOTTOM w0.114: v1(112.5,122.99) 112.5,122.31 110.33,120.14 98.11,120.14 95.66,117.68 95.17,117.68 90.75,113.26 90.36,113.26 89.29,112.2 U18.BC6
APU_SPI_CS0#: length 73.1
  TOP w0.114: R609.1 v1(139.38,146.03)
  IN4 w0.089: v1(113.03,119.77) 116.15,122.9 116.15,129.13 118.27,131.25 120.13,131.25 123.19,134.31 123.19,138.62 127.59,143.03 134.48,143.03 137.49,146.03 v1(139.38,146.03)
  BOTTOM w0.102: U18.BB8 88.52,110.6 88.89,110.23 89.01,110.23 89.1,110.32 90.14,110.32 90.4,110.58 90.4,110.76 91.12,111.49 93.61,111.49 95.9,113.78
  BOTTOM w0.114: v1(113.03,119.77) 107.03,113.78 95.9,113.78
