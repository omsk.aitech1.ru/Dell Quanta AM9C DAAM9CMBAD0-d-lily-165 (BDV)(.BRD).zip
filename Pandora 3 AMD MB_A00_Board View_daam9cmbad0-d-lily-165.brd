# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DBGDATA_6: length 8.7
  BOTTOM w0.114: U22.P40 129.85,106 129.54,106.31 129.28,106.31 129.08,106.11 126.14,106.11 124.96,107.29 R956.2 124.09,106.85 122.95,106.85 R957.1
DBGDATA_7: length 14.9
  BOTTOM w0.114: U22.P41 129.27,105.87 126.04,105.87 125.3,106.61 120.29,106.61 119.99,106.3 119.9,106.3 R959.1 119.28,105.68 116.64,105.68 v1(116.5,105.82) 116.5,106.02 116.62,106.15 R958.2
DCR_EN: length 205.1
  TOP w0.114: v1(182.85,54.99) 181.89,55.94 v1(177.46,55.94) 166.56,55.94 153.65,43.03 153.65,33.68 148.88,28.91 139.06,28.91 137.98,29.99 128.59,29.99 127.87,30.71 119.35,30.71 v1(119.35,30.71) ; R1010.2 79.02,115.2 79.02,114.12 78.7,113.79 78.7,112.92 v2(79.09,112.53)
  IN1 w0.089: v2(79.09,112.53) 79.49,112.13 79.49,109.43 79.77,109.14 82.63,109.14 83.05,109.57 86.57,109.57 87.21,110.21 88.42,110.21 89.72,111.52 92.11,111.52 92.53,111.1 96.22,111.1 98.21,109.11 99.42,109.11 100.9,107.63 100.9,105.29 101.25,104.94 103.28,104.94 105.63,102.59 105.63,99.35 109.42,95.57 109.42,91.85 112.74,88.52 112.74,87.94 114.41,86.26 115.69,86.26 116.32,85.63 116.32,84.76 115.91,84.36 115.91,79.38 113.67,77.14 113.67,69.87 113.06,69.26 113.06,47.78 113.78,47.06 113.78,32.28 115.36,30.71 119.35,30.71 v1(119.35,30.71)
  BOTTOM w0.102: v2(79.09,112.53) 79.32,112.3 U18.AL6
  BOTTOM w0.114: R1037.1 v1(182.85,54.99)
DCR_EN_R: length 3.8
  BOTTOM w0.114: R1037.2 v1(182.85,52.28) 182.85,51.52 183.6,50.77 CN9.33
DDBIA0_0: length 33.7
  IN4 w0.114: v1(131.5,109.3) 131.05,109.75 130.5,109.75 129.68,110.57 129.68,111.86 130.59,112.76 130.59,114.67 132.66,116.75 133.08,116.75 136.59,120.25 136.59,127.3 136.92,127.63 136.92,131.05 137.27,131.4 137.27,136.5 v1(136.75,137.02)
  BOTTOM w0.14: U22.J38 131.15,108.95 v1(131.5,109.3) ; VRAM1.D2 v1(136.75,137.02)
DDBIA0_1: length 32.7
  IN4 w0.114: v1(125.61,113.99) 125.61,115.97 127.04,117.4 127.04,126.09 127.28,126.34 127.28,127.14 127.55,127.4 127.55,127.75 127.23,128.06 127.23,129.37 127.55,129.69 127.55,130.17 127.23,130.49 127.23,130.9 127.55,131.21 127.55,131.7 127.23,132.01 127.23,132.42 127.58,132.77 127.58,133.23 127.23,133.58 127.23,133.83 127.52,134.12 127.52,134.42 127.5,134.44 127.5,135.43 127.54,135.47 127.54,136.63 v1(127.15,137.02)
  BOTTOM w0.102: 128.55,110.52 128.67,110.63 129.19,110.63 129.31,110.72 129.53,110.72 129.62,110.63 129.87,110.63 U22.F40
  BOTTOM w0.14: 128.55,110.52 127.97,110.52 126.48,112.01 126.48,113.48 125.97,113.99 v1(125.61,113.99) ; v1(127.15,137.02) VRAM1.D13
DDBIA0_2: length 19.9
  BOTTOM w0.102: 130.87,114.38 130.87,113.82 131,113.69 U22.A38
  BOTTOM w0.14: VRAM1.P13 127.41,129.28 127.41,129.03 127.15,128.77 127.15,128.45 126.92,128.22 126.58,128.22 126.4,128.03 125.86,128.03 125.6,127.77 125.6,124.58 v1(127.23,122.96) 127.23,118.48 127.5,118.21 127.5,117.76 130.87,114.38
DDBIA0_3: length 19.8
  BOTTOM w0.102: 135.15,114.83 135.09,114.76 135.09,113.65 135.16,113.58 135.16,113.3 135.08,113.22 135.08,112.97 135.4,112.65 U22.B30
  BOTTOM w0.14: 135.15,114.83 v1(135.15,122.99) 138.2,126.04 138.2,127.83 137.95,128.08 137.46,128.08 137.32,128.22 136.98,128.22 136.75,128.45 136.75,128.77 136.43,129.09 136.43,129.34 VRAM1.P2
DDBIA1_0: length 20.7
  BOTTOM w0.102: 137.72,114.52 137.72,113.96 137.84,113.85 137.84,113.32 137.85,113.3 137.85,113.3 138.15,113 U22.B25
  BOTTOM w0.14: VRAM2.D2 145.92,129.39 145.92,129.14 145.57,128.79 145.57,128.47 145.29,128.2 144.95,128.2 144.8,128.05 144.36,128.05 143.44,127.13 143.44,125.92 137.83,120.31 137.83,114.62 137.72,114.52
DDBIA1_1: length 28.7
  BOTTOM w0.102: 142.14,114.41 142.14,113.77 142.22,113.69 142.22,113.33 142.33,113.19 142.33,112.97 142,112.65 U22.B18
  BOTTOM w0.14: VRAM2.D13 154.9,129.31 154.9,129.06 155.17,128.79 155.17,128.47 155.4,128.24 155.79,128.24 156.02,128.01 156.38,128.01 156.62,127.78 156.62,126.31 156.17,125.86 156.17,124.53 v1(153.05,121.41) 153,121.36 151.57,121.36 150.14,119.92 144.29,119.92 142.15,117.78 142.15,114.42 142.14,114.41
DDBIA1_2: length 26.5
  IN4 w0.114: v1(144.75,116.55) 145.35,117.15 145.35,118.4 144.73,119.02 144.73,125.62 145.25,126.14 145.25,130.24 145.09,130.39 145.09,136.39 145.36,136.65 145.98,136.65 v1(146.37,137.04)
  BOTTOM w0.102: U22.A12 145.3,113.68 145.39,113.77 145.39,114.48 145.18,114.69
  BOTTOM w0.14: 145.18,114.69 145.18,116.12 v1(144.75,116.55) ; VRAM2.P2 v1(146.37,137.04)
DDBIA1_3: length 28.8
  IN4 w0.114: v1(150.85,115.52) 150.43,115.94 150.43,116.52 150.68,116.77 151.05,116.77 151.3,117.02 151.3,118.17 154.5,121.37 154.5,126.73 154.89,127.12 154.89,134.89 154.8,134.98 154.8,137.43 v1(155.21,137.84)
  BOTTOM w0.102: 149.57,114.21 149.57,113.93 149.47,113.82 149.47,113.32 149.37,113.22 149.37,112.97 U22.B5
  BOTTOM w0.14: VRAM2.P13 154.82,137.44 v1(155.21,137.84) ; v1(150.85,115.52) 150.85,115.49 149.57,114.21
DDBIB0_0: length 28.9
  IN4 w0.114: v1(174.72,116.94) 174.8,117.02 174.8,118.12 174.46,118.46 163.89,118.46 158.85,113.41 154.64,113.41 v1(153.86,112.64)
  BOTTOM w0.102: 153.55,112.64 152.3,111.38 152.05,111.38 151.94,111.27 151.52,111.27 151.43,111.17 151.17,111.17 U22.E2
  BOTTOM w0.14: VRAM3.D13 v1(174.72,116.94) ; 153.55,112.64 v1(153.86,112.64)
DDBIB0_1: length 25.2
  IN4 w0.114: v1(154.75,106.55) 155.19,106.99 157.62,106.99 158.3,106.31 164.29,106.31 164.81,106.82 174.2,106.82 v1(174.72,107.34)
  BOTTOM w0.102: U22.M1 151.86,107.1 151.95,107.19 152.66,107.19 152.87,106.97
  BOTTOM w0.14: 152.87,106.97 154.32,106.97 v1(154.75,106.55) ; VRAM3.D2 v1(174.72,107.34)
DDBIB0_2: length 29.6
  IN1 w0.114: v1(166.67,116.94) 166.22,117.39 166.02,117.39 165.67,117.74 165.67,118.38 165.3,118.75 163.08,118.75 160.77,116.44 160.77,108.35 156.01,103.6 154.84,103.6 v1(154.59,103.34)
  BOTTOM w0.102: U22.V2 150.85,103.8 151.17,104.12 151.39,104.12 151.69,103.9 151.92,103.9 152.16,103.66 153.47,103.66
  BOTTOM w0.14: v1(166.67,116.94) 167.07,116.54 VRAM3.P13 ; v1(154.59,103.34) 154.59,103.58 154.37,103.8 153.61,103.8 153.47,103.66
DDBIB0_3: length 20.3
  BOTTOM w0.102: 152.8,99.6 152.74,99.54 152.14,99.54 152.05,99.63 151.52,99.63 151.5,99.65 151.5,99.65 151.2,99.95 U22.AE2
  BOTTOM w0.14: VRAM3.P2 167.03,107.65 166.73,107.65 166.42,107.34 166.15,107.34 165.87,107.06 165.87,106.71 165.79,106.63 165.79,105.99 165.62,105.82 164.9,105.82 163.83,104.75 162.33,104.75 v1(159.65,102.06) 157.26,99.68 155.56,99.68 155.48,99.6 152.8,99.6
DDBIB1_0: length 19.1
  BOTTOM w0.102: 153.04,96.88 151.89,96.88 151.81,96.96 151.51,96.96 151.39,96.87 151.17,96.87 150.85,97.2 U22.AK2
  BOTTOM w0.14: 153.04,96.88 153.1,96.95 157.65,96.95 158.08,96.52 v1(160.36,96.52) 161.94,96.52 163.92,98.51 165.48,98.51 165.88,98.11 165.88,97.21 166.14,96.95 166.41,96.95 166.7,96.66 167,96.66 VRAM4.D2
DDBIB1_1: length 21.8
  IN1 w0.114: v1(166.7,87.34) 166.7,87.33 166.7,86.1 165.72,85.12 158.61,85.12 154.3,89.43 v1(154.3,90.18)
  BOTTOM w0.102: 152.83,92.68 152,92.68 151.88,92.8 U22.AV1
  BOTTOM w0.14: 152.83,92.68 153.98,91.53 153.98,90.5 v1(154.3,90.18) ; v1(166.7,87.34) 167.11,87.75 VRAM4.D13
DDBIB1_2: length 31.9
  IN4 w0.114: v1(150.65,88.63) 151.55,87.74 151.55,87.1 152.79,85.86 174.13,85.86 174.47,86.2 174.47,87.11 v1(174.71,87.35)
  BOTTOM w0.102: 148.98,89.7 148.72,89.96 148.72,90.44 148.84,90.55 148.84,90.99 148.93,91.11 148.93,91.33 148.84,91.42 148.84,91.66 U22.AY6
  BOTTOM w0.14: v1(150.65,88.63) 149.59,89.7 148.98,89.7 ; VRAM4.P13 v1(174.71,87.35)
DDBIB1_3: length 33.5
  IN4 w0.114: v1(175.51,96.95) 175.04,97.42 168.03,97.42 167.22,96.61 167.22,95.2 165.72,93.7 160.25,93.7 159.49,92.93 153.96,92.93 152.86,91.83 148.21,91.83 147.95,92.1 147.95,92.75 v2(147.5,93.2)
  BOTTOM w0.14: v1(175.51,96.95) VRAM4.P2 ; U22.AV9 147.25,92.95 v2(147.5,93.2)
DDR0_SA0: length 9
  TOP w0.114: v1(105.22,47.48) 104.71,47.99 v1(104.71,48.77) 104.71,51.59 104.85,51.73 R915.1 104.71,52.26 R913.2
  BOTTOM w0.114: CN16.256 104.98,45.89 105.3,46.21 105.3,47.4 v1(105.22,47.48)
DDR0_SA1: length 9.1
  TOP w0.114: v1(105.58,48.14) 105.83,48.39 v1(105.83,49.46) 105.83,51.54 106.02,51.73 R916.1 105.86,52.26 R914.2
  BOTTOM w0.114: v1(105.58,48.14) 106.24,47.48 106.24,46.11 105.98,45.85 CN16.260
DDR1_SA0: length 4.3
  TOP w0.114: v1(105.47,58.83) 105.47,58.54 R919.1 R917.2
  BOTTOM w0.114: CN17.256 104.98,58.33 v1(105.47,58.83)
DDR1_SA1: length 4.8
  TOP w0.114: R918.2 106.11,58.55 105.82,58.25 R920.1 106.05,57.77 106.26,57.57 106.26,56.64 v1(106.53,56.36)
  BOTTOM w0.114: v1(106.53,56.36) 106.24,56.36 105.98,56.62 CN17.260
DDR4_RUNON: length 267.1
  TOP w0.114: U34.77 237.61,16.61 v1(237.66,16.57)
  IN1 w0.089: v1(20.77,47.98) 21.28,47.47 24.3,47.47 25.05,46.71 25.05,42.14 28.15,39.03 28.15,33 30.09,31.06 30.09,22.53 36.17,16.46 51.51,16.46 55.88,20.82 56.47,21.42 98.83,21.42 102.38,17.87 106.33,17.87 109.38,14.82 112.46,14.82 113.91,13.38 116.19,13.38 116.85,12.72 119.81,12.72 120.51,12.03 125.88,12.03 127.24,13.38 127.24,14.7 129.1,16.57 140.45,16.57 141.42,17.53 145.1,17.53 145.39,17.24 156.38,17.24 156.6,17.46 180.5,17.46 183.66,14.3 202.84,14.3 212.32,4.82 232.94,4.82 238.44,10.32 238.44,15.78 v1(237.66,16.57)
  BOTTOM w0.114: PR479.1 v1(20.77,47.98)
DDR4_SUSON: length 267.8
  TOP w0.114: v1(238.32,16.62) 238.32,16.46 237.91,16.05 237.43,16.05 237.27,16.21 U34.76
  IN1 w0.089: v1(21.91,45.95) 21.91,46.53 22.32,46.95 23.9,46.95 24.17,46.68 24.17,42.69 27.93,38.94 27.93,32.9 29.86,30.97 29.86,22.44 36.07,16.23 51.6,16.23 56.11,20.73 56.57,21.2 98.73,21.2 102.29,17.64 106.24,17.64 108.8,15.08 108.8,14.24 109.89,13.15 116.1,13.15 116.75,12.5 119.71,12.5 120.41,11.8 125.98,11.8 127.47,13.29 127.47,14.61 129.19,16.34 140.54,16.34 141.51,17.31 145.01,17.31 145.3,17.02 156.47,17.02 156.69,17.23 180.4,17.23 183.56,14.07 202.75,14.07 212.22,4.6 233.04,4.6 238.67,10.23 238.67,16.26 v1(238.32,16.62)
  BOTTOM w0.114: v1(21.91,45.95) PR120.1
DDR4_SUSON_2V5: length 262.4
  TOP w0.114: v1(117.26,25.11) 117.59,25.44 123.43,25.44 123.86,25.87 128.96,25.87 130.38,27.29 136.86,27.29 137.73,26.42 137.73,25.87 139.62,23.98 152.89,23.98 153.64,24.73 154.45,24.73 154.67,24.51 179.1,24.51 184.9,18.71 191.69,18.71 199.48,10.92 205.88,10.92 210.57,6.23 v1(232.55,6.23) 233.91,6.23 235.27,7.6 235.27,10.77 234.68,11.36 234.68,12.58 235.11,13.01 U34.68
  IN4 w0.089: v1(26.63,48.93) 27.23,48.33 27.23,46.79 26.51,46.07 26.51,36.72 35.81,27.42 41.67,27.42 42.39,26.7 48.93,26.7 50.98,28.74 99.31,28.74 103.1,32.53 110.39,32.53 111.84,31.08 113.41,31.08 113.75,30.74 113.75,28.49 114.88,27.36 115.83,27.36 117.26,25.93 v1(117.26,25.11)
  BOTTOM w0.114: v1(26.63,48.93) 26.6,48.97 17.37,48.97 PR386.1
DDR_PWRGD: length 253.9
  TOP w0.114: R202.2 229.83,33.19 221.16,33.19 v1(218.81,30.84)
  IN1 w0.089: v1(203.34,12.86) 202.36,13.84 183.47,13.84 180.31,17 156.79,17 156.57,16.79 145.2,16.79 144.91,17.08 141.61,17.08 140.64,16.11 129.29,16.11 127.69,14.51 127.69,13.19 126.07,11.57 120.32,11.57 119.62,12.27 116.66,12.27 116,12.92 109.8,12.92 108.58,14.15 108.58,14.98 106.14,17.41 102.19,17.41 98.64,20.97 56.66,20.97 56.33,20.64 51.7,16 35.98,16 29.63,22.34 29.63,30.87 27.7,32.81 27.7,38.84 22.87,43.67 v1(22.75,43.67)
  BOTTOM w0.114: v1(218.81,30.84) 218.78,30.84 v1(218.35,30.41) 216.77,28.83 212.74,28.83 203.9,19.98 203.9,13.42 v1(203.34,12.86) ; PU9.8 22.42,42.91 22.75,43.24 v1(22.75,43.67)
DGPU_HOLD_RST#: length 51.3
  IN1 w0.089: v2(83.53,106.33) 84.02,105.84 86.09,105.84 87.16,106.91 87.16,107.7 87.38,107.92 89.09,107.92 90.53,109.36 91.38,109.36 91.98,109.96 95.75,109.96 98.42,107.29 99.62,107.29 99.76,107.14 99.76,104.82 100.78,103.8 101.81,103.8 103.23,102.39 103.64,102.39 103.77,102.52 104.09,102.52 104.49,102.12 104.49,98.87 108.27,95.09 108.27,91.01 111.07,88.21 v1(111.07,88.22)
  BOTTOM w0.114: v1(111.07,88.22) v1(112.54,88.22) 113.65,87.1 R657.2 ; U18.AR14 83,105.8 v2(83.53,106.33)
DGPU_HOLD_RST#_R: length 5.9
  BOTTOM w0.114: R657.1 117.79,87.1 118.16,87.47 U24.1 119.68,87.47 120.46,88.24 R658.2
DGPU_PWR_EN: length 182
  TOP w0.114: v1(127.35,46.57) 127.35,54.66 v1(127.07,54.93) 123.37,58.64 123.37,71.15 125.28,73.06 125.28,78.71 v1(125.45,78.89)
  IN1 w0.089: v1(160.64,41.05) 160.09,41.05 159.09,40.05 159.09,39.5 158.82,39.23 153.58,39.23 v1(152.97,39.84) 152.42,39.3 147.8,39.3 v1(147.29,39.81) 145.28,41.82 142.79,41.82 141.97,41 131.14,41 127.96,44.18 127.96,45.96 v1(127.35,46.57)
  IN2 w0.127: v1(127.35,46.57) 127.12,46.34 119.4,46.34 116.89,43.83 v1(110.98,43.83)
  BOTTOM w0.102: U18.BC13 91.94,106.6
  BOTTOM w0.114: R1079.1 125.42,78.92 v1(125.45,78.89) ; v1(160.64,41.05) 160.23,40.63 R1022.2 ; v1(110.98,43.83) 110.8,44.01 110.8,47.08 113.32,49.6 113.32,53.05 113,53.37 113,55.38 110.17,58.21 110.17,73.16 106.97,76.36 106.97,90.68 109.59,93.3 109.59,99.77 107.48,101.88 105.28,104.08 105.28,107.21 104.26,108.23 99.78,108.23 99.71,108.16 98.46,108.16 98.42,108.21 93.55,108.21 91.94,106.6 ; R1024.2 153.49,40.37 v1(152.97,39.84) ; R1034.2 147.74,40.26 v1(147.29,39.81)
DGPU_PWROK: length 74.5
  IN1 w0.089: v1(133.62,54.43) 134.43,54.43 135.75,55.76 143.02,55.76 146.39,52.39 148.7,52.39 148.79,52.31 150.46,52.31 151.68,51.09 v1(154.88,51.09) 157.6,51.09 163.94,57.43 172.06,57.43 v1(172.32,57.68)
  IN3 w0.127: v1(137.84,42.01) 135.95,43.91 135.95,52.26 133.78,54.43 v1(133.62,54.43)
  BOTTOM w0.114: PR496.2 149.3,51.48 149.54,51.25 151.72,51.25 151.85,51.38 Q51.1 152.31,52.02 152.54,51.79 R1073.1 R1020.2 154.6,51.79 154.88,51.51 v1(154.88,51.09) ; v1(137.84,42.01) 137.83,42.01 PR416.2 ; v1(172.32,57.68) 172.51,57.87 172.51,60.1 171.88,60.74 v1(171.64,60.74) 170.9,60.74 170.6,61.04 PU25.1 ; v1(133.62,54.43) 133.35,54.15 PR407.1 133.35,53.8 PR512.2
DGPU_PWROK_R: length 228.3
  TOP w0.114: v1(194.69,36.93) 194.69,36.51 197.76,33.44 233.94,33.44 234.63,32.75 234.63,30.21 234.37,29.94 233.51,29.94 233.18,29.61 233.18,29.19 233.07,29.08 232.64,29.08 230.77,27.2 U34.107
  IN1 w0.089: v1(122.24,70.57) 122.86,69.95 122.86,53.3 128.19,47.97 128.19,44.27 131.23,41.23 141.87,41.23 142.69,42.05 146.55,42.05 147.64,43.13 147.64,47.35 150.26,49.98 v1(153.17,49.98) 155.31,49.98 158.77,46.52 v1(158.77,41.02) 161.55,43.79 177.48,43.79 180.79,40.49 186.25,40.49 188.66,38.08 193.54,38.08 v1(194.69,36.93) ; v1(107.26,93.3) 107.28,93.3 107.81,92.77 107.81,90.51 111.34,86.98 v1(111.77,86.98)
  BOTTOM w0.102: U18.BC17 89.39,103.36 90.19,103.36 90.36,103.54 93.62,103.54 93.99,103.17 98.02,103.17
  BOTTOM w0.114: 98.02,103.17 98.55,103.17 98.86,102.86 v1(98.88,102.86) 98.88,102.84 99.21,102.51 99.21,101.53 99.4,101.34 105.54,101.34 108.14,98.74 108.14,94.18 v1(107.26,93.3) ; 153.17,51.01 153.12,50.96 151.36,50.96 151.19,50.79 Q51.3 ; 153.17,51.01 R1073.2 ; 153.17,51.01 v1(153.17,49.98) ; R1027.1 159.16,40.63 v1(158.77,41.02) ; v1(111.77,86.98) 111.04,86.25 111.04,78.33 117.11,72.26 120.54,72.26 v1(122.24,70.57)
DGPUT_CLK: length 2.8
  BOTTOM w0.114: Q40.1 127.96,85.21 127.71,85.45 R732.2 R691.1
DGPUT_CLK_R: length 5.9
  BOTTOM w0.114: R691.2 128.44,87.47 128.44,91.34 128.91,91.81 129.19,91.81 129.63,92.25 U22.AW40
DGPUT_DATA: length 6.7
  BOTTOM w0.114: Q40.4 126.9,83.91 127.27,84.28 127.27,85.43 126.99,85.7 v1(125.08,85.7) 125.08,86.19 125.35,86.46 R731.2 R693.1
DGPUT_DATA_R: length 5.9
  BOTTOM w0.102: 128.11,89.14 128.11,91.31 129,92.2 129.01,92.2
  BOTTOM w0.114: 128.11,89.14 127.06,88.09 127.06,87.54 R693.2 ; U22.AW41 129.01,92.2
DIECRACKMON: length 13.6
  BOTTOM w0.102: 152.49,114.29 152.11,113.91 U22.B2
  BOTTOM w0.127: 152.49,114.29 152.68,114.48 152.92,114.48 154.36,115.92 TP276.1 159.47,122.63 R646.1
DMIC_CLK: length 210.9
  TOP w0.114: v1(37.15,24.15) 36.85,23.85 v1(36.85,17.33) 36.85,15.26 31.86,10.27 27.63,10.27 R246.1
  IN3 w0.127: v1(115.92,25.93) 115.71,25.71 114.95,25.71 114.7,25.96 112.27,25.96 111.52,26.71 111.52,32.99 117.25,38.72 117.25,45.27 118.87,46.89 118.87,50.61 v1(117.09,52.39)
  IN4 w0.089: v1(170.5,56.65) 169.91,57.23 168.03,57.23 167.42,56.63 167.42,55.58 154.21,42.36 142.85,42.36 141.88,41.39 130.97,41.39 128.7,43.67 128.7,47.61 125.94,50.36 119.12,50.36 v1(117.09,52.39) ; v1(37.15,24.15) 37.74,24.15 38.37,24.79 49.13,24.79 50.03,25.69 51.42,25.69 52.39,26.66 56.9,26.66 57.89,27.64 99.74,27.64 103.55,31.45 109.52,31.45 111.32,29.65 111.32,27.24 112.15,26.41 113.39,26.41 113.91,25.9 115.9,25.9 v1(115.92,25.93)
  BOTTOM w0.114: v1(170.5,56.65) 171.39,55.76 R1051.1
DMIC_CLK_C: length 5.2
  BOTTOM w0.114: CN9.5 v1(169.6,52.79) 169.6,53.05 EC64.2 R1051.2
DMIC_CLK_R: length 4.5
  TOP w0.114: R246.2 26.4,10.58 EC32.2 23.87,10.58 v1(23.81,10.52) 23.59,10.3 CN5.29
DMIC_DATA: length 206.1
  TOP w0.114: R248.1 27.47,9.85 32.02,9.85 37.29,15.11 v1(37.29,19.13) v1(37.29,23.51)
  IN3 w0.127: v1(115.98,25.28) 114.77,25.28 114.53,25.52 112.09,25.52 111.09,26.53 111.09,33.17 116.82,38.9 116.82,45.45 118.43,47.07 118.43,50.38 v1(117.09,51.73)
  IN4 w0.089: v1(115.98,25.28) 115.75,25.5 113.74,25.5 113.23,26.02 111.98,26.02 110.93,27.08 110.93,29.49 109.36,31.06 103.71,31.06 99.9,27.25 58.05,27.25 57.06,26.26 52.55,26.26 51.59,25.29 50.19,25.29 49.29,24.4 46.6,24.4 46.12,23.92 38.06,23.92 37.65,23.51 v1(37.29,23.51) ; v1(117.09,51.73) 118.85,49.97 125.78,49.97 128.31,47.45 128.31,43.51 130.81,41 142.04,41 143.01,41.97 154.37,41.97 168.47,56.06 v1(168.47,56.62)
  BOTTOM w0.114: R1050.1 v1(168.47,56.62)
DMIC_DATA_C: length 6.6
  BOTTOM w0.114: CN9.4 v1(169.1,51.57) 169.1,53.69 EC63.2 169.37,53.69 169.69,54.01 169.69,55.52 R1050.2
DMIC_DATA_R: length 4.5
  TOP w0.114: CN5.30 24.03,9.8 24.25,9.57 EC33.2 25.57,9.57 v1(25.6,9.6) 25.63,9.63 R248.2
DP_AUX_ZVSS: length 11.2
  BOTTOM w0.114: U18.B9 56.02,109.8 53.7,112.12 53.7,113.03 51.44,115.29 48.69,115.29 R472.1
DP_STEREOSYNC: length 12.8
  BOTTOM w0.114: U18.E11 58.39,108.2 58.08,107.89 57.64,107.89 57.43,107.68 56.93,107.68 56.88,107.73 56.62,107.73 56.56,107.68 56.13,107.68 56.09,107.72 55.81,107.72 55.7,107.61 55.33,107.61 55,107.93 54.24,107.93 54.01,108.16 54.01,109.1 51.49,111.61 R497.1 50.82,111.17 49.16,111.17 48.97,111.37 R496.1
DP_ZVSS: length 6.8
  BOTTOM w0.114: R476.1 53.35,112.69 53.35,112 U18.A9
DQA0_0: length 36.3
  IN4 w0.114: v1(135.95,137.02) 135.52,136.59 135.52,135.94 135.54,135.92 135.54,133.99 135.54,133.98 135.54,131.76 133.49,129.72 133.49,119.15 132.38,118.04 132.11,118.04 129.7,115.62 129.7,113.22 128.88,112.41 128.88,110.09 130.32,108.65 132.62,108.65 v1(133.1,108.17)
  BOTTOM w0.14: U22.L34 133.1,108.1 v1(133.1,108.17) ; VRAM1.E2 v1(135.95,137.02)
DQA0_1: length 36.1
  IN4 w0.114: v2(131.5,108.2) 131.02,107.72 130.02,107.72 127.42,110.33 127.42,112.16 128.12,112.87 128.12,115.23 132.51,119.62 132.51,135.36 133.06,135.91 133.81,135.91 v1(134.3,135.42)
  BOTTOM w0.14: VRAM1.F4 134.7,135.82 134.3,135.42 v1(134.3,135.42) ; v2(131.5,108.2) 131.95,107.75 U22.L37
DQA0_2: length 34.3
  IN4 w0.114: v1(130.7,108.2) 130.19,108.2 127.87,110.51 127.87,111.97 128.58,112.68 128.58,115.1 133.04,119.55 133.04,133.36 133.16,133.49 134.09,133.49 134.72,134.12 134.72,135.83 v1(135.1,136.22)
  BOTTOM w0.14: VRAM1.E4 135.1,136.27 v1(135.1,136.22) ; U22.L38 131.15,107.75 v1(130.7,108.2)
DQA0_3: length 34.4
  IN4 w0.114: v1(136.75,136.22) 136.37,135.84 136.37,131.57 136.45,131.49 136.45,128.1 135.48,127.13 135.48,120.39 132.66,117.56 132.39,117.56 130.2,115.38 130.2,113.02 129.28,112.09 129.28,110.12 130.21,109.19 130.53,108.87 131.72,108.87 v1(132.15,109.3)
  BOTTOM w0.14: v1(132.15,109.3) 132.2,109.3 U22.J35 ; v1(136.75,136.22) VRAM1.F2
DQA0_4: length 35
  IN4 w0.114: v1(136.75,138.67) 137.35,138.67 137.5,138.52 138.28,138.52 139.19,137.61 139.19,120.23 133.87,114.92 133.25,114.92 133.01,114.69 133.01,113.6 131.81,112.4 131.81,111.33 131.4,110.91 v2(131.4,110.4)
  BOTTOM w0.14: U22.G37 131.7,110.1 v2(131.4,110.4) ; VRAM1.B2 136.4,139.02 v1(136.75,138.67)
DQA0_5: length 34.8
  IN4 w0.114: v1(131.33,111.55) 131.34,111.55 131.34,112.47 132.49,113.62 132.49,114.81 133.07,115.39 133.75,115.39 138.77,120.41 138.77,136.99 138.08,137.68 137.56,137.68 137,138.24 136.33,138.24 v1(135.15,139.42)
  BOTTOM w0.14: v1(131.33,111.55) 131.15,111.36 U22.E38 ; VRAM1.B4 v1(135.15,139.42)
DQA0_6: length 37.6
  IN4 w0.114: v1(135.15,140.22) 135.53,139.84 138.55,139.84 140.02,138.36 140.02,119.89 134.67,114.54 134.67,113.86 133.11,112.29 132.9,112.29 132.69,112.08 132.69,111.47 v1(132.2,110.97)
  BOTTOM w0.14: v1(135.15,140.22) VRAM1.A4 ; v1(132.2,110.97) 132.29,110.89 132.31,110.89 U22.E35
DQA0_7: length 34.3
  IN4 w0.114: v1(132.24,111.73) 132.24,112.31 133.32,113.39 133.32,114.35 133.46,114.5 134.04,114.5 139.61,120.06 139.61,138.14 138.32,139.42 v1(136.75,139.42)
  BOTTOM w0.14: U22.D35 132.62,111.35 v1(132.24,111.73) ; v1(136.75,139.42) VRAM1.A2
DQA0_8: length 37.9
  IN4 w0.114: v1(128.11,108.84) 126.94,110.01 126.44,110.01 126.11,110.34 126.11,111.11 123.91,113.31 123.91,116.88 125.09,118.06 125.09,138.66 126.25,139.82 127.55,139.82 v1(127.95,139.42)
  BOTTOM w0.14: VRAM1.B13 v1(127.95,139.42) ; U22.H41 129.17,109.07 128.33,109.07 v1(128.11,108.84)
DQA0_9: length 39.2
  IN4 w0.114: v1(127.34,108.89) 126.68,109.56 126.31,109.56 125.66,110.21 125.66,110.97 123.45,113.18 123.45,117.01 124.64,118.2 124.64,138.85 126.04,140.26 v1(127.15,140.26)
  BOTTOM w0.102: U22.H40 129.85,109.3 129.52,109.62 129.28,109.62 128.98,109.33
  BOTTOM w0.14: 128.98,109.33 127.78,109.33 v1(127.34,108.89) ; v1(127.15,140.26) 127.55,139.85 VRAM1.A13
DQA0_10: length 41.1
  IN4 w0.114: v1(128.75,140.22) 128.27,140.7 125.84,140.7 124.18,139.04 124.18,118.34 122.99,117.15 122.99,113.04 125.24,110.8 125.24,110.03 126.17,109.1 126.4,109.1 v1(126.6,108.89)
  BOTTOM w0.14: v1(126.6,108.89) 127.34,109.63 128.83,109.63 U22.G41 ; VRAM1.A11 v1(128.75,140.22)
DQA0_11: length 37
  IN4 w0.114: v1(126.58,110.51) 126.58,111.23 124.36,113.45 124.36,116.48 125.55,117.67 125.55,138.16 125.97,138.58 126.41,138.58 126.82,138.99 128.38,138.99 v1(128.75,138.62)
  BOTTOM w0.102: U22.G40 129.5,109.85 129.18,110.17 128.9,110.17 128.66,109.93
  BOTTOM w0.14: 128.66,109.93 127.16,109.93 v1(126.58,110.51) ; VRAM1.B11 v1(128.75,138.62)
DQA0_12: length 30.4
  IN4 w0.114: v1(127.98,136.22) 127.98,135.41 128.33,135.05 128.33,132.42 128.36,132.39 128.36,131.91 129.16,131.11 129.16,130.45 129.12,130.41 129.12,129.48 129.16,129.44 129.16,128.39 129.16,127.97 128.71,127.52 128.71,127.14 128.58,127.01 127.92,127.01 127.79,126.88 127.79,117.27 126.27,115.75 126.27,112.82 v1(126.95,112.15)
  BOTTOM w0.102: 128.42,111.37 128.53,111.37 128.64,111.27 129.18,111.27 129.32,111.12 129.58,111.12 U22.E40
  BOTTOM w0.14: v1(126.95,112.15) 127.65,112.15 128.42,111.37 ; VRAM1.E13 127.58,136.62 v1(127.98,136.22)
DQA0_13: length 29.4
  IN4 w0.114: v1(127.29,112.7) 126.73,113.26 126.73,115.61 128.3,117.19 128.3,124.72 128.43,124.85 129.02,124.85 129.15,124.98 129.15,126.36 130.27,127.49 130.27,130.76 129.99,131.05 129.99,133.36 129.65,133.7 129.65,134.53 v1(128.75,135.42)
  BOTTOM w0.102: 128.61,111.59 128.7,111.5 U22.D41
  BOTTOM w0.14: 128.61,111.59 127.75,112.45 127.5,112.7 v1(127.29,112.7) ; v1(128.75,135.42) 127.95,135.42 VRAM1.F13
DQA0_14: length 32.9
  IN4 w0.114: v1(127.65,113.24) 127.44,113.24 127.18,113.5 127.18,115.48 130.71,119.01 130.71,123.58 130.59,123.71 128.94,123.71 128.81,123.84 128.81,124.22 128.94,124.34 129.95,124.34 130.08,124.47 130.08,126.21 131.06,127.19 131.06,132.39 130.56,132.88 130.56,133.32 130.86,133.62 130.86,134.35 129.95,135.27 129.95,135.82 v1(129.55,136.22)
  BOTTOM w0.102: 128.75,111.85 128.87,111.73 129.19,111.73 129.31,111.82 129.53,111.82 129.85,111.5 U22.D40
  BOTTOM w0.14: v1(127.65,113.24) 128.05,112.84 128.05,112.55 128.75,111.85 ; VRAM1.F11 v1(129.55,136.22)
DQA0_15: length 36
  IN4 w0.114: v1(127.65,113.9) 127.65,115.35 131.98,119.69 131.98,124.09 131.86,124.22 130.71,124.22 130.59,124.34 130.59,124.72 130.71,124.85 131.86,124.85 131.98,124.98 131.98,125.36 131.86,125.49 130.71,125.49 130.59,125.61 130.59,125.99 130.71,126.12 131.86,126.12 131.98,126.25 131.98,126.63 131.51,127.1 131.51,136.12 130.14,137.5 129.23,137.5 v1(128.75,137.02)
  BOTTOM w0.14: U22.C41 128.85,112.1 128.3,112.65 128.3,113.51 127.92,113.9 v1(127.65,113.9) ; VRAM1.E11 v1(128.75,137.02)
DQA0_16: length 27.5
  BOTTOM w0.14: VRAM1.M11 128.75,131.42 126.55,131.42 126.39,131.58 125.94,131.58 122.92,128.56 v1(122.92,127.89) 122.92,123.67 124.76,121.83 124.76,117.41 127.9,114.28 128.21,114.28 128.6,113.88 128.6,112.76 128.89,112.47 129.33,112.47 U22.C40
DQA0_17: length 24.4
  BOTTOM w0.102: U22.B39 130.03,113.17 130.03,113.96
  BOTTOM w0.14: VRAM1.M13 127.15,130.62 126.6,130.62 126.55,130.67 125.76,130.67 123.44,128.35 v1(123.44,125.46) 123.44,123.89 125.28,122.04 125.28,117.63 128.12,114.8 129.19,114.8 130.03,113.96
DQA0_18: length 22
  BOTTOM w0.102: 130.33,114.07 130.33,113.52 U22.A39
  BOTTOM w0.14: VRAM1.N13 127.3,130.22 126.86,129.78 126.02,129.78 123.96,127.71 123.96,124.11 125.81,122.26 v1(125.81,121.39) 125.81,117.84 128.47,115.18 129.22,115.18 130.33,114.07
DQA0_19: length 24
  BOTTOM w0.102: 130.62,114.26 130.62,113.73 130.75,113.6 130.75,113.28 130.69,113.22 130.69,112.95 131,112.65 U22.B38
  BOTTOM w0.14: 130.62,114.26 129.25,115.62 128.76,115.62 126.33,118.06 126.33,122.48 v1(125.48,123.32) 124.54,124.26 124.54,126.5 124.54,126.5 124.54,127.45 125.99,128.9 126.52,128.9 126.6,128.98 126.88,128.98 127.15,129.25 127.15,129.57 127.4,129.82 128.75,129.82 VRAM1.N11
DQA0_20: length 17.8
  BOTTOM w0.102: U22.B36 132.1,112.65 131.8,112.95 131.8,113.27 131.87,113.34 131.87,113.75 131.98,113.86 131.98,114.44
  BOTTOM w0.14: 131.98,114.44 129.05,117.37 v1(129.05,122.79) 129.05,123.91 127.4,125.56 127.4,126.51 127.16,126.76 127.16,127.18 127.55,127.57 VRAM1.T13
DQA0_21: length 16.1
  BOTTOM w0.102: 132.21,114.59 132.21,113.77 132.1,113.66 U22.A36
  BOTTOM w0.14: 132.21,114.59 132.1,114.7 132.1,115.06 129.58,117.58 v1(129.58,124.06) 129.58,124.93 128.56,125.94 128.25,125.94 127.88,126.32 127.88,126.69 VRAM1.U13
DQA0_22: length 16.9
  BOTTOM w0.102: U22.B35 132.65,113.02 132.33,113.34 132.33,113.6 132.44,113.71 132.44,114.72 132.36,114.79
  BOTTOM w0.14: VRAM1.T11 128.77,127.45 128.77,126.89 130.11,125.56 v1(130.11,121.8) 130.11,117.7 132.36,115.44 132.36,114.79
DQA0_23: length 21.4
  BOTTOM w0.102: U22.A35 132.65,115.81
  BOTTOM w0.14: VRAM1.U11 129.51,126.66 130.11,126.66 130.31,126.86 130.31,128.64 130.59,128.92 131.35,128.92 131.88,128.38 131.88,128.18 130.64,126.94 v1(130.64,123.18) 130.64,117.82 132.65,115.81
DQA0_24: length 16.2
  BOTTOM w0.102: 133.55,114.7 133.55,114.5 133.34,114.29 133.34,113.8 133.45,113.69 133.45,113.32 133.75,113.02 U22.B33
  BOTTOM w0.14: 133.55,114.7 133.55,117.07 132.15,118.46 v1(132.15,121.37) 132.15,123.81 134.75,126.41 VRAM1.U4
DQA0_25: length 17.4
  BOTTOM w0.102: 134.16,114.24 134.16,113.84 134.07,113.75 134.07,113.31 133.98,113.19 133.98,112.97 134.3,112.65 U22.B32
  BOTTOM w0.14: 134.16,114.24 133.85,114.55 133.85,117.7 132.69,118.86 v1(132.69,119.65) 132.69,123.61 135.15,126.07 135.15,127.42 VRAM1.T4
DQA0_26: length 15.8
  BOTTOM w0.102: U22.A32 134.3,113.66 134.41,113.77 134.41,114.36
  BOTTOM w0.14: 134.41,114.36 134.15,114.62 134.15,118.33 133.21,119.28 133.21,123.28 v1(133.96,124.03) 136.43,126.49 136.43,126.94 VRAM1.U2
DQA0_27: length 17
  BOTTOM w0.102: 134.45,114.71 134.64,114.52 134.64,113.71 134.53,113.6 134.53,113.32 134.7,113.16 134.7,112.9 U22.B31
  BOTTOM w0.14: 134.45,114.71 134.45,118.97 v1(134.09,119.33) 133.73,119.69 133.73,123.06 136.75,126.08 136.75,127.12 136.35,127.53 VRAM1.T2
DQA0_28: length 21.7
  BOTTOM w0.102: U22.A30 135.4,113.78 135.31,113.87 135.31,114.65 135.45,114.79
  BOTTOM w0.14: 135.45,114.79 135.45,122.67 v1(136.32,123.54) 138.89,126.11 138.89,128.07 138,128.96 137.5,128.96 137.44,129.02 136.95,129.02 136.75,129.22 136.75,129.57 136.5,129.82 135.15,129.82 VRAM1.N4
DQA0_29: length 21.4
  BOTTOM w0.102: 135.75,114.75 135.52,114.52 135.52,113.99 135.55,113.96 135.65,113.86 135.65,113.27 135.95,112.97 U22.B29
  BOTTOM w0.14: VRAM1.N2 136.6,130.22 137.02,129.8 137.44,129.8 137.5,129.86 138.03,129.86 139.41,128.49 139.41,126.01 v1(137.48,124.08) 135.75,122.35 135.75,114.75
DQA0_30: length 22.9
  BOTTOM w0.102: U22.B28 136.5,112.65 136.2,112.95 136.2,113.24 136.27,113.31 136.27,113.75 136.36,113.84 136.36,114.39 136.05,114.7
  BOTTOM w0.14: VRAM1.M2 136.71,130.66 137.31,130.66 137.38,130.73 138.1,130.73 139.93,128.9 139.93,125.89 136.05,122.01 136.05,114.7
DQA0_31: length 25
  BOTTOM w0.102: 136.35,114.8 136.56,114.59 136.56,113.72 136.5,113.66 U22.A28
  BOTTOM w0.14: VRAM1.M4 134.99,131.02 135.39,131.42 137.25,131.42 137.49,131.66 138.11,131.66 v1(140.34,129.43) 140.45,129.31 140.45,125.83 136.35,121.72 136.35,114.8
DQA1_0: length 25.9
  BOTTOM w0.102: U22.B27 137.05,113 136.73,113.32 136.73,113.6 136.76,113.64 136.76,114.81 136.65,114.92
  BOTTOM w0.14: VRAM2.F4 147.13,131.48 144.99,131.48 144.79,131.69 144.26,131.69 v1(141.54,128.97) 140.97,128.4 140.97,125.75 136.65,121.43 136.65,114.92
DQA1_1: length 22.3
  BOTTOM w0.102: 136.97,115.29 136.97,113.53 U22.A27
  BOTTOM w0.14: 136.97,115.29 136.95,115.3 136.95,121.12 141.49,125.66 v1(141.49,127.36) 141.49,127.99 144.27,130.76 144.94,130.76 145.07,130.64 145.57,130.64 VRAM2.F2
DQA1_2: length 22.5
  BOTTOM w0.102: U22.B26 137.6,112.62 137.3,112.92 137.3,113.22 137.37,113.29 137.37,113.6 137.25,113.72 137.25,114.92
  BOTTOM w0.14: VRAM2.E2 145.72,130.24 145.32,129.84 144.13,129.84 142.01,127.72 v1(142.01,126.01) 142.01,125.59 137.25,120.83 137.25,114.92
DQA1_3: length 22.9
  BOTTOM w0.102: 137.53,114.73 137.45,114.66 137.45,113.9 137.6,113.75 U22.A26
  BOTTOM w0.14: 137.53,114.73 137.53,120.54 142.53,125.55 142.53,127.5 144,128.97 144.99,128.97 145.02,129 145.33,129 145.57,129.24 145.57,129.59 145.82,129.84 147.17,129.84 VRAM2.E4
DQA1_4: length 18.1
  BOTTOM w0.102: 138.5,114.85 138.81,114.54 138.81,113.77 138.7,113.66 U22.A24
  BOTTOM w0.14: 138.5,114.85 138.5,119.87 v1(140.94,122.31) 143.38,124.75 143.62,124.75 145.57,126.7 145.57,127.19 145.88,127.5 145.88,127.75 VRAM2.B2
DQA1_5: length 17.5
  BOTTOM w0.102: 138.9,114.95 139.04,114.81 139.04,113.72 138.93,113.61 138.93,113.32 139.09,113.16 139.09,112.91 U22.B23
  BOTTOM w0.14: 138.9,114.95 138.9,119.46 v1(142.93,123.5) 145.97,126.53 VRAM2.A2
DQA1_6: length 18.5
  BOTTOM w0.102: 139.2,115.1 139.25,115.05 U22.A23
  BOTTOM w0.14: 139.2,115.1 139.2,119.1 145.78,125.68 146.78,125.68 147.2,126.09 147.2,127.47 VRAM2.B4
DQA1_7: length 19.7
  BOTTOM w0.102: 139.51,115.21 139.51,113.69 139.57,113.64 139.57,113.31 139.48,113.19 139.48,112.97 139.8,112.65 U22.B22
  BOTTOM w0.14: 139.51,115.21 139.51,118.96 145.71,125.16 147.66,125.16 148.04,125.54 148.04,126.22 147.57,126.69 VRAM2.A4
DQA1_8: length 27.6
  BOTTOM w0.102: U22.B20 140.9,112.64 140.57,112.97 140.57,113.22 140.67,113.32 140.67,113.83 140.77,113.93 140.77,114.39
  BOTTOM w0.14: 140.77,114.39 140.36,114.8 140.36,118.37 144.67,122.68 148.41,122.68 v1(149.26,123.53) 150.02,124.3 150.02,128.07 150.63,128.68 151.51,128.68 152,128.19 152,126.75 152.23,126.52 152.65,126.52 VRAM2.A11
DQA1_9: length 28.1
  BOTTOM w0.102: U22.A20 140.9,113.66 141.05,113.81 141.05,114.6
  BOTTOM w0.14: VRAM2.B11 153.58,127.43 153.58,126.83 153.23,126.48 153.23,126.23 152.56,125.56 152.16,125.56 151.34,126.37 151.34,127.92 151.24,128.02 150.91,128.02 150.68,127.79 150.68,124.22 v1(150.45,123.99) 148.62,122.16 144.62,122.16 140.8,118.34 140.8,114.85 141.05,114.6
DQA1_10: length 23.5
  BOTTOM w0.102: U22.B19 141.45,113.01 141.76,113.32 141.76,113.57 141.55,113.78 141.55,114.95
  BOTTOM w0.14: 141.55,114.95 141.4,115.1 141.4,117.98 144.41,120.99 148.93,120.99 151.84,123.91 v1(152.78,123.91) 152.98,123.91 154.17,125.1 154.17,125.47 154.85,126.15 154.85,126.96 VRAM2.A13
DQA1_11: length 23.3
  BOTTOM w0.102: 141.3,114.75 141.3,113.6 U22.A19
  BOTTOM w0.14: 141.3,114.75 141.1,114.95 141.1,118.15 144.47,121.52 148.72,121.52 v1(149.23,122.03) 152.04,124.84 152.88,124.84 153.94,125.89 154.09,125.89 154.44,126.24 154.44,126.73 154.39,126.78 154.39,127.46 VRAM2.B13
DQA1_12: length 31.7
  BOTTOM w0.102: 142.4,115.05 142.98,114.47 142.98,113.86 142.87,113.75 142.87,113.32 142.73,113.18 142.73,112.92 U22.B17
  BOTTOM w0.14: 142.4,115.05 142.4,117.61 144.23,119.44 150.66,119.44 151.6,120.38 153.3,120.38 v1(154.78,121.87) 157.11,124.19 157.11,126.06 156.96,126.21 156.96,128.37 156.44,128.9 155.93,128.9 155.83,129 155.44,129 155.17,129.26 155.17,129.61 154.95,129.84 153.57,129.84 VRAM2.E11
DQA1_13: length 30.7
  BOTTOM w0.102: 142.66,115.18 143.19,114.65 143.19,113.77 143.1,113.68 U22.A16
  BOTTOM w0.14: VRAM2.E13 155.02,130.24 155.4,129.86 156.41,129.86 157.32,128.95 157.32,126.78 157.78,126.31 157.78,124.07 v1(157.32,123.6) 153.57,119.86 151.82,119.86 150.88,118.92 144.07,118.92 142.66,117.51 142.66,115.18
DQA1_14: length 33.2
  BOTTOM w0.102: U22.B16 143.1,112.65 143.43,112.97 143.43,113.19 143.34,113.31 143.34,113.61 143.42,113.69 143.42,114.83 142.91,115.33
  BOTTOM w0.14: VRAM2.F13 155.17,130.64 155.89,130.64 155.99,130.74 156.46,130.74 157.84,129.36 157.84,126.99 158.3,126.53 158.3,123.62 v1(156.79,122.11) 154.02,119.34 152.04,119.34 151.09,118.4 143.9,118.4 142.91,117.41 142.91,115.33
DQA1_15: length 35.2
  BOTTOM w0.102: U22.A15 143.65,115 143.21,115.44
  BOTTOM w0.14: 143.21,115.44 143.21,117.33 143.75,117.87 151.31,117.87 152.25,118.82 154.53,118.82 v1(156.18,120.47) 158.82,123.11 158.82,126.82 158.36,127.29 158.36,129.78 156.48,131.65 155.91,131.65 155.7,131.44 153.57,131.44 VRAM2.F11
DQA1_16: length 34.7
  IN4 w0.114: v1(143.65,115.75) 142.23,117.17 142.23,139.44 143.67,140.88 147.33,140.88 v1(147.97,140.24)
  BOTTOM w0.102: U22.B15 143.65,113 143.97,113.32 143.97,113.6 143.86,113.71 143.86,115.54
  BOTTOM w0.14: 143.86,115.54 v1(143.65,115.75) ; v1(147.97,140.24) VRAM2.U4
DQA1_17: length 30.7
  IN4 w0.114: v1(143.65,116.55) 142.65,117.55 142.65,139.01 144.07,140.42 145.34,140.42 v1(145.54,140.23)
  BOTTOM w0.102: U22.A14 144.2,113.71 144.1,113.81 144.1,116.1
  BOTTOM w0.14: VRAM2.U2 145.58,140.23 v1(145.54,140.23) ; 144.1,116.1 v1(143.65,116.55)
DQA1_18: length 30.2
  IN4 w0.114: v1(143.68,117.2) 143.07,117.81 143.07,138.27 144.28,139.48 145.53,139.48 v1(145.57,139.44)
  BOTTOM w0.102: U22.B14 144.2,112.65 144.53,112.97 144.53,113.19 144.44,113.31 144.44,113.81 144.32,113.93 144.32,116.3
  BOTTOM w0.14: VRAM2.T2 v1(145.57,139.44) ; 144.32,116.3 144.17,116.45 144.17,116.7 v1(143.68,117.2)
DQA1_19: length 31
  IN4 w0.114: v1(144.75,115.75) 144.2,116.3 144.2,117.57 143.48,118.29 143.48,137.96 144.07,138.54 146.27,138.54 v1(147.17,139.44)
  BOTTOM w0.102: U22.B13 144.75,113 145.07,113.32 145.07,113.84 145.18,113.95 145.18,114.37 144.75,114.8
  BOTTOM w0.14: 144.75,114.8 v1(144.75,115.75) ; v1(147.17,139.44) VRAM2.T4
DQA1_20: length 24.5
  IN4 w0.114: v1(145.85,114.95) 146.55,115.65 146.55,116.06 147.56,117.06 147.56,121.29 149.25,122.98 149.25,132.44 148.5,133.19 148.5,134.95 v1(148.02,135.44)
  BOTTOM w0.102: U22.A11 v1(145.85,114.95)
  BOTTOM w0.14: v1(148.02,135.44) 147.62,135.84 VRAM2.M4
DQA1_21: length 27.5
  IN4 w0.114: v1(145.85,115.85) 146.14,116.14 146.14,116.24 147.1,117.2 147.1,121.47 148.79,123.17 148.79,129.92 147.48,131.23 147.48,131.65 147.79,131.95 147.79,132.28 147.6,132.47 147.6,133.31 147.69,133.41 147.69,134.04 147.6,134.13 147.6,135.17 147.59,135.18 147.59,136.66 v1(147.97,137.04)
  BOTTOM w0.102: 146.3,115.4 146.3,114.8 146.06,114.56 146.06,113.71 146.17,113.6 146.17,113.32 146.02,113.17 146.02,112.92 U22.B11
  BOTTOM w0.14: VRAM2.N4 v1(147.97,137.04) ; 146.3,115.4 v1(145.85,115.85)
DQA1_22: length 25.5
  IN4 w0.114: v1(145.85,116.65) 146.62,117.42 146.62,122.16 147.37,122.91 147.37,128.49 147.71,128.83 147.71,129.46 146.77,130.4 146.77,135.84 v1(146.37,136.24)
  BOTTOM w0.102: 146.38,116.12 146.55,115.95 146.55,114.75 146.29,114.49 146.29,113.78 146.4,113.66 U22.A10
  BOTTOM w0.14: 146.38,116.12 v1(145.85,116.65) ; v1(146.37,136.24) VRAM2.N2
DQA1_23: length 25.5
  IN4 w0.114: v1(145.57,136.22) 146.01,135.78 146.01,135.08 145.94,135.01 145.94,131.44 145.72,131.23 145.72,119.3 145.99,119.04 145.99,117.59 v1(145.85,117.45)
  BOTTOM w0.102: U22.B10 146.4,112.65 146.73,112.97 146.73,113.19 146.64,113.31 146.64,113.75 146.52,113.86 146.52,114.42 146.75,114.65 146.75,116.14
  BOTTOM w0.14: v1(145.57,136.22) 145.95,135.84 VRAM2.M2 ; v1(145.85,117.45) 146.75,116.55 146.75,116.14
DQA1_24: length 29.7
  IN4 w0.114: v1(151.91,136.2) 151.4,135.69 151.4,134.12 150.55,133.27 150.55,130.84 150.67,130.71 151.22,130.71 151.34,130.59 151.34,130.2 151.22,130.08 150.67,130.08 150.55,129.95 150.55,129.57 150.67,129.44 151.22,129.44 151.34,129.32 151.34,128.93 151.22,128.81 150.67,128.81 150.55,128.68 150.55,122.13 149.07,120.65 v1(149.07,117.3)
  BOTTOM w0.102: 148.51,116.36 148.51,115.63 147.82,114.94 147.82,113.69 147.74,113.61 147.74,113.31 147.83,113.19 147.83,112.97 147.5,112.65 U22.B8
  BOTTOM w0.14: VRAM2.M11 152.81,136.2 v1(151.91,136.2) ; 148.51,116.36 148.51,116.73 v1(149.07,117.3)
DQA1_25: length 28.2
  IN4 w0.114: v1(153.52,137.04) 153.06,136.58 153.06,136.04 153.18,135.93 153.18,135.29 152.29,134.4 152.29,129.87 152.16,129.75 152.16,127.52 151.5,126.86 151.5,125.25 151.63,125.12 151.97,125.12 152.09,125 152.09,124.62 151.96,124.49 151.63,124.49 151.5,124.36 151.5,123.82 151.59,123.73 151.94,123.73 152.03,123.64 152.03,123.29 151.89,123.15 151.65,123.15 151.5,123 151.5,121.76 149.6,119.86 149.6,117 v1(149.15,116.55)
  BOTTOM w0.102: 148.74,115.96 148.74,115.54 148.05,114.85 U22.A7
  BOTTOM w0.14: v1(149.15,116.55) 149.15,116.37 148.74,115.96 ; VRAM2.N11 153.17,136.69 v1(153.52,137.04)
DQA1_26: length 26.9
  IN4 w0.114: v1(154.39,136.23) 154.39,136.01 153.9,135.52 153.9,134.88 153.98,134.8 153.98,132.39 153.99,132.39 153.99,127.1 153.49,126.6 153.49,121.24 150.88,118.63 v1(150.88,117.23)
  BOTTOM w0.102: U22.B7 148.05,113 148.37,113.32 148.37,113.6 148.26,113.71 148.26,114.75 150.74,117.23 v1(150.88,117.23)
  BOTTOM w0.14: v1(154.39,136.23) 154.39,136.26 VRAM2.N13
DQA1_27: length 26.4
  IN4 w0.114: v1(150.86,116.23) 151.15,116.23 151.72,116.79 151.72,117.71 155.22,121.21 v1(155.22,135.44)
  BOTTOM w0.102: v1(150.86,116.23) 150.45,116.23 149.52,115.3 149.14,115.3 148.5,114.66 148.5,113.78 148.6,113.68 U22.A6
  BOTTOM w0.14: v1(155.22,135.44) 154.82,135.84 VRAM2.M13
DQA1_28: length 32
  IN4 w0.114: v1(153.57,138.64) 154,139.07 155.4,139.07 155.66,138.82 155.66,137.57 155.7,137.52 155.7,127.09 156.68,126.12 156.68,122.08 v1(152.15,117.55)
  BOTTOM w0.102: 151.3,115.65 151.3,115.38 149.79,113.87 149.79,113.81 149.7,113.72 U22.A4
  BOTTOM w0.14: VRAM2.T11 v1(153.57,138.64) ; v1(152.15,117.55) 151.3,116.7 151.3,115.65
DQA1_29: length 32.8
  IN4 w0.114: v1(154.37,139.49) 155.53,139.49 155.89,139.12 156.03,139.12 156.59,138.56 156.59,135.17 157.24,134.52 157.24,121.84 v1(152.15,116.75)
  BOTTOM w0.102: v1(152.15,116.75) 151.64,116.24 151.64,115.59 151.52,115.47 151.52,115.24 150.02,113.74 150.02,113.66 149.94,113.58 149.94,113.31 150.03,113.19 150.03,112.97 149.85,112.8 149.85,112.55 U22.B4
  BOTTOM w0.14: v1(154.37,139.49) 154.77,139.09 VRAM2.T13
DQA1_30: length 32
  IN4 w0.114: v1(152.15,115.75) 157.72,121.32 157.72,134.9 156.99,135.64 156.99,137.83 156.83,137.98 156.83,138.71 156.5,139.05 156.5,139.79 156.04,140.24 v1(155.17,140.24)
  BOTTOM w0.102: v1(152.15,115.75) 151.73,115.33 151.73,115.07 150.3,113.64 U22.A3
  BOTTOM w0.14: VRAM2.U13 v1(155.17,140.24)
DQA1_31: length 35.4
  IN4 w0.114: v1(152.15,115.08) 158.18,121.11 158.18,135.18 157.34,136.02 157.34,137.94 157.1,138.18 157.1,138.81 156.91,139.01 156.91,139.77 155.88,140.8 154.13,140.8 v1(153.57,140.24)
  BOTTOM w0.102: U22.B3 150.69,113.18 150.69,113.66 152.1,115.08 v1(152.15,115.08)
  BOTTOM w0.14: VRAM2.U11 v1(153.57,140.24)
DQB0_0: length 37
  IN4 w0.114: v1(177.92,115.34) 178.47,115.89 178.95,116.37 178.95,118.78 177.25,120.49 163.05,120.49 157.98,115.42 154.32,115.42 v1(152.94,114.03)
  BOTTOM w0.102: v1(152.94,114.03) 152.94,113.34 152.08,112.48 151.38,112.48 U22.C2
  BOTTOM w0.14: VRAM3.A11 v1(177.92,115.34)
DQB0_1: length 32.5
  IN4 w0.114: v1(153.66,114.03) 154.59,114.96 158.17,114.96 163.24,120.03 176.32,120.03 177.93,118.41 v1(177.93,116.95)
  BOTTOM w0.102: U22.C1 152.02,112.1 153.66,113.74 v1(153.66,114.03)
  BOTTOM w0.14: VRAM3.A13 v1(177.93,116.95)
DQB0_2: length 33.6
  IN4 w0.114: v1(177.16,116.14) 177.45,116.43 177.45,118.25 176.13,119.57 163.43,119.57 158.36,114.5 154.8,114.5 v1(154.33,114.03)
  BOTTOM w0.102: v1(154.33,114.03) 154.26,114.03 152.08,111.85 151.9,111.85 151.79,111.73 151.51,111.73 151.39,111.82 151.17,111.82 151,111.65 150.75,111.65 U22.D2
  BOTTOM w0.14: VRAM3.B13 176.77,116.54 v1(177.16,116.14)
DQB0_3: length 33
  IN4 w0.114: v1(176.32,115.34) 176.72,115.74 176.72,116.45 176.99,116.72 176.99,118.06 175.94,119.12 163.62,119.12 158.54,114.03 v1(155.1,114.03)
  BOTTOM w0.102: 153.72,113.15 152.19,111.61 151.97,111.61 151.86,111.5 U22.D1
  BOTTOM w0.14: 153.72,113.15 154.46,113.15 155.1,113.78 v1(155.1,114.03) ; VRAM3.B11 176.72,114.94 176.32,115.34 v1(176.32,115.34)
DQB0_4: length 26
  IN4 w0.114: v1(173.13,116.94) 172.64,117.43 164.54,117.43 164.19,117.08 163.45,117.08 159.16,112.79 154.74,112.79 154.08,112.13 153.7,112.13 153.04,111.47 v1(153.04,111.11)
  BOTTOM w0.102: 152.51,110.31 151.96,110.31 151.87,110.4 U22.F1
  BOTTOM w0.14: 152.51,110.31 153.04,110.84 v1(153.04,111.11) ; VRAM3.F13 173.52,116.55 v1(173.13,116.94)
DQB0_5: length 26.3
  IN4 w0.114: v1(153.7,111.11) 154.14,111.55 161.07,111.55 162.75,113.22 170.37,113.22 170.92,113.77 171.68,113.77 173.92,116.01 v1(173.92,116.09)
  BOTTOM w0.102: 152.74,110.08 151.9,110.08 151.81,110.17 151.52,110.17 151.2,109.85 U22.G2
  BOTTOM w0.14: v1(153.7,111.11) 153.7,111.04 152.74,110.08 ; v1(173.92,116.09) 174.32,116.49 VRAM3.E13
DQB0_6: length 28
  IN4 w0.114: v1(154.44,111.06) 155.04,110.45 161.27,110.45 163.13,112.31 172.92,112.31 173.63,113.02 174.61,113.02 175.12,113.52 175.12,114.94 v1(174.72,115.34)
  BOTTOM w0.102: U22.G1 152.9,109.85
  BOTTOM w0.14: VRAM3.E11 v1(174.72,115.34) ; v1(154.44,111.06) 154.25,110.87 154.07,110.87 153.72,110.52 153.05,109.85 152.9,109.85
DQB0_7: length 26.2
  IN4 w0.114: v1(155.19,111.04) 161.21,111.04 162.94,112.77 172.15,112.77 v1(173.92,114.54)
  BOTTOM w0.102: 153.17,109.61 151.89,109.61 151.81,109.53 151.51,109.53 151.39,109.62 151.17,109.62 150.85,109.3 U22.H2
  BOTTOM w0.14: 153.17,109.61 153.88,110.33 154.56,110.33 155.19,110.95 v1(155.19,111.04) ; VRAM3.F11 173.82,114.64 173.82,114.64 v1(173.92,114.54)
DQB0_8: length 24.9
  IN4 w0.114: v1(155.65,107.65) 158.21,107.65 158.31,107.55 170.27,107.55 170.43,107.71 173.55,107.71 v1(173.92,107.34)
  BOTTOM w0.102: 152.53,108.32 152.06,108.32 151.95,108.43 151.51,108.43 151.39,108.52 151.17,108.52 150.85,108.2 U22.K2
  BOTTOM w0.14: 152.53,108.32 152.82,108.62 154.68,108.62 v1(155.65,107.65) ; VRAM3.F2 v1(173.92,107.34)
DQB0_9: length 25.7
  IN4 w0.114: v1(174.72,108.14) 174.32,108.54 169.47,108.54 169.44,108.57 167.85,108.57 167.02,109.41 166.35,109.41 166.05,109.11 163.61,109.11 162.61,108.11 155.31,108.11 v1(154.85,107.65)
  BOTTOM w0.102: U22.K1 151.87,108.2 151.97,108.09 152.64,108.09
  BOTTOM w0.14: 152.64,108.09 152.89,108.35 153.9,108.35 154.18,108.07 154.43,108.07 v1(154.85,107.65) ; VRAM3.E2 v1(174.72,108.14)
DQB0_10: length 26.4
  IN4 w0.114: v1(154.08,107.65) 154.23,107.65 155.14,108.56 162.25,108.56 163.9,110.21 170.42,110.21 170.51,110.13 171.06,110.13 171.81,109.37 174.35,109.37 v1(174.72,109.74)
  BOTTOM w0.102: 153,108.1 152.76,107.86 151.92,107.86 151.81,107.97 151.52,107.97 151.2,107.65 U22.L2
  BOTTOM w0.14: VRAM3.E4 v1(174.72,109.74) ; 153,108.1 153.6,108.1 154.05,107.65 v1(154.08,107.65)
DQB0_11: length 24
  IN4 w0.114: v1(153.15,107.65) 153.7,108.2 153.7,108.21 153.81,108.32 154.31,108.32 155.01,109.02 162.06,109.02 164.05,111.01 171.31,111.01 172.11,110.22 172.69,110.22 v1(173.12,109.79)
  BOTTOM w0.102: v1(153.15,107.65) U22.L1
  BOTTOM w0.14: VRAM3.F4 173.52,109.39 v1(173.12,109.79)
DQB0_12: length 31.6
  IN4 w0.114: v1(153.95,106.55) 154.59,105.91 156.7,105.91 158.32,104.28 175.31,104.28 176.4,105.37 176.4,108.22 v1(177.12,108.94)
  BOTTOM w0.102: U22.N2 151.2,106.55 151.52,106.87 151.94,106.87 152.05,106.98 152.5,106.98 152.93,106.55
  BOTTOM w0.14: VRAM3.B4 v1(177.12,108.94) ; 152.93,106.55 v1(153.95,106.55)
DQB0_13: length 31.8
  IN4 w0.114: v1(177.12,107.34) 177.51,106.95 177.65,106.95 178.07,106.54 178.07,106.16 175.77,103.86 157.14,103.86 v1(155.55,105.45)
  BOTTOM w0.102: U22.P2 150.85,106 151.17,106.32 151.39,106.32 151.51,106.23 151.95,106.23 152.04,106.14 154.21,106.14
  BOTTOM w0.14: 154.21,106.14 154.56,106.14 154.76,105.95 155.05,105.95 v1(155.55,105.45) ; VRAM3.B2 v1(177.12,107.34)
DQB0_14: length 32.3
  IN4 w0.114: v1(177.92,108.14) 178.53,107.53 178.53,105.97 176,103.44 156.76,103.44 v1(154.75,105.45)
  BOTTOM w0.102: U22.P1 151.87,106 151.96,105.9 154.3,105.9
  BOTTOM w0.14: v1(177.92,108.14) VRAM3.A2 ; 154.3,105.9 v1(154.75,105.45)
DQB0_15: length 35.4
  IN4 w0.114: v1(177.92,109.74) 178.98,108.68 178.98,105.78 176.23,103.02 156.38,103.02 v1(153.95,105.45)
  BOTTOM w0.102: U22.R2 151.2,105.45 151.52,105.77 151.81,105.77 151.9,105.68 153.72,105.68
  BOTTOM w0.14: 153.72,105.68 v1(153.95,105.45) ; VRAM3.A4 177.52,109.36 177.9,109.74 v1(177.92,109.74)
DQB0_16: length 31.9
  IN1 w0.114: v1(169.13,115.34) 168.74,114.95 168.08,114.95 167.44,115.59 167.44,116.35 167.11,116.68 167.11,117.19 166.66,117.64 166.66,118.28 165.56,119.37 162.82,119.37 160.15,116.7 160.15,108.93 v1(156.62,105.4)
  BOTTOM w0.102: U22.R1 153.32,105.45
  BOTTOM w0.14: VRAM3.M11 168.73,114.94 v1(169.13,115.34) ; 153.32,105.45 153.75,105.02 154.21,105.02 154.34,104.89 v1(156.11,104.89) v1(156.62,105.4)
DQB0_17: length 33.9
  IN1 w0.114: v1(154.16,104.28) 154.16,104.53 153.45,105.25 153.45,105.78 153.7,106.03 155.73,106.03 159.31,109.61 159.31,117.05 162.47,120.21 166.32,120.21 168.46,118.07 168.46,117.07 v1(168.35,116.96)
  BOTTOM w0.102: 153.17,105.21 151.87,105.21 151.79,105.13 151.51,105.13 151.39,105.22 151.17,105.22 150.85,104.9 U22.T2
  BOTTOM w0.14: v1(154.16,104.28) 154.16,104.31 153.72,104.75 153.64,104.75 153.17,105.21 ; v1(168.35,116.96) 168.72,116.59 VRAM3.M13
DQB0_18: length 31
  IN1 w0.114: v1(153.52,104.25) 153.52,104.03 153.72,103.83 154.48,103.83 154.91,104.26 155.65,104.26 156.01,104.61 156.01,105.55 159.73,109.27 159.73,116.87 162.65,119.79 165.82,119.79 167.55,118.07 167.55,116.97 v1(167.52,116.94)
  BOTTOM w0.102: 152.91,104.99 151.95,104.99 151.86,104.9 U22.T1
  BOTTOM w0.14: v1(153.52,104.25) 153.52,104.38 152.91,104.99 ; VRAM3.N13 v1(167.52,116.94)
DQB0_19: length 34.3
  IN1 w0.114: v1(168.3,115.37) 168.7,115.76 168.7,116.46 169.33,117.09 169.33,118.09 166.8,120.63 162.3,120.63 158.89,117.22 158.89,113.11 153.61,107.83 153.61,107.21 152.87,106.47 v1(152.87,104.26)
  BOTTOM w0.102: 152.46,104.66 151.51,104.66 151.36,104.5 151.1,104.5 U22.U2
  BOTTOM w0.14: 152.46,104.66 v1(152.87,104.26) ; v1(168.3,115.37) 167.92,114.99 VRAM3.N11
DQB0_20: length 25.2
  IN1 w0.114: v1(154.97,102.35) 156.75,102.35 162.01,107.62 162.01,115.49 163.57,117.05 164.07,117.05 164.18,116.94 v1(165.12,116.94)
  BOTTOM w0.102: 153.7,102.8 153.24,103.26 151.66,103.26 U22.W1
  BOTTOM w0.14: v1(154.97,102.35) 154.52,102.8 153.7,102.8 ; VRAM3.T13 v1(165.12,116.94)
DQB0_21: length 26
  IN1 w0.114: v1(165.12,116.14) 163.73,116.14 162.43,114.85 162.43,106.86 157.42,101.84 154.79,101.84 v1(154.32,102.31)
  BOTTOM w0.102: 153.63,102.55 153.13,103.05 151.93,103.05 151.81,102.93 151.52,102.93 151.2,103.25 U22.W2
  BOTTOM w0.14: VRAM3.U13 v1(165.12,116.14) ; v1(154.32,102.31) 154.08,102.55 153.63,102.55
DQB0_22: length 25.8
  IN1 w0.114: v1(165.12,115.34) 164.81,115.65 163.91,115.65 162.85,114.6 162.85,106.56 157.68,101.39 154.41,101.39 v1(153.68,102.12)
  BOTTOM w0.102: 153.05,102.6 152.85,102.8 151.97,102.8 151.87,102.7 U22.Y1
  BOTTOM w0.14: v1(153.68,102.12) 153.2,102.6 153.05,102.6 ; VRAM3.T11 v1(165.12,115.34)
DQB0_23: length 25.9
  IN1 w0.114: v1(164.21,115.2) 163.44,114.43 163.44,106.25 158.12,100.93 154.21,100.93 v1(153.02,102.12)
  BOTTOM w0.102: 153.02,102.26 152.68,102.6 152.08,102.6 151.95,102.46 151.51,102.46 151.39,102.37 151.17,102.37 150.85,102.7 U22.Y2
  BOTTOM w0.14: 153.02,102.26 v1(153.02,102.12) ; v1(164.21,115.2) 164.46,114.94 VRAM3.U11
DQB0_24: length 19.9
  BOTTOM w0.102: U22.AB2 150.85,101.6 151.17,101.27 151.39,101.27 151.51,101.36 151.81,101.36 151.88,101.3 154.21,101.3
  BOTTOM w0.14: 154.21,101.3 154.22,101.31 155.55,101.31 156.29,102.05 156.29,102.93 158.15,104.79 158.15,107.31 160.51,109.67 v1(161.33,109.67) 164.39,109.67 VRAM3.U4
DQB0_25: length 19.2
  BOTTOM w0.102: 153.17,101 153.12,101.05 U22.AC1
  BOTTOM w0.14: 153.17,101 155.92,101 156.81,101.88 156.81,102.71 158.67,104.58 158.67,106.89 v1(160.13,108.34) 160.79,109.01 164.37,109.01 164.41,108.96 164.91,108.96 165.28,109.34 VRAM3.T4
DQB0_26: length 18.8
  BOTTOM w0.102: U22.AC2 151.2,101.05 151.52,100.73 151.81,100.73 151.92,100.84 152.99,100.84 153.13,100.7
  BOTTOM w0.14: VRAM3.U2 164.37,108.09 160.81,108.09 v1(159.47,106.74) 159.19,106.47 159.19,104.36 157.33,102.5 157.33,101.82 156.21,100.7 153.13,100.7
DQB0_27: length 19.1
  BOTTOM w0.102: U22.AD1 151.87,100.5 151.97,100.6 152.75,100.6 153.05,100.3
  BOTTOM w0.14: 153.05,100.3 156.45,100.3 157.85,101.7 157.85,102.28 159.71,104.14 159.71,106.25 160.85,107.39 v1(161.48,107.39) 164.92,107.39 165.27,107.74 VRAM3.T2
DQB0_28: length 22.4
  BOTTOM w0.102: 154.18,99.32 152.02,99.32 151.95,99.4 U22.AF1
  BOTTOM w0.14: 154.18,99.32 154.21,99.3 155.6,99.3 155.73,99.43 158.29,99.43 v1(161.75,102.89) 162.5,103.64 164.51,103.64 166.67,105.8 166.67,106.65 166.74,106.72 166.74,107.16 166.92,107.34 167.27,107.34 167.52,107.59 167.52,108.94 VRAM3.N4
DQB0_29: length 22
  BOTTOM w0.102: 151.9,99.07 151.81,99.16 151.51,99.16 151.39,99.07 151.17,99.07 150.85,99.4 U22.AF2
  BOTTOM w0.14: VRAM3.N2 167.92,107.49 167.52,107.09 167.52,105.92 164.71,103.11 162.7,103.11 v1(160.87,101.27) 158.64,99.05 156,99.05 156,99.05 153.45,99.05 153.42,99.07 151.9,99.07
DQB0_30: length 21.6
  BOTTOM w0.102: 153.28,98.77 153.2,98.85 U22.AG1
  BOTTOM w0.14: 153.28,98.77 159.1,98.77 162.83,102.5 v1(164.02,102.5) 164.84,102.5 168.37,106.03 168.37,107.39 VRAM3.M2
