# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N2734263: length 42.2
  BOTTOM w0.152: PR220.1P 105.68,10.95 105.83,11.1 105.83,17.44 105.19,18.08 78.62,18.08 v1(77.9,17.36) 76.7,16.16 75.61,16.16 PC82.1 74.51,15.87 PC79.1 72.85,16.73 PR189.1
N2837902: length 4.2
  BOTTOM w0.114: Q23.5 261.3,54.72 261.2,54.82 260.77,54.82 260.65,54.7 Q23.6 v1(260.65,52.84) 260.65,52 R399.2
N2837932: length 5.2
  BOTTOM w0.114: Q23.3 261.95,55.26 262.12,55.1 262.59,55.1 v1(263.09,55.6) R394.1 263.97,54.72 264.32,54.37 R393.2
N2837976: length 4.9
  TOP w0.254: PQ72.3 265.96,58.87 266.23,58.6 v1(266.23,58.35) 265.93,58.04 v1(265.52,58.04)
  BOTTOM w0.254: v1(265.52,58.04) 265.52,56.8 265.1,56.38 C681.1 R394.2
N2875473: length 7.1
  TOP w0.114: v1(5.47,12.13) 5.65,11.96 R1112.1 R1111.1
  BOTTOM w0.114: v1(5.47,12.13) 5.21,12.13 4.28,13.06 4.28,14.5 3.35,15.43 CN10.52
N4259362:
  vias: v1(60.64,5.57)
N4908051: length 3.7
  BOTTOM w0.114: PR205.2 145.66,13.46
  BOTTOM w0.203: 147.49,11.74 147.49,11.56 147.73,11.32 PU2.20
  BOTTOM w0.254: 147.49,11.74 147.49,12.1 146.93,12.65 v1(146.83,12.65) 146.46,12.65 145.66,13.46
N5524290:
  vias: v1(61.1,4.81)
N6840049: length 2.4
  BOTTOM w0.254: Q25.6 180.35,38.03 180.53,38.21 v1(181.17,38.21) 181.17,38.21 R416.1
N8721558: length 1
  TOP w0.114: R749.1 R750.1
N8974652: length 4
  TOP w0.254: PQ43.6 57.48,13.36 PR245.2 58.81,14.05 59.09,13.77 v1(59.14,13.77) 59.71,14.34 PC253.1
N8974664: length 5.3
  TOP w0.254: PC253.2 60.91,14.11 v1(60.44,13.64) 59.72,12.92 PR242.1 57.9,12.92 57.69,12.71 PQ43.5
N8974676: length 2.9
  TOP w0.254: PQ44.2 53.12,14.71 53.86,15.45 v1(53.86,15.68) 53.86,15.8 53.56,16.11 PD7.2
N8974680: length 2
  TOP w0.254: PR243.2 50.6,14.72 v1(50.74,14.58) 50.81,14.51 PQ44.1
N8974688: length 6.7
  TOP w0.254: PQ43.2 54.02,12.71 52.95,11.63 52.27,11.63 52.13,11.48 PR244.1 v1(51.32,11.1) 51.32,12.11 51.74,12.53 PQ44.3
N9111136: length 1.8
  TOP w0.114: R642.1 118.61,107.83 118.95,107.83 R643.2
N9111150: length 1.8
  TOP w0.114: R644.2 119,109.02 118.79,109.02 R641.1
N17675684: length 4.7
  TOP w0.254: CN5.36 23.07,6.8
  TOP w0.508: R1087.2 R1088.2 25.34,6.71 25.22,6.83 C9370.1 23.09,6.83 23.07,6.8
N20819839: length 3.1
  TOP w0.114: CN13.15 40.81,20.3 40.45,19.94 v1(40.07,19.94) R518.2
N20819841: length 3.1
  TOP w0.114: CN13.13 40.32,21.57 v1(40.07,21.32) 39.89,21.14 R517.2
N20819843: length 3.1
  TOP w0.114: R515.2 39.92,22.43 v1(40.07,22.59) 40.32,22.84 CN13.11
N20932838: length 1.6
  TOP w0.114: TP137.1 80.63,110.88 v2(80.21,110.46)
  BOTTOM w0.102: U18.AL9 79.65,109.94 80.16,110.46 v2(80.21,110.46)
N20935118: length 13.8
  BOTTOM w0.114: D22.2 83,127.39 83.25,127.64 84.52,127.64 84.77,127.39 D21.2 84.77,126.12 85.03,125.86 86.3,125.86 86.55,126.12 D23.2 86.55,127.49 86.81,127.74 v1(87.82,127.74) 87.94,127.62 R562.1 R560.2 C764.1 87.94,124.81 88.42,124.33 Q36.6
N20935208: length 4.7
  BOTTOM w0.254: Q36.2 91.5,123.68 91.3,123.48 91.3,123.12 91.39,123.03 Q36.3 93.17,123.03 93.65,122.54 R570.1
N21204781: length 2.2
  TOP w0.114: TP80.1 267.17,66.73 267.94,66.73 268.22,66.45 U5.36
N21204898: length 2.3
  TOP w0.114: U5.18 275.41,67.65 275.53,67.53 R93.2
N21318962: length 1.1
  BOTTOM w0.254: PC9133.2 112.85,136.8 PR292.1
N21318970: length 50.9
  TOP w0.254: PR284.1 118.39,136.33 118.61,136.11 118.61,135.4 v1(118.51,135.3)
  IN2 w0.254: v1(76.62,133.53) 77.92,134.83 79.62,134.83 80.38,134.06 83.84,134.06 84.91,135.13 92.6,135.13 93.48,134.25 96.86,134.25 99.17,131.93 106.04,131.93 108.01,133.9 117.86,133.9 118.63,134.66 118.63,135.18 v1(118.51,135.3)
  BOTTOM w0.254: PL19.3 75.88,134.27 v1(76.62,133.53) ; PR279.2 118.14,135.67 v1(118.51,135.3)
N21318972: length 7
  TOP w0.254: v1(79.08,132.7) v1(79.87,132.7) 80,132.7 PR285.1
  BOTTOM w0.254: PL19.4 75.88,131.73 76.34,132.19 77.45,132.19 77.96,132.7 v1(79.08,132.7)
N21319071:
  vias: v1(89.5,137.39)
N21319138: length 2.2
  BOTTOM w0.254: PR296.1 90.46,133.46 v1(90.69,133.69) 91.14,134.13 PR291.1
N21319203: length 1
  BOTTOM w0.254: PR288.1 109.81,137.05 109.8,137.06 PC9127.2
N21319230: length 39.7
  IN1 w0.254: v1(120.85,150.49) 120.85,150.72 119.99,151.57 110.44,151.57 105.08,146.21 105.08,144.26 105.63,143.71 105.63,138.77 102.68,135.82 102.68,134 103.33,133.35 v1(104.5,133.35)
  BOTTOM w0.254: v1(120.85,150.49) 121.41,149.92 PR263.1 ; PL18.4 101.76,132.25 102.86,133.35 v1(104.5,133.35)
N21319232: length 38.8
  IN4 w0.254: v1(104.51,134.69) 104.31,134.89 104.31,136.61 105.21,137.52 105.21,146.26 110.79,151.84 121.32,151.84 v1(122.22,150.94)
  BOTTOM w0.254: PL18.3 101.76,135.29 102.36,134.69 v1(104.51,134.69) ; v1(122.22,150.94) v1(122.85,150.31) 122.85,148.73 PR261.2
N21319271: length 1.1
  BOTTOM w0.254: PC9095.2 115.64,149.78 PR250.1
N21319291: length 1
  BOTTOM w0.254: PR253.1 114.31,149.61 PC9099.2
N21319308: length 1.3
  TOP w0.254: PC9102.2 113.55,149.74 PR257.1
N21319358: length 23.8
  TOP w0.254: v1(118.56,147.11) 119.36,147.11 119.66,146.8 v1(119.66,146.41) PR280.2 PR276.1
  IN2 w0.254: v1(118.56,147.11) 117.93,146.48 117.93,141.88 117.93,141.87 117.1,141.04 116.65,141.04 116.34,140.73 116.34,140.02 115.68,139.36 109.33,139.36 107.53,137.56 107.53,137.12 106.88,136.47 v1(106.88,136.25)
  BOTTOM w0.254: v1(106.88,136.25) PR275.2
N21319374: length 37.6
  IN3 w0.254: v1(94.95,135.68) 95.28,135.34 100.16,135.34 102.68,137.86 112.63,137.86 113.08,138.32 117.25,138.32 118.01,139.08 118.01,140.39 119.57,141.95 v1(119.57,142.45)
  BOTTOM w0.254: PR281.2 120.44,142.45 v1(119.57,142.45) 118.77,143.24 PR278.1 ; PR277.2 90.59,135.46 v1(91.45,135.46) 92.04,135.46 92.67,136.08 94.54,136.08 v1(94.95,135.68)
N21319396: length 1.1
  BOTTOM w0.254: PC9131.2 111.61,136.98 111.83,137.2 PR289.1
N21319416: length 4.1
  TOP w0.254: PR264.2 115.21,148.73 v1(113.93,147.45) v1(113.12,147.45)
  BOTTOM w0.203: PU16.35 112.9,146.98 113.12,147.2 v1(113.12,147.45)
N21319424: length 5.4
  BOTTOM w0.203: PU16.25 108.28,143.46 PC9105.1
  BOTTOM w0.381: PC9105.1 108.13,143.02 107.84,142.73 106.64,142.73 PR254.1
N21319498: length 1.1
  BOTTOM w0.254: PR251.1 PR258.1
N21319549:
  vias: v1(79.62,134.14)
N21319655: length 41.5
  TOP w0.254: v1(119.19,135.29) 118.99,135.48 118.99,136.14 119.18,136.33 PR303.1
  IN2 w0.254: v1(85.28,134) 85.28,134.02 85.89,134.63 92.55,134.63 93.31,133.86 96.69,133.86 99.01,131.54 106.2,131.54 108.17,133.51 118.03,133.51 119.02,134.5 119.02,135.12 v1(119.19,135.29)
  BOTTOM w0.254: v1(119.19,135.29) 119.56,135.65 PR302.2 ; PL20.3 84.74,134.54 v1(85.28,134)
N21319657: length 5.3
  TOP w0.254: v1(81.78,132.73) 81.78,132.31 PR304.1
  BOTTOM w0.254: v1(81.78,132.73) 83.47,132.73 84.74,131.47 PL20.4
N21319706:
  vias: v1(96.81,136.83)
N21319821:
  vias: v1(106.31,148.82)
N21319902:
  vias: v1(105.63,139.48)
N21320002:
  vias: v1(111.47,150.7)
N21323214: length 49.3
  TOP w0.203: v1(68.06,133.96) v1(63.82,133.96) 60.43,133.96 60.07,134.32 57.2,134.32 55.62,132.73 55.62,128.17 53.18,125.73 48.32,125.73 46.91,124.32 46.91,120.32 46.19,119.6 46.19,116.06 44.28,114.15 38.14,114.15 v1(38.02,114.27)
  TOP w0.254: v1(38.02,114.27) 37.67,114.27 PR319.1
  BOTTOM w0.254: v1(38.02,114.27) 37.38,114.91 PR317.2 ; v1(68.06,133.96) PL21.3
N21323223: length 5.2
  TOP w0.254: v1(65.48,132.53) 65.43,132.59 PR322.1
  BOTTOM w0.254: PL21.4 68.06,131.93 67.46,132.53 v1(65.48,132.53)
N21323248: length 5.6
  TOP w0.254: PR345.1 v1(62.92,132.56)
  BOTTOM w0.254: v1(62.92,132.56) 62.5,132.97 61.35,132.97 60.07,131.7 PL22.4
N21323250: length 40.7
  TOP w0.203: v1(59.66,133.78) 57.13,133.78 55.95,132.6 55.95,128.04 53.31,125.4 48.46,125.4 47.24,124.18 47.24,120.18 46.52,119.46 46.52,115.92 44.41,113.81 38.22,113.81 v1(38.03,113.63)
  TOP w0.254: PR344.1 37.92,113.52 v1(38.03,113.63)
  BOTTOM w0.254: PL22.3 60.07,134.19 v1(59.66,133.78) ; v1(38.03,113.63) 37.47,113.63 PR341.2
N21323457: length 2.1
  BOTTOM w0.203: PU17.31 42.93,123.69 43.03,123.8 v1(43.09,123.8) PR312.1
N21323459: length 4.3
  BOTTOM w0.203: PU17.32 43.5,123.29 43.69,123.1 PR310.2 42.7,122.82 42.63,122.89 PU17.33
N21323488: length 2.3
  BOTTOM w0.203: PU17.34 42.88,122.49 v1(43.07,122.31) 43.4,122.31 PR307.2
N21323581:
  vias: v1(42.89,119.39)
N21323587:
  vias: v1(42.99,121.01)
N21323694: length 6
  BOTTOM w0.203: PU17.25 39.2,126.07 PC9145.1 38.93,126.81 38.93,128.71 v1(38.82,128.81) 38.85,128.83 39.29,128.83 PR305.1
N21323895: length 1.2
  BOTTOM w0.254: PR340.1 PR335.1
N21323983: length 1.3
  BOTTOM w0.254: PC9170.2 34,124.41 PR336.1
N21323993: length 3.1
  BOTTOM w0.254: PC9164.2 32.14,128.11 v1(32.14,126.8) 32.14,126.09 PR332.1
N21324209: length 33.4
  TOP w0.254: v1(43.89,120.16) 43.89,119.98 43.04,119.13 37.17,119.13 36.89,118.85 v1(36.89,118.37)
  BOTTOM w0.254: v1(36.89,118.37) 36.89,118.08 36.49,117.67 PR326.2 36.3,117.39 35.52,116.61 PR324.1 ; v1(43.89,120.16) 44.02,120.03 45.1,120.03 45.87,120.81 45.87,123.95 48.02,126.09 48.02,131.32 50.28,133.58 53.87,133.58 54.38,133.07 55.69,133.07 PR323.2
N21324276: length 1.9
  BOTTOM w0.381: PR333.1 v1(31.48,123.85) 31.27,123.63 PC9166.2
N21324680: length 1.4
  BOTTOM w0.508: PR308.2 PC9149.1
N21324706: length 1.5
  TOP w0.508: PR313.1 71.18,136.3 71.8,136.92 PC9150.2
N21324846:
  vias: v1(37.43,128.76)
N21324850:
  vias: v1(56.22,135.06)
N21327684: length 6.8
  BOTTOM w0.254: PR368.2 127.06,47.25 127.51,47.25 128.16,47.9 v1(128.16,48.29) 127.92,48.53 PR510.1 PC9208.1 126.2,49.05 126.36,49.22 PU20.4
N21327720: length 4.8
  BOTTOM w0.254: PU20.5 125.41,49.38 124.96,48.93 PR370.2 124.61,48.53 124.45,48.37 124.45,46.69 124.74,46.39 PR366.1
N21327736: length 1.5
  BOTTOM w0.381: PR369.1 PC9209.2
N21328285: length 3.6
  BOTTOM w0.254: PU19.23 144.19,37.58 144.46,37.85 v1(146.11,37.85) 147.04,37.85 PC9201.1
N21328291: length 1.6
  BOTTOM w0.254: PU19.6 145.7,34.06 PR360.1
N21328299: length 3.6
  BOTTOM w0.254: PU19.5 v1(146.39,34.56) 146.69,34.56 146.77,34.64 PR364.1 PR362.2
N21328309: length 31.7
  IN4 w0.254: v1(149.02,35.04) 148.77,35.29 146.92,35.29 145.94,34.3 145.94,32.55 145.44,32.05 138.84,32.05 138.38,32.51 130.78,32.51 124.95,38.34 v1(124.25,38.34)
  BOTTOM w0.254: PR362.1 148.63,35.42 v1(149.02,35.04) ; v1(124.25,38.34) SJ15.2
N21328315: length 3.5
  BOTTOM w0.254: 143.35,38.11 143.19,37.95 PU19.21
  BOTTOM w0.508: PR363.1 PC9202.1 143.83,38.59 143.35,38.11
N21328341:
  vias: v1(135.09,36.25)
N21328349: length 1.9
  TOP w0.381: v1(137.33,36.89) 137.55,36.89 137.73,36.71 v1(137.73,36.3) PC9194.1
N21328385:
  vias: v1(141.54,41.08)
N21328393: length 1.8
  BOTTOM w0.254: PU19.20 142.69,38.49 PR359.1
N21328924: length 3.5
  BOTTOM w0.254: PR374.2 PR375.1 121.34,39.62 121.22,39.5 PU21.7
N21328930: length 3.7
  BOTTOM w0.508: PU21.2 121.22,31.71 120.08,30.57 PC9212.1 PR373.1
N21330723: length 4.8
  BOTTOM w0.508: PR387.2 26.69,51.68 v1(26.69,51.67) 26.68,51.56 26.69,51.55 PR388.1 26.39,50.81 25.88,51.32 25.88,52 25.58,52.3 PU23.7
N21330729: length 4.4
  BOTTOM w0.114: PU23.2 v1(17.67,52.3) 17.12,52.3 17.07,52.35 PC9235.1 PR481.2 PR386.2
N21336998: length 50.3
  TOP w0.254: v1(126.25,71.96) v1(125.77,71.48) 124.65,70.36 124.65,58.44 128.95,54.15 128.95,47.61 130.21,46.35 130.62,46.35 v1(130.89,46.08) 131.51,46.08 PR418.1
  BOTTOM w0.254: v1(126.25,71.96) 126.41,71.8 142.11,71.8 142.69,71.23 PL27.3 ; v1(130.89,46.08) 131.4,45.57 PR417.2
N21337000: length 3.5
  TOP w0.254: v1(142.42,73.46) 142.12,73.77 PR419.1
  BOTTOM w0.254: v1(142.42,73.46) 142.69,73.73 PL27.4
N21337006:
  vias: v1(143.14,56.7)
N21337030:
  vias: v1(140.93,67.59)
N21337211: length 37.5
  TOP w0.254: PR441.1 131.96,46.9 v1(130.88,46.9) 130.71,46.73 130.37,46.73 129.33,47.77 129.33,54.31 125.03,58.6 125.03,70.2 125.8,70.97 v1(126.25,70.97)
  BOTTOM w0.254: v1(130.88,46.9) 131.08,47.1 PR440.2 ; v1(126.25,70.97) 126.49,71.21 131.91,71.21 132.02,71.1 PL28.3
N21337215: length 3.2
  TOP w0.254: PR444.1 v1(132.02,73.64)
  BOTTOM w0.254: v1(132.02,73.64) PL28.4
N21337239: length 1
  BOTTOM w0.254: PR395.1 PR402.1
N21337282:
  vias: v1(135.29,55.91)
N21337322: length 41.6
  IN4 w0.254: v1(151.05,47.31) 154.78,47.31 163.12,55.65 163.12,65.93 159.93,69.12 157.4,69.12 155.5,71.01 v1(154.76,71.01)
  BOTTOM w0.254: SJ19.2 151.97,71.38 152.34,71.01 v1(154.76,71.01) ; PR405.1 v1(151.05,47.31)
N21337324: length 38.7
  IN2 w0.254: v1(155.02,69.62) 156.32,68.31 160.68,68.31 162.42,66.57 162.42,55.19 v1(152.3,45.07)
  BOTTOM w0.254: v1(155.02,69.62) 154.68,69.95 152.25,69.95 152.07,69.77 SJ18.2 ; PR404.2 v1(152.3,45.07)
N21337361:
  vias: v1(153.3,64.27)
N21337426:
  vias: v1(148.45,55.83)
N21337478: length 1.1
  BOTTOM w0.254: PC9242.2 PR394.1
N21337492: length 1
  BOTTOM w0.254: PC9244.2 PR396.1
N21337509: length 2.2
  TOP w0.254: PC9251.2 v1(147.75,49.8) 147.75,49.77 146.93,48.95 PR401.1
N21337833: length 1
  BOTTOM w0.254: PR439.1 PR435.1
N21337892: length 1.3
  BOTTOM w0.254: PC9278.2 132.97,50.18 132.7,50.46 PR433.1
N21337910: length 1.8
  BOTTOM w0.254: PR431.1 133.75,52.53 134.12,52.16 134.61,52.16 PC9274.2
N21338013: length 27.5
  TOP w0.254: v1(131.33,48.56) 132.06,47.83 134.27,47.83 PR423.1 PR425.2
  BOTTOM w0.152: v1(131.33,48.56) v1(130.82,49.07) 130.82,53.1 129.26,54.66 127.74,54.66 124.64,57.76 124.64,57.76 124.64,57.99 PR422.2
N21338031: length 42
  BOTTOM w0.152: PR420.2 156.28,73.5 161.02,68.76 161.02,52 152.82,43.8 150.35,43.8 v1(150.28,43.74) 149.76,43.21 148.19,43.21 147.98,43.42 PR424.2
  BOTTOM w0.254: PR424.2 PR421.1
N21338063: length 2.2
  TOP w0.254: PC9275.2 v1(136.61,52.79) 136.61,52.68 136.21,52.28 136.2,52.28 135.78,51.87 PR432.1
N21338079: length 6.1
  BOTTOM w0.203: 140.49,53.85 140.71,53.62 140.71,52.95 140.58,52.82 PU24.25
  BOTTOM w0.254: PR397.1 139,56.24 v1(138.75,55.99) 138.75,55.48 138.92,55.3 PC9253.1 138.92,54.82 139.23,54.51 139.82,54.51 140.49,53.85
N21339343: length 3
  BOTTOM w0.254: PU25.2 170.11,61.04 171.08,60.06 PC9296.1 PR450.2
N21339361: length 3.2
  BOTTOM w0.254: PU25.23 171.57,62.1 v1(173.06,60.61) PC9297.1
N21339367: length 4.7
  BOTTOM w0.254: PR449.2 v1(168.12,58.18) 168.37,58.18 168.62,58.43 168.62,60.25 168.11,60.77 PU25.6
N21339375: length 2.8
  BOTTOM w0.254: PU25.5 168.6,60.81 169.13,60.29 PR454.1 PR452.2
N21339385: length 25.9
  BOTTOM w0.254: PR452.1 170.09,58.6 169.09,57.59 v1(165.29,57.59) 164.05,57.59 163.37,58.27 163.37,72.94 165.46,75.03 SJ20.2
N21339393: length 4.1
  BOTTOM w0.254: 172.4,63.05 172.35,63.1 PU25.21
  BOTTOM w0.508: 172.4,63.05 v1(172.66,63.05) 173.04,63.43 PC9298.1 PR453.1
N21339411:
  vias: v1(164.15,67.92)
N21339426:
  vias: v1(171.77,66.81)
N21339465:
  vias: v1(175.96,66.27)
N21339473: length 3.3
  BOTTOM w0.254: 172.35,63.73 172.22,63.6 PU25.20
  BOTTOM w0.508: PR447.1 172.94,64.85 v1(172.61,64.52) 172.61,63.99 172.35,63.73
N21342284: length 1.6
  BOTTOM w0.114: PC9323.1 119.06,25.2 119.14,25.28 119.56,25.28 119.62,25.22 PU27.12
N21342286: length 1.7
  BOTTOM w0.114: PU27.10 119.7,24.42 119.47,24.19 PC9324.1
N21342302: length 6.2
  BOTTOM w0.114: PR500.1 PR501.1 126.38,23.6 v1(126.1,23.32) 125.97,23.2 124.97,23.2 PC9320.1 124.23,23.68 123.49,24.42 PU27.5
N21342308: length 4.5
  BOTTOM w0.114: PR465.2 126.29,26.04 125.91,26.42 124.95,26.42 PC9319.1 123.95,25.96 123.21,25.22 PU27.3
N21342378: length 1.7
  BOTTOM w0.191: PU28.12 163.19,24.1 162.95,24.34
  BOTTOM w0.254: 162.95,24.34 PC9325.1
N21342380: length 1.8
  BOTTOM w0.191: PU28.10 163.1,23.3 162.99,23.2
  BOTTOM w0.254: 162.99,23.2 162.86,23.07 162.35,23.07 PC9326.1
N21342398: length 5.8
  BOTTOM w0.191: PU28.5 166.53,23.3
  BOTTOM w0.254: 166.53,23.3 v1(167.07,23.3) 167.37,23.3 167.69,22.98 PC9322.1 167.92,22.86 168.31,22.47 169.14,22.47 PR499.1 PR502.1
N21342406: length 4.9
  BOTTOM w0.191: 166.61,24.24 166.48,24.1 PU28.3
  BOTTOM w0.254: 166.61,24.24 166.96,24.59 v1(167.11,24.59) 167.12,24.59 167.14,24.59 PC9321.1 167.92,25.31 168.39,24.85 169.17,24.85 PR463.2
N21417994: length 11.8
  BOTTOM w0.254: Q40.2 128.95,84.56 129.38,84.14 129.38,83.71 129.09,83.42 127.69,83.42 127.28,83 124.92,83 v1(124.57,83.35) R1015.1 R1016.2 124.02,84.69 124.65,84.69 125.04,84.3 125.6,84.3 125.86,84.56 Q40.5
N22904348: length 2.9
  BOTTOM w0.203: PU9.7 22.02,43
  BOTTOM w0.254: PR115.2 22.7,44.55 22.09,43.94 v1(22.09,43.39) 22.02,43.32 22.02,43
N22908658: length 2.4
  TOP w0.508: PR382.1 v1(21.46,34.48) 21.82,34.83 PC9219.2
N23370488: length 3
  BOTTOM w0.254: PU18.2 35,109.3 34.71,109.59 PC9186.1 34.6,110.55 33.51,110.55 33.4,110.43 33.4,110.43 PR353.2
N23370512: length 4.4
  BOTTOM w0.254: PR477.2 38.01,111.84 v1(37.81,112.04) 37.76,112.04 37.5,111.79 37.5,110.16 37,109.66 PU18.6
N23370520: length 2.7
  BOTTOM w0.254: PR478.2 PR474.1 37,110.19 36.5,109.7 PU18.5
N23370528: length 29.5
  TOP w0.254: v1(33.41,111.84) 33.13,111.84 29.81,108.52 29.81,96.7 29.34,96.23 29.34,93.61 29.2,93.47 v1(28.82,93.47)
  BOTTOM w0.254: PR478.1 35.16,112.12 v1(34.48,112.12) 34.2,111.84 v1(33.41,111.84) ; PR493.1 30.61,97.6 30.72,97.49 30.72,96.1 PR494.1 29.77,95.57 29.36,95.16 29.36,93.81 29.01,93.47 v1(28.82,93.47)
N23370536:
  vias: v1(32.83,108.23)
N23370587: length 1.2
  TOP w0.508: PC9343.1 v3(34.17,100.83)
  vias: v1(33.21,104.37)
N23379083: length 3
  BOTTOM w0.254: PU18.23 33.56,108.29 33.39,108.46 33.39,109.18 33.09,109.48 v1(33.08,109.48) 33.08,109.48 PC9350.1
N23379108:
  vias: v1(35.07,98.81)
N23379126: length 1.5
  BOTTOM w0.508: PR475.2 PC9344.1
  vias: v1(29.83,105.8)
N23379130: length 2.3
  BOTTOM w0.254: PU18.20 33.24,106.79
  BOTTOM w0.508: PR475.1 32.03,105.97 v1(32.85,106.79) 33.24,106.79
N23650304: length 3.6
  TOP w0.114: R138.1 v1(184.59,42.93) C486.1 184.59,44.66 184.6,44.67 Q8.2
N23650397: length 17.7
  TOP w0.114: R138.2 185.37,41.37 184.93,40.94 v1(181.19,40.94) 179.45,40.94 177.26,43.12 177.26,46.62 177.15,46.73 175.92,46.73 175.66,46.47 R122.2 174.22,46.47 174.18,46.43 Q6.3
N23657334: length 3.7
  BOTTOM w0.114: PQ71.2 135.13,29.32 PC9363.1 PR506.1 PR505.1
N23657362: length 5.8
  BOTTOM w0.114: PQ70.2 32.83,77.44 32.66,77.27 31.84,77.27 v1(31.36,77.75) PC9362.1 PR504.1 PR503.1
N23726703:
  vias: v1(130.34,67.37)
N23908431: length 5
  BOTTOM w0.114: Q41.6 220.73,17.06 220.66,17 220.16,17 220.08,17.07 Q41.5 220.08,18.52 219.88,18.72 219.49,18.72 219.28,18.94 v1(219.28,19.15) R861.1
N23910724: length 4.3
  TOP w0.114: U34.12 218.86,19.81 218.13,20.55 v1(217.79,20.55) 217.78,20.55 C1190.1
N23910978: length 3
  TOP w0.114: D43.2 218.47,16.74 218.77,16.44 v1(219.29,16.44) 219.52,16.21 U34.21
N23911170: length 3
  TOP w0.114: U34.81 v1(237.97,18.21) 238.64,18.88 D42.1
N23911426: length 5.7
  TOP w0.203: U34.3 219.63,23.41 219.47,23.58
  TOP w0.508: C1182.2 216.76,24.92 217.92,24.92 218.16,24.68 R1071.2 218.81,24.24 219.47,23.58
N23998288: length 4.7
  BOTTOM w0.114: PR175.2 v1(31.31,75.67) 31.69,75.29 31.99,75.29 32.18,75.48 PQ70.6 32.18,76.8 32.31,76.92 32.7,76.92 32.83,76.8 PQ70.5
N23998293: length 11
  TOP w0.508: v1(36.11,83.04) v1(36.11,80.85) v1(36.11,78.79)
  BOTTOM w0.254: PQ70.3 33.48,77.43
  BOTTOM w0.305: PQ73.4 v1(36.11,83.04) ; v1(36.11,78.79) PQ52.4
  BOTTOM w0.508: 33.48,77.43 33.84,77.07 PR178.2 PC188.1 34.6,78.41 34.98,78.79 v1(36.11,78.79)
N24059824: length 4.8
  BOTTOM w0.114: PR484.2 131.03,31.22 130.67,30.87 v1(130.67,30.79) 130.67,30.36 131.07,29.97 PQ71.6 132.42,29.97 132.54,29.85 132.54,29.44 132.41,29.32 PQ71.5
N24059826: length 9.2
  BOTTOM w0.254: PQ71.3 134.65,28.67 134.76,28.55 135.16,28.55 PC9354.1
  BOTTOM w0.508: PQ53.3 130.08,29.89 v1(130.51,29.46) 130.7,29.27 130.7,28.44 131.28,27.85 PR485.2 134.95,27.85 135.31,28.22 PC9354.1
N24355958: length 3.5
  BOTTOM w0.254: U202.2 160.01,38.41 159.79,38.19 159.79,36.82 v1(160.06,36.56) 160.17,36.45 R1021.2
N24355962: length 6.8
  BOTTOM w0.254: R1022.1 161.01,40 161.22,39.79 161.22,39.21 161.07,39.06 U202.1 159.95,39.06 159.29,38.4 158.48,38.4 158.12,38.05 158.12,37.17 v1(158.31,36.99) 158.31,36.26 R1023.2
N24356422: length 4.9
  BOTTOM w0.254: R1026.2 154.8,40.36 154.8,40.37 R1024.1 154.36,40.13 154.08,39.85 153.88,39.85 153.34,39.31 153.34,38.04 153.57,37.81 U203.1
N24356510: length 17.6
  IN1 w0.089: v1(155.86,39.7) 157.34,39.7 158.18,40.55 158.18,46.25 154.9,49.54 v1(154.18,49.54)
  BOTTOM w0.114: R1020.1 v1(154.18,49.54) ; v1(155.86,39.7) 155.52,39.7 154.92,39.1 154.92,38.67 154.71,38.46 U203.2
N24357397: length 5.2
  BOTTOM w0.254: U203.5 155.89,37.44 155.64,37.19 C1239.1 156.16,36.44 v1(156.53,36.81) 156.85,37.13 156.85,37.76 157.05,37.95 R1028.2 157.35,38.98 R1029.2
N24357816: length 3.5
  BOTTOM w0.254: R1030.2 153.49,36.17 153.48,36.65 v1(153.49,36.65) 153.49,37.21 153.48,37.36 152.96,37.88 152.96,38.21 152.69,38.49 U205.2
N24357876: length 7.3
  BOTTOM w0.254: U205.5 150.69,39.14 150.89,39.34 150.89,39.66 150.72,39.83 C9367.1 151.22,40.35 151.22,40.35 R1032.2 151.71,40.65 152.44,41.38 154.19,41.38 v1(154.19,41.38) 154.19,41.38 R1031.2
N24358102: length 5.2
  BOTTOM w0.254: R1034.1 R1035.2 149.33,38.57 150.96,38.57 151.53,39.14 U205.1
N24499832: length 4.6
  TOP w0.114: PR492.2 PR495.2 38.72,110.03 v1(37.76,110.98) v1(36.89,111.86)
  BOTTOM w0.114: v1(36.89,111.86) 37,111.75 PR474.2
N24502919: length 4.2
  BOTTOM w0.203: PU24.35 143.96,49.96 143.99,49.93 144.53,49.93 144.55,49.94
  BOTTOM w0.254: 144.55,49.94 144.7,49.94 v1(145.96,51.21) 146.24,51.48 PR496.1
N24606322: length 1.9
  TOP w0.114: D5.1 v1(176.68,43.96) 176.68,43.08 R1038.1
N24670022: length 190
  TOP w0.254: v1(125.94,51.32) 125.55,50.93 125.55,46.71 124.92,46.08 124.92,42.43 125.24,42.11 125.24,39.59 124.92,39.27 124.92,35.05 125.56,34.41 v1(125.56,33.63) ; R1044.2 211.17,15.31 v1(210.75,15.72) ; R1040.1 v1(228.93,30.89)
  IN1 w0.254: v1(228.93,30.89) 227.56,32.26 222.18,32.26 v1(220.6,30.68)
  IN3 w0.254: v1(220.6,30.68) 219.94,30.02 217.51,30.02 210.66,23.17 197.45,23.17 190.26,15.98 180.64,15.98 177.8,18.82 149.33,18.82 147.01,21.14 147.01,22.58 149.59,25.15 149.59,29.59 150.97,30.98 150.97,34.88 149.27,36.58 149.27,38.87 148.33,39.81 148.33,40.54 147.4,41.47 146.03,41.47 143.67,39.11 133.57,39.11 130.6,36.14 127.33,36.14 125.66,34.47 125.66,33.73 v1(125.56,33.63)
  BOTTOM w0.254: v1(125.94,51.32) 126.62,51.32 R1042.1 ; v1(210.75,15.72) 210.75,22.88 214.48,26.61 v1(218.59,26.61) 220.6,28.62 v1(220.6,30.68) ; R1043.1 122.48,29.69 124.61,31.82 124.61,32.68 v1(125.56,33.63)
N24670249: length 5.4
  TOP w0.114: R433.2 232.74,30.52 231.75,31.51 R202.1 231.75,32.06 R1074.2 232.74,32.61 232.98,32.86 v1(233.31,32.86) 233.74,32.42 R201.1
N24670478: length 5
  TOP w0.114: R1075.1 R1076.1 v1(241.86,22.7) 241.75,22.59 C9366.1 R1045.1 R1046.2
N24672527: length 59.3
  BOTTOM w0.114: Q23.2 261.3,55.22 261.67,54.86 262.98,54.86 C1237.2 262.6,53.45 v1(262.6,51.29) 262.6,50.74 258.7,46.84 251.44,46.84 245.75,41.15 238.89,41.15 237.35,39.61 237.35,33.24 235.61,31.5 230.95,31.5 228.56,29.11 R1048.1 R1049.1
N24812312: length 2.8
  TOP w0.254: v1(145.86,36.38) PC9368.1 PR511.1
  BOTTOM w0.254: v1(145.86,36.38) 145.54,36.38 145.22,36.06 PU19.2
N24814069: length 4.1
  BOTTOM w0.114: PR512.1 135.54,53.8 137.78,51.56 PU24.20
N24862121: length 5.8
  BOTTOM w0.203: PR508.2 108.09,137.68 108.27,137.85 108.27,138.89 v1(108.88,139.5) 110.05,139.5 111.3,140.76 PU16.20
N24881921: length 6.4
  BOTTOM w0.254: PQ65.2 115.44,54.16 115.2,53.92 v1(115.2,53.45) 115.84,52.81 PR457.1 116.39,52.21 116.52,52.08 116.52,51.47 117.44,50.55 PQ66.3
N24881929: length 9.3
  IN4 w0.635: v1(122.27,64.4) v1(122.27,59.74)
  BOTTOM w0.635: v1(122.27,64.4) PQ64.1 121.19,63.73 v1(121.78,63.13) 121.83,63.09 PC9299.1 ; PQ63.1 v1(122.27,59.74)
N24881935: length 6.2
  BOTTOM w0.635: PQ68.1 112.76,64.4 113.06,64.11 PC9301.1 112.19,63.09 v1(112.18,63.09) PQ67.1
N24881987: length 13.1
  BOTTOM w0.381: PR461.1 PQ67.2 v1(114.22,62.06) 114.22,62.7 PC9301.2 114.22,63.47 PQ68.2 114.22,64.84 114.8,65.42 117.98,65.42 118.5,65.95 118.5,66.42 118.34,66.59 PU30.7
N24882598: length 2.9
  BOTTOM w0.114: R1055.2 138.01,28.42 C9362.1 136.89,28.27 136.89,27.23 137.05,27.08 Q52.2
N24882612: length 414
  TOP w0.114: v1(112.96,21.84) 114.74,20.06 125.69,20.06 127.92,22.29 133.56,22.29 v1(134.47,23.2) ; v1(110.35,122.46) 110.35,119.15 112.32,117.18 112.32,92.15 109.04,88.87 109.04,78.04 117.01,70.07 117.01,63 118.79,61.22 118.79,56.48 120.22,55.04 120.22,50.13 v1(117.54,47.45)
  IN3 w0.127: v1(112.96,21.84) 110.66,24.14 110.66,33.35 ; 110.66,33.35 116.38,39.07 116.38,46.3 117.53,47.45 v1(117.54,47.45) ; 110.66,33.35 96.32,33.35 94,31.02 61.48,31.02 60.76,30.3 57,30.3 54.32,27.62 54.32,24.22 52.38,22.28 52.38,21.19 38.6,7.41 26.29,7.41 24.97,6.09 12.73,6.09 12.39,6.42 12.39,8.43 12.15,8.68 v1(12.15,10.32) 11.35,9.53 9.29,9.53 8.52,10.3 8.52,21.27 10.5,23.26 11.7,23.26 16.29,27.85 24.17,27.85 27.9,31.58 27.9,41.41 27.42,41.89 27.42,67.44 28.97,68.99 v1(29.43,68.99)
  IN4 w0.089: v1(110.35,122.46) 108.33,124.48 98.13,124.48 97.67,124.93 93.57,124.93 92.34,126.17 83.27,126.17 v2(81.93,127.51) 80.59,126.17 78.54,126.17 77.75,126.96 59.82,126.96 v1(59.21,126.35)
  BOTTOM w0.114: v1(29.43,68.99) Q59.2 ; v1(134.47,23.2) 134.85,22.82 Q58.2 136.01,22.82 136.08,22.89 136.08,23.52 136.52,23.96 136.52,25.41 136.87,25.76 Q52.1 ; Q55.2 60.69,126.05 60.39,126.35 v1(59.21,126.35) ; v2(81.93,127.51) 81.93,126.88 81.2,126.15 Q54.2 ; Q56.2 v1(112.96,21.84) ; v1(110.35,122.46) 109.9,122.91 109.52,122.91 108.98,122.37 Q53.2 ; v1(12.15,10.32) 12.15,11.11 12.84,11.81 v1(13.07,11.81) C9363.1 14.08,11.81 15.42,10.47 Q57.2 16.51,10.47 16.64,10.33 16.64,9.55 R1054.2
N24882626: length 1.8
  BOTTOM w0.508: Q53.1 R1056.2
N24882655: length 3.3
  BOTTOM w0.508: Q54.1 79.88,125.78 79.62,126.03 v1(78.5,126.03) 78.29,126.25 R1057.2
N24882676:
  vias: v1(57.32,124.8)
N24882692: length 4.6
  BOTTOM w0.508: R1059.2 v1(115.05,20.76) 115.05,22.89 114.78,23.16 Q56.1
N24882721: length 3.2
  BOTTOM w0.508: Q57.1 15.89,8.06 16.24,7.7 v1(16.24,7.22) R1060.2
N24882750: length 2.7
  BOTTOM w0.508: R1061.2 134.01,24.1 v1(134.25,23.86) 135.16,23.86 Q58.1
N24882779: length 3.3
  BOTTOM w0.508: Q59.1 30.42,66.73 v1(31.18,67.49) R1062.2
N24882921: length 5.2
  BOTTOM w0.254: Q60.2 130.05,45.31 v1(129.78,45.57) C9364.1 R1064.2
N24882931: length 6.7
  TOP w0.254: v1(127.52,44.48) 127.83,44.17 v1(127.83,43.77) 127.77,43.71 C9365.1 R1063.2
  BOTTOM w0.254: Q60.1 Q61.2 127.11,44.06 v1(127.52,44.48)
N24882949:
  vias: v1(125.18,41.41)
N25130381: length 2.7
  BOTTOM w0.305: R1068.1 v1(182.69,13.17) CON1.69
N25456866: length 5
  BOTTOM w0.191: 153.02,27.99 153.33,27.68 PU29.3
  BOTTOM w0.254: PR467.1 v1(152.85,30.68) 152.85,28.94 152.46,28.55 PC9334.1 152.56,28.33 152.68,28.33 153.02,27.99
N25456868: length 5.2
  BOTTOM w0.191: 154.27,28.01 154.13,27.88 PU29.5
  BOTTOM w0.254: 154.27,28.01 154.78,28.52 PC9335.1 155.33,28.52 155.49,28.68 155.49,30.43 v1(155.61,30.56) 155.5,30.68 PR468.2
N25456946: length 1.5
  BOTTOM w0.191: 154.24,24.44 154.13,24.55 PU29.10
  BOTTOM w0.254: PC9337.1 154.27,24.41 154.24,24.44
N25456948: length 1.6
  BOTTOM w0.191: PU29.12 153.33,24.39 153.23,24.28
  BOTTOM w0.254: PC9336.1 153,23.8 153.23,24.03 153.23,24.28
N25457219: length 5.3
  BOTTOM w0.114: R1079.2 124.8,78.13 C9372.1 125.24,77.94 126.09,78.79 v1(126.09,79.3) 126.09,80.35 126.05,80.39 Q62.2
N25457225: length 11.6
  BOTTOM w0.114: R1078.2 C9371.1 123.12,81.46 123.25,81.59 124.64,81.59 124.76,81.71 Q62.1 126.09,81.71 126.47,81.34 126.47,80.46 126.77,80.16 129.57,80.16 129.79,80.38 129.79,81.42 130.08,81.71 Q63.2
N25457247: length 6
  BOTTOM w0.508: Q63.1 v1(132.22,80.39) 135.21,80.39 135.98,79.62 R1077.2
N28035667: length 4.1
  BOTTOM w0.254: Q20.3 30.3,64.37 30.54,64.13 v1(30.54,63.48) 30.54,63.47 30.3,63.23 29.25,63.23 29.12,63.1 R350.1
N28035669: length 4.6
  BOTTOM w0.114: Q21.3 28.91,60.3 28.33,60.88 28.33,61.31 v1(27.52,62.12) Q20.2
N28786240: length 10.5
  TOP w0.254: R1109.2 198.33,26.79 198.44,26.89 v1(198.8,26.89) 199.81,25.88 202.85,25.88 203.4,26.43 203.4,30.79 J3.2
N28786247: length 9.5
  TOP w0.254: R1108.2 200.37,24.15 v1(201.23,24.15) 202.72,24.15 203.78,25.21 203.78,30.03 203.9,30.15 J3.3
N28786291: length 1.8
  TOP w0.114: J2.2 248.8,25.95 248.87,25.88 R1110.1
N28910756: length 3.4
  BOTTOM w0.508: PR201.1 v1(64.29,15.11) 63.66,15.75 PR195.1 PQ30.2
N28911104: length 1.7
  TOP w0.508: PC9376.1 62.29,8.88 62.68,8.49 PR515.2
N30029303: length 3.4
  TOP w0.114: R118.2 v1(186.65,49.26) 186.65,48.16 186.09,47.6 Q8.3
N30866543: length 4.3
  BOTTOM w0.254: PQ31.3 37.61,15.02 37.15,15.47 v1(37.15,16.24) 37.37,16.45 PR194.2 PR185.2
N30989079: length 12.9
  TOP w0.508: v1(56.06,9.21) PC84.2 PC85.2 59.76,9.21 v1(59.76,9.21)
  BOTTOM w0.33: PQ40.4 v1(56.06,9.21) ; v1(59.76,9.21) PQ41.4
  BOTTOM w0.508: PR217.1 61.56,12.84 61.62,12.9 PQ30.3 60.77,13.2 60.77,11.79 59.76,10.78 v1(59.76,10.09) v1(59.76,9.21)
N30992906: length 1.6
  BOTTOM w0.254: v1(88.58,6.33) 89.08,6.83 PR235.1
N30999297: length 7.3
  BOTTOM w0.508: PR234.1 76.19,4.81 v1(76.92,4.81) 77.41,4.81 77.81,5.21 PD4.1 78.57,5.95 78.93,6.31 78.93,7.62 78.67,7.88 PD3.1
N31000343: length 2
  BOTTOM w0.508: PR483.2 75.6,10.67 v1(75.6,9.86) 75.42,9.67 PC236.1
N31030974: length 8
  BOTTOM w0.114: PQ29.3 51.14,14.89 50.83,14.57 PR193.1 50.83,13.73 50.52,13.42 50.52,13.05 50.78,12.78 PD2.1 52.29,12.78 52.4,12.67 v1(52.4,11.37) PC229.1 EL14.2
N31030992: length 8
  BOTTOM w0.114: PR202.1 59.38,13.07 59.06,12.75 56.59,12.75 56.43,12.91 v1(55.06,12.91) 55.06,13.95 54.42,14.58 PQ29.1
N31031004: length 7.7
  BOTTOM w0.114: PQ29.2 53.18,15.84 53.37,15.65 55.16,15.65 55.49,15.32 PQ28.3 55.49,14.03 55.74,13.77 v1(56.02,13.77) 56.22,13.98 56.22,14.51 56.45,14.74 57.21,14.74 PR196.1
N31031010: length 9.2
  BOTTOM w0.114: PR193.2 50.05,15.16 PR186.1 49.38,15.83 49.38,16.83 50.07,17.52 v1(50.71,17.52) 54.66,17.52 54.83,17.35 PQ28.2
N32053427: length 7.7
  BOTTOM w0.114: TP145.1 87.95,121.45
  BOTTOM w0.127: U18.AU1 84.84,116.3 86.13,117.59 86.13,118.31 87.95,120.13 87.95,121.45
N32053441: length 7.3
  BOTTOM w0.127: TP144.1 88.58,120.25 86.35,118.02 86.35,117.45 84.77,115.87 84.77,115.82 U18.AU2
N32250937: length 5.9
  BOTTOM w0.102: TP255.1 94.3,102.52 93.77,102.52 93.36,102.93 90.61,102.93 90.38,102.69 89.04,102.69 U18.BC18
N45706464: length 1.3
  TOP w0.114: TP141.1 82.23,110.86 v2(81.54,110.86)
  BOTTOM w0.102: v2(81.54,110.86) 81.89,110.86 U18.AP8
N47893673: length 1.4
  TOP w0.114: v2(76.66,110.21) 76.08,110.21 TP133.1
  BOTTOM w0.127: v2(76.66,110.21) 76.94,110.21 U18.AH9
N124462712:
  vias: v1(137.1,7.6)
N124462714: length 10.5
  BOTTOM w0.254: PD6.2 145.05,8.95 144.76,9.24 144.02,9.24 143.75,9.5 143.75,10.8 144.02,11.07 PC90.1 144.02,12.16 143.6,12.58 143.6,14.68 144.23,15.32 v1(144.44,15.32) 144.97,15.32 145.38,15.73 PD5.1
N124462746: length 3.8
  BOTTOM w0.203: 150.91,12.71 150.47,12.26 PU2.5
  BOTTOM w0.254: 150.91,12.71 v1(152.92,12.71) 153.25,13.04 PR204.1
N124462831: length 2.9
  BOTTOM w0.203: PU2.1 148.87,12.34 148.65,12.55 148.43,12.55
  BOTTOM w0.254: PR208.2 147.65,12.55 148.43,12.55
N124462892: length 4.9
  BOTTOM w0.254: PD5.3 146.04,15.63 v1(145.73,15.32) 144.71,14.3 PC89.2
N124462894: length 2.2
  BOTTOM w0.254: PC252.2 145.46,10.73 144.92,10.19 PD6.3
N124463006:
  vias: v1(176.49,8.82)
N124463025: length 2.5
  BOTTOM w0.508: PR227.1 146.61,6.51 v1(146.61,7.47) 146.61,8.09 146.6,8.1 PC235.1
N124463039:
  vias: v1(154.75,12.32)
N134668295: length 3.5
  BOTTOM w0.114: PR221.1 v1(116.09,9.17) 116.09,8.73 116.1,8.72 JBAT1.6
N134668551: length 4.1
  BOTTOM w0.254: PQ31.2 39.61,13.04 39.86,13.28 PR214.2 v1(40.42,12.48) 40.42,11.9 40.2,11.67 PQ36.3

## Copper pours and planes (outline as drawn)
3.3V_SW on BOTTOM (solid shape): 169.99,12.08 173.07,12.08 173.61,11.54 173.61,9.44 174.31,8.74 175.71,8.74 175.96,8.49 175.96,7.35 175.14,6.52 169.2,6.52 168.17,7.55 167.85,7.55 167.81,7.55 165.98,7.55 165.93,7.6 165.93,9.94 165.6,10.27 165.01,10.27 164.71,10.57 164.71,13.24 165.01,13.54 168.53,13.54
3V3IN on BOTTOM (solid shape): 248.65,17.2 249.44,17.2 250.25,16.39 250.83,16.39 250.83,16.38 251.78,16.38 251.83,16.34 251.83,16.11 251.8,16.08 249.8,16.08 249.67,16.21 245.89,16.21 245.68,16.41 245.68,17.4 245.77,17.5 246.67,17.5 246.73,17.56 248.3,17.56
5V_DH on BOTTOM (solid shape): 136.54,12.15 136.54,11.84 135.5,10.8 135.5,10.53 135.41,10.44 134.62,10.44 134.62,10.44 134.46,10.61 134.46,11.31 135.47,12.32 136.36,12.32
5V_DL on TOP (solid shape): 143.47,5.29 143.47,4.68 143.33,4.54 139.57,4.54 139.54,4.58 139.54,5.52 139.82,5.8 142.96,5.8
5V_DL on TOP (solid shape): 148.86,7.38 148.86,6.2 148.78,6.13 148.22,6.13 147.69,6.66 147.69,7.8 147.88,7.99 147.89,8 147.91,8.01 148.23,8.01
5V_DL on BOTTOM (solid shape): 141.14,5.69 141.14,4.65 141.02,4.54 137.58,4.54 137.54,4.55 137.53,4.59 137.53,5.14 137.58,5.19 137.63,5.19 137.63,5.19 138.95,5.19 139.51,5.75 141.07,5.75
5V_SW on BOTTOM (solid shape): 135.55,10.06 135.55,7.99 135.72,7.83 136.85,7.83 137.01,7.67 137.01,4.69 136.87,4.55 127.8,4.55 127.69,4.66 127.69,8.67 128.05,9.02 133.79,9.02 134,9.23 134,9.98 134.15,10.13 135.48,10.13
5388VLDOIN on TOP (solid shape): 25.47,32.5 25.47,30.6 25.25,30.38 25.16,30.38 25.16,30.39 24.09,30.39 24.09,30.38 24,30.38 23.89,30.5 23.89,32.48 24.08,32.67 25.29,32.67
+1.05V_RUN on TOP (solid shape): 101.92,100.55 104.66,100.55 104.79,100.42 104.79,98.81 104.76,98.79 98.75,98.79 98.75,100.67 101.8,100.67
+1.05V_RUN on TOP (solid shape): 86.34,102.36 86.8,102.36 86.83,102.35 86.85,102.31 86.85,102.09 86.79,102 86.68,102.01 86.09,101.82 86.46,101.33 86.54,101.29 86.57,101.22 86.57,101.2 86.57,100.93 86.46,100.82 86.44,100.82 86.36,100.81 86.28,100.78 86.27,100.77 85.83,100.77 85.82,100.78 85.65,100.82 85.48,100.78 85.47,100.77 85.19,100.77 85.18,100.78 85,100.82 84.83,100.78 84.82,100.77 84.36,100.77 84.27,100.86 84.26,100.88 84.26,100.91 84.26,100.95 84.26,101.25 84.2,101.42 84.04,101.48 83.8,101.48 83.64,101.64 83.64,101.8 83.68,101.87 83.7,101.95 83.7,102.23 83.67,102.33 83.59,102.43 83.58,102.45 83.58,102.5 83.59,102.53 83.67,102.63 83.7,102.73 83.7,102.8 83.76,102.86 85.85,102.86
+1.05V_RUN on BOTTOM (solid shape): 85.6,103.8 85.62,103.79 85.63,103.78 85.85,103.66 86.09,103.7 86.18,103.71 86.24,103.65 86.37,103.47 86.58,103.41 86.61,103.4 86.72,103.29 86.72,102.71 86.71,102.68 86.45,102.42 86.45,102.2 86.45,102.18 86.43,102.17 86.29,102.03 86.29,102.02 86.1,101.65 86.38,101.36 86.41,101.34 86.43,101.31 86.41,101.27 86.38,101.26 86.31,101.26 86.3,101.26 86.15,101.3 86,101.26 85.99,101.26 85.51,101.26 85.5,101.26 85.35,101.3 85.2,101.26 85.19,101.26 84.71,101.26 84.7,101.26 84.55,101.3 84.4,101.26 84.39,101.26 84.29,101.26 84.15,101.4 84.04,101.48 83.91,101.54 83.89,101.54 83.87,101.57 83.86,101.58 83.86,101.6 83.85,101.7 83.81,101.84 83.82,101.86 83.9,101.94 84.04,102.27 83.77,102.5 83.7,102.53 83.67,102.6 83.67,103 83.7,103.07 83.77,103.1 84,103.23 84.03,103.5 84.04,103.58 84.09,103.63 84.14,103.65 84.18,103.68 84.27,103.71 84.35,103.75 84.38,103.76 84.41,103.75 84.63,103.69 84.88,103.79 84.91,103.79 84.97,103.76 85.03,103.74 85.29,103.65 85.53,103.78 85.55,103.79 85.57,103.8
+1.05V_RUN on BOTTOM (solid shape): outline of 603 points within 29.71,69.75 105.96,100.16
+1.05V_RUN on IN3 (solid shape): outline of 853 points within 83.2,98.79 104.08,104.27
+1.5V_SUS on TOP (solid shape): 265.34,62.36 265.34,58.41 265.34,58.39 265.32,58.37 265.24,58.3 265.18,58.21 265.17,58.21 264.91,57.94 261.89,57.94 261.15,58.68 261.14,58.7 261.15,58.73 261.97,60.33 262.76,62.05 262.85,62.29 263.06,62.49 265.21,62.49
+1.05V_SUS on BOTTOM (solid shape): 122.9,52.66 123.74,52.66 123.86,52.53 123.86,50.3 123.79,50.22 122.95,50.22 122.62,49.89 120.89,49.89 120.74,50.04 120.74,50.88 120.66,50.96 119.65,50.96 119.42,51.19 119.42,51.89 119.61,52.08 120.51,52.08 120.74,52.3 120.74,53.12 120.76,53.14 122.42,53.14
+1.5V_SUS on BOTTOM (solid shape): 118.94,45.27 124.27,45.27 124.85,44.68 124.85,43.31 124.58,43.03 123.13,43.03 122.91,42.82 122.91,41.4 122.78,41.26 121.88,41.26 121.85,41.27 121.83,41.29 121.5,41.49 121.16,41.29 121.14,41.27 121.12,41.26 117.38,41.26 117.22,41.43 117.22,42.53 117.45,42.76 118.44,42.76 118.45,42.75 118.76,42.75 118.81,42.75 118.87,42.76 118.9,42.76 118.91,42.77 119.04,42.86 119.13,42.99 119.15,43.01 119.15,43.12 119.08,43.36 118.87,43.5 118.83,43.55 118.83,44.12 118.77,44.19 118.77,44.19 118.7,44.29 118.6,44.36 118.59,44.37 118.38,44.58 118.38,45.17 118.49,45.28 118.92,45.28
+1.05V_SUS on BOTTOM (solid shape): outline of 137 points within 30.65,79.71 38.11,96.95
+1.5V_SUS on IN2 (solid shape): 263.49,60.48 263.49,55.91 263.13,55.55 261.05,55.55 260.74,55.86 260.74,58.03 261.13,58.7 261.97,60.33 262.01,60.43 262.5,60.91 263.06,60.91
+1.5V_SUS on IN2 (solid shape): 119.46,45.47 119.67,45.41 119.87,45.47 124.68,45.47 126,44.15 126,42.65 125.99,42.63 125.98,42.61 125.9,42.53 124.3,42.53 119.36,42.53 119.08,42.81 119.06,42.84 119.07,42.88 119.05,43.41 118.52,43.43 118.48,43.42 118.45,43.43 118.28,43.61 118.28,44.93 118.82,45.47
+1.05V_SUS on IN2 (solid shape): outline of 3728 points within 29.3,32.34 123.08,86.59
+1.5V_VDD on TOP (solid shape): 268.11,70.54 268.76,70.54 269.02,70.28 269.02,68.95 269.23,68.74 269.23,68.41 269.18,68.36 268.39,68.36 268.39,69.27 267.7,69.96 267.7,70.23 267.61,70.32 267.15,70.32 266.91,70.08 266.55,70.08 266.54,70.08 266.41,70.2 266.41,70.48 266.77,70.84 267.82,70.84
+1.5V_VDD on TOP (solid shape): 269.23,64.88 269.23,64.79 268.99,64.56 268.99,63.96 268.52,63.49 266.79,63.49 266.6,63.29 266.6,62.79 267,62.4 267,61.27 266.77,61.04 265.77,61.04 265.6,61.22 265.6,62.44 265.96,62.8 265.96,64.27 266.04,64.35 267.96,64.35 268.38,64.78 268.38,64.92 268.41,64.95 269.15,64.95
+1.5V_VDD on TOP (solid shape): 276.02,70.17 276.02,69.38 275.73,69.09 274.83,69.09 274.68,68.94 274.68,68.05 274.58,67.95 274.18,67.95 274.18,67.95 273.37,67.95 273.34,67.96 273.33,67.98 273.33,68.13 273.34,68.14 273.37,68.15 274.18,68.15 274.18,68.35 273.36,68.35 273.34,68.36 273.32,68.38 273.32,68.4 273.32,68.74 273.32,68.75 273.33,68.77 273.36,68.8 273.4,68.83 273.59,69.03 273.59,69.56 275.44,69.56 275.44,70.06 274.75,70.06 274.75,69.56 273.59,69.56 273.59,69.65 274.51,70.57 275.62,70.57
+1.5V_VDD on SVCC (solid shape): 275.22,70.49 275.31,70.43 275.41,70.41 276.23,70.41 276.57,70.08 276.57,65.08 272.81,61.32 266.51,61.32 266,61.83 266,63.96 266.94,64.9 267,64.98 267.02,65.09 267.02,68.02 267,68.12 266.94,68.21 266.41,68.74 266.41,70.51 266.87,70.97 274.74,70.97
+1.8V_GFX on TOP (solid shape): 146.25,87.62 146.25,85.58 145.1,84.43 143.93,84.43 143.78,84.28 143.78,83.93 143.65,83.8 142.84,83.8 142.76,83.88 142.76,84.33 142.63,84.46 141.03,84.46 140.86,84.28 140.86,83.88 140.65,83.67 139.92,83.67 139.74,83.85 139.74,87.53 141.01,88.8 145.07,88.8
+1.8V_GFX on TOP (solid shape): 146.01,96.78 146.52,96.78 146.7,96.59 146.7,96.21 146.6,96.1 146.57,96.09 146.55,96.1 146.33,96.12 146.13,96.02 146.11,96.01 146.09,96 145.71,96 145.69,96.01 145.67,96.02 145.14,96.02 145.12,95.49 145.13,95.48 145.13,95.46 145.13,95.21 145.07,95.09 145.04,94.96 145.01,94.88 144.92,94.86 144.6,94.81 144.43,94.55 144.43,94.53 144.37,94.48 144.35,94.47 144.33,94.47 143.97,94.35 143.89,93.99 143.87,93.89 143.79,93.85 143.4,93.85 143.3,93.95 143.29,93.97 143.29,94 143.31,94.26 143.16,94.47 143.11,94.55 143.15,94.64 143.27,94.76 143.32,94.91 143.35,94.98 143.43,95.01 143.45,95.01 143.75,95.01 143.91,95.07 143.98,95.23 143.98,95.51 143.91,95.67 143.75,95.74 143.46,95.74 143.38,95.82 143.38,95.84 143.24,96.05 143,96.13 142.93,96.16 142.9,96.23 142.9,97.15 143.14,97.39 145.39,97.39
+1.8V_GFX on BOTTOM (solid shape): 143.84,88.05 143.84,87.62 143.83,87.6 143.72,87.5 143.69,87.38 143.69,87.1 143.73,86.97 143.84,86.89 143.85,86.88 144.02,86.71 144.29,86.71 144.34,86.66 144.34,86.35 144.71,85.99 144.71,85.48 145,85.18 145,84.85 144.95,84.79 141.89,84.79 141.63,85.05 141.63,88.09 141.91,88.37 143.52,88.37
+1.8V_GFX on BOTTOM (solid shape): 122.09,110.88 122.09,109.47 122.08,109.46 122.07,109.44 121.96,109.33 120.18,109.33 120.12,109.39 120.11,109.4 120.1,109.42 120.1,110.7 120.53,111.13 120.62,111.16 120.97,110.92 121.3,111.03 121.48,111.21 121.76,111.21
+1.8V_GFX on BOTTOM (solid shape): 152.58,25.47 152.62,25.46 152.63,25.42 152.63,24.66 152.83,24.66 152.83,25.42 152.85,25.46 152.89,25.47 153,25.47 153.03,25.44 153.03,24.44 152.99,24.37 152.97,24.28 152.97,24.14 152.77,23.94 152.76,23.94 152.66,23.85 152.62,23.73 152.62,23.71 152.41,23.5 152.41,23.36 152.27,23.22 152.25,23.21 152.23,23.2 151.22,23.2 151.09,23.08 151.09,21.68 150.91,21.5 149.96,21.5 149.8,21.66 149.8,23.85 151.13,25.19 152.19,25.19 152.48,25.47
+1.8V_GFX on IN2 (solid shape): outline of 863 points within 118.78,78.81 143.91,92.4
+1.8V_GFX on IN3 (solid shape): 151.16,23.24 151.16,21.78 150.88,21.5 149.8,21.5 149.71,21.55 149.71,21.65 149.7,22.03 149.37,22.23 149.3,22.26 149.27,22.33 149.27,22.77 149.81,23.31 149.81,23.36 151.04,23.36
+1.8V_GFX on IN3 (solid shape): 121.39,79.73 121.47,79.73 122.67,79.73 122.99,80.05 123.8,80.05 124.02,79.82 124.02,77.67 123.89,77.54 122.04,77.54 121.17,78.41 122.81,78.41 122.81,78.36 122.82,78.3 122.83,78.25 122.86,78.2 122.89,78.15 122.93,78.11 122.97,78.07 123.02,78.04 123.07,78.02 123.12,78 123.18,77.99 123.23,77.99 123.29,78 123.34,78.02 123.39,78.04 123.44,78.07 123.48,78.11 123.52,78.15 123.55,78.2 123.57,78.25 123.59,78.3 123.6,78.36 123.6,78.41 123.59,78.47 123.57,78.52 123.55,78.57 123.52,78.62 123.48,78.66 123.44,78.7 123.39,78.73 123.34,78.76 123.29,78.77 123.23,78.78 123.18,78.78 123.12,78.77 123.07,78.76 123.02,78.73 122.97,78.7 122.93,78.66 122.89,78.62 122.86,78.57 122.83,78.52 122.82,78.47 122.81,78.41 121.17,78.41 119.92,79.67 119.92,80.04 120.06,80.2 120.93,80.2
+1.8V_GFX on IN4 (solid shape): outline of 458 points within 142.17,85.24 146.82,97.02
+1.8V_GFX on IN4 (solid shape): outline of 1930 points within 119.11,78.75 128.9,112.45
+1.8V_RUN on TOP (solid shape): 82.97,104.21 82.98,104.19 82.97,104.15 82.93,103.94 83,103.75 83,103.37 82.83,103.2 82.82,103.19 82.8,103.19 82.69,103.19 82.5,103.01 82.42,102.98 82.36,102.94 82.02,102.94 81.95,102.98 81.87,103 81.57,103 81.51,103 81.49,103.01 81.42,103.09 81.4,103.11 81.41,103.14 81.44,103.34 81.38,103.52 81.38,104.16 81.45,104.26 82.92,104.26
+1.8V_RUN on TOP (solid shape): 50.1,107.79 50.1,106.94 49.44,106.28 49.44,106.13 49.44,106.12 49.37,105.87 49.44,105.62 49.44,105.61 49.44,105.52 49.59,105.36 49.88,105.36 50,105.36 50.02,105.38 50.03,105.39 50.14,105.44 50.24,105.51 50.45,105.72 50.89,105.72 50.94,105.67 50.94,103.17 50.64,102.88 48.95,102.88 48.71,103.12 48.71,103.51 48.64,103.58 48.64,103.9 47.9,104.64 47.88,104.64 47.85,104.67 47.85,106.72 47.86,106.76 47.85,106.8 47.85,107.26 47.88,107.31 47.91,107.42 47.91,107.54 47.91,107.56 47.93,107.58 48.32,107.98 49.92,107.98
+1.8V_RUN on BOTTOM (solid shape): 46.17,102.47 46.17,99.42 45.66,98.91 45.4,98.91 45.28,99.04 45.28,100.56 44.9,100.94 42.74,100.94 42.61,101.07 42.61,101.96 42.74,102.09 44.9,102.09 45.4,102.6 46.04,102.6
+1.8V_RUN on BOTTOM (solid shape): 82.69,103.95 82.69,103.55 82.68,103.54 82.65,103.44 82.66,103.33 82.66,103.32 82.66,103.12 82.52,102.98 82.5,102.98 82.29,102.84 82.22,102.6 82.03,102.6 81.46,103.18 81.46,103.9 81.82,104.26 82.37,104.26
+1.8V_RUN on BOTTOM (solid shape): outline of 83 points within 125.95,18.88 153.02,30.28
+1.8V_RUN on IN1 (solid shape): outline of 616 points within 39.38,98.91 50.69,111.89
+1.8V_RUN on IN3 (solid shape): outline of 1174 points within 81.34,102.86 99.78,111.8
+1.8V_SUS on TOP (solid shape): 130.49,39.07 130.49,37.19 130.24,36.94 125.95,36.94 125.31,37.57 125.31,39.07 125.46,39.22 130.34,39.22
+1.8V_SUS on BOTTOM (solid shape): 133.54,38.84 133.54,33.76 133.03,33.25 131.09,33.25 130.62,32.78 130.62,32.39 131.08,31.93 131.08,31.55 130.92,31.4 130.7,31.4 129.76,30.46 126.72,30.46 126.38,30.79 126.38,34.24 126.38,34.25 126.38,35.13 124.63,36.88 124.62,36.9 124.62,36.92 124.62,37.56 124.6,37.58 124.6,38.18 124.63,38.34 124.6,38.48 124.6,38.48 124.6,38.72 124.68,38.85 124.7,39 124.71,39.03 124.78,39.1 126.94,39.1 127.06,39.22 133.16,39.22
+1.8V_SUS on BOTTOM (solid shape): 83.69,110.04 83.69,109.72 83.67,109.69 83.65,109.69 83.45,109.4 83.65,109.11 83.68,109.09 83.69,109.07 83.69,108.95 83.34,108.61 81.84,108.61 81.67,108.77 81.67,109.63 81.72,109.67 81.78,109.7 81.85,109.67 82.26,109.69 82.28,110.1 82.25,110.17 82.28,110.23 82.31,110.26 83.47,110.26
+1.8V_SUS on IN2 (solid shape): 131.05,31.76 131.05,31.53 130.75,31.22 128.99,31.22 128.94,31.27 128.94,32.16 129.02,32.24 130.57,32.24
+1.8V_SUS on IN2 (solid shape): 118.86,34.3 119.37,34.3 119.57,34.09 119.57,33.28 118.3,33.28 117.21,34.37 117.21,34.8 118.35,34.8
+1.35V_GFX on TOP (solid shape): 123.89,139.4 123.89,137.34 123.87,137.31 123.84,137.29 122.97,137.29 122.72,137.55 122.72,139.37 122.85,139.5 123.79,139.5
+1.35V_GFX on TOP (solid shape): 171.46,83.01 171.46,82.07 171.84,81.69 171.84,80.65 170.85,79.66 169.71,79.66 169.41,79.35 169.41,79 168.21,77.81 167.6,77.81 167.4,78.01 167.4,78.8 166.84,79.35 166.84,80.42 166.49,80.78 166.49,82.15 167.48,83.14 171.34,83.14
+1.35V_GFX on BOTTOM (solid shape): 169.55,83.1 169.61,83.1 169.88,83.1 170.07,82.91 170.07,82.1 170.4,81.77 171.82,81.77 172.1,81.49 172.1,80.35 172.38,80.07 173.34,80.07 173.37,80.04 173.37,78.2 173.36,78.15 173.37,78.1 173.37,76.8 173.97,76.21 174.28,76.21 174.64,75.85 174.64,73.44 174.54,73.33 173.65,73.33 172.89,74.1 165.95,74.1 165.82,74.22 165.82,75.19 165.83,75.19 165.83,75.83 165.82,75.83 165.82,79.89 165.93,79.99 165.93,82.45 165.98,82.5 166.33,82.5 166.94,83.11 169.49,83.11
+1.35V_GFX on BOTTOM (solid shape): 145.24,139.31 145.25,139.29 145.32,139.19 145.42,139.12 145.45,139.1 145.45,139.07 145.45,138.74 145.25,138.54 144.46,138.54 144.23,138.31 144.23,137.9 144.44,137.7 145.23,137.7 145.25,137.68 145.26,137.67 145.3,137.61 145.36,137.55 145.37,137.54 145.38,137.51 145.38,137.41 145.37,137.39 145.26,137.26 145.21,137.11 145.21,137.09 144.96,136.83 144.71,136.83 144.63,136.84 144.56,136.83 141.54,136.83 141.47,136.91 141.47,138.41 141.54,138.49 141.97,138.49 142.81,139.32 145.21,139.32
+1.35V_GFX on BOTTOM (solid shape): 139.54,138.49 140.75,138.49 140.99,138.25 140.99,136.89 140.83,136.73 137.43,136.73 137.38,136.78 137.35,136.82 137.31,136.85 137.1,137.06 137.1,137.07 137.06,137.19 136.97,137.3 136.97,137.32 136.97,137.5 137.2,137.72 138.04,137.72 138.19,137.88 138.19,138.38 137.99,138.59 137.15,138.59 137.11,138.62 137.11,138.65 137.08,138.81 136.96,138.96 136.96,138.98 136.96,139.11 136.96,139.13 137.07,139.27 137.11,139.41 137.11,139.43 137.15,139.48 138.55,139.48
+1.35V_GFX on BOTTOM (solid shape): 126.96,139.1 126.96,138.91 126.94,138.87 126.93,138.86 126.84,138.75 126.79,138.62 126.79,138.6 126.69,138.49 126.67,138.49 126.59,138.45 126.52,138.37 126.51,138.36 126.47,138.34 126.39,138.34 126.38,138.35 125.81,138.05 126.41,137.81 126.42,137.82 126.46,137.84 126.8,137.84 126.8,137.79 126.84,137.64 126.93,137.53 126.94,137.52 126.96,137.48 126.96,137.39 126.44,136.87 125.83,136.64 126.42,136.35 126.45,136.38 126.94,135.9 126.94,135.67 127.37,135.23 127.62,135.23 127.72,135.13 127.72,134.96 127.6,134.83 125.09,134.83 124.04,135.87 124.04,137.14 123.89,137.29 123.43,137.29 123.3,137.42 123.3,139.19 123.54,139.43 126.63,139.43
+1.35V_GFX on BOTTOM (solid shape): 175.5,121.93 176.72,121.93 177.03,121.62 177.03,117.15 177.01,117.11 176.98,117.1 176.67,117.1 176.64,117.11 176.49,117.25 176.3,117.3 176.23,117.32 176.2,117.38 175.95,117.62 175.66,117.45 175.66,117.44 175.52,117.3 175.5,117.3 175.34,117.24 175.2,117.11 175.17,117.1 175.07,117.1 175.04,117.11 174.89,117.25 174.7,117.3 174.63,117.32 174.6,117.38 174.59,117.42 174.57,117.46 174.57,117.65 174.32,118.26 174.07,117.65 174.07,117.46 174.06,117.43 173.92,117.3 173.9,117.3 173.74,117.25 173.6,117.11 173.57,117.1 173.47,117.1 173.38,117.19 173.35,117.22 173.11,117.45 173.11,117.76 173.12,117.77 173.14,117.9 173.12,118.03 173.11,118.04 173.11,119.11 173.9,119.89 173.9,120.93 173.77,121.06 173.74,121.06 173.73,121.08 173.58,121.17 173.41,121.21 173.12,121.21 172.96,121.37 172.96,121.93 173.24,122.2 175.22,122.2
+1.35V_GFX on IN2 (solid shape): outline of 22813 points within 122.7,79.99 178.8,141.58
+1.35V_GFX on IN3 (solid shape): outline of 27391 points within 121.65,84.14 180.13,143.46
+2.5V_SUS on TOP (solid shape): 110.09,66.43 110.09,57.87 110.75,57.21 110.75,49.55 110.74,49.53 110.73,49.51 110.58,49.36 107.88,49.36 107.83,49.39 107.83,49.4 107.68,49.6 107.49,49.76 107.26,49.87 107.01,49.9 106.99,49.9 106.77,50.12 106.77,51.01 107.08,51.32 108.53,51.32 108.87,51.66 108.87,53.65 108.88,53.74 108.87,53.83 108.87,54.29 108.88,54.39 108.87,54.48 108.87,55.72 108.86,55.74 108.75,55.97 108.52,56.08 108.5,56.08 108.21,56.38 108.21,56.76 108.22,56.81 108.23,56.85 108.23,57.13 108.22,57.18 108.21,57.23 108.21,57.54 108.22,57.59 108.23,57.63 108.23,57.91 108.22,57.96 108.21,58.01 108.21,60.03 107.84,60.4 107.84,60.41 107.74,60.59 107.57,60.7 107.55,60.71 107.53,60.73 107.53,60.78 107.54,60.8 107.55,60.81 107.92,61.55 107.55,62.29 107.54,62.31 107.53,62.33 107.53,66.11 107.56,66.18 107.58,66.25 107.49,66.55 107.2,66.68 106.3,66.68 105.93,66.68 105.88,66.63 105.88,66.07 105.75,65.94 105.19,65.94 104.86,66.27 104.86,68.2 105.05,68.39 108.13,68.39
+2.5V_SUS on BOTTOM (solid shape): 106.19,53.98 106.21,53.98 106.35,53.88 106.5,53.84 106.52,53.84 106.79,53.57 106.79,52.34 108.56,50.58 108.56,49.28 108.54,49.25 108.02,49.25 107.84,49.43 107.82,49.43 107.8,49.45 107.73,49.55 107.65,49.63 107.37,49.83 107.03,49.9 107.01,49.9 106.57,50.35 105.27,50.35 105.09,50.53 105.09,52.2 105.1,52.2 105.1,53.63 105.17,53.7 105.31,53.7 105.34,53.69 105.36,53.65 105.36,52.2 105.6,52.2 105.6,53.82 105.77,53.98
+2.5V_SUS on BOTTOM (solid shape): outline of 170 points within 23.72,50.04 106.8,74.17
+3.3V_ALW on TOP (solid shape): 217.13,11.82 217.13,10.32 216.88,10.06 215.18,10.06 215.02,10.22 215.02,11.89 215.2,12.07 216.88,12.07
+3.3V_ALW on BOTTOM (solid shape): 273.8,81.84 274.3,81.84 274.53,81.61 274.53,79.96 274.26,79.68 272.81,79.68 272.73,79.76 272.73,81.71 272.88,81.86 273.78,81.86
