# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_ALW2: length 382.2
  IN2 w0.508: v1(60.21,31.29) 60.23,31.31 99.5,31.31 101.49,33.3 112.46,33.3 116.28,37.12 122.99,37.12 127.06,33.05 131.52,33.05 v1(133,31.58) 133,30.8 133.18,30.61 149.66,30.61 150.84,31.79 150.84,34.28 149.89,35.23 v1(149.64,35.23)
  IN3 w0.508: v1(133,31.58) 133.01,31.56 133.01,22.77 144.1,11.67 144.1,7.1 145.59,5.61 147.81,5.61 148.98,6.79 v1(150.13,6.79)
  IN4 w0.508: v1(252.85,47.47) 252.08,47.47 242.7,38.1 209.41,38.1 206.59,40.92 178.81,40.92 177.03,39.14 167.98,39.14 165.22,36.38 163.94,36.38 161.76,34.19 155.53,34.19 154.82,34.9 153.91,34.9 153.59,35.23 v1(149.64,35.23) ; v1(60.21,31.29) 59.85,30.93 39.22,30.93 38.14,29.85 34,29.85 27.74,36.11 27.74,48.74 26.19,50.29 26.19,66.36 28.13,68.31 28.13,71.94 30.37,74.17 30.37,74.32 30.76,74.72 v1(31.08,74.72)
  BOTTOM w0.203: PC248.1 149.21,7.57 149.7,8.05 149.7,8.38 149.67,8.41 PU2.13
  BOTTOM w0.508: PR175.1 29.65,75.44 30.36,74.72 v1(31.08,74.72) ; v1(252.85,47.47) 258.71,47.47 260.67,49.43 R399.1 ; v1(150.13,6.79) 149.51,7.41 PC248.1 ; v1(133,31.58) 132.56,31.58 132.28,31.29 PR484.1 ; PR214.1 40.42,14.99 41.69,16.26 45.48,16.26 47.48,18.27 v1(52.77,18.27) 56.41,18.27 56.95,17.72 56.95,16.43 57.21,16.18 C724.1 PR196.2 58.48,15.14 59.04,15.7 59.76,15.7 60.21,16.15 PD1.1 v1(60.21,31.29)
+5V_ALW_USB3: length 5.7
  TOP w0.254: R404.1 267.7,40.77 268.64,40.77 268.88,41.01 C688.2 268.88,42.77 v1(268.49,43.16) 267.77,43.16 267.63,43.31 U7.4
+5V_HDMIF1: length 6.4
  TOP w0.508: D2.2 282.89,64.01 v1(283.2,64.32) 283.2,65.61 282.77,66.04 D1.2 280.89,66.04 v1(279.97,66.96)
  vias: v1(276.26,71.11) v1(276.92,71.11)
+5V_HDMIF1_D: length 4.6
  TOP w0.254: D1.1 279.03,66.04 278.74,66.33 278.74,68.09 v1(278.23,68.61) 278.23,69.3 R84.1
+5V_HDMIF1_D24: length 7.2
  TOP w0.254: D2.1 279.04,64.01 278.24,64.81 v1(278.24,67.26) 278.24,67.64 277.81,68.07 276.47,68.07 276.02,68.52 R83.1
+5V_RUN: length 285.6
  TOP w0.508: FS1.1 101.69,31.4 94.35,24.06 94.35,20.83 96.3,18.88 v1(96.33,18.88)
  TOP w1.016: 174.97,80.94 175.97,80.94 180.58,76.33 180.58,69.54 185.48,64.64 185.48,56.45 192.22,49.71 192.22,43.39 196.66,38.95 198.78,38.95 ; 29.55,66.48 29.73,66.66 34.26,66.66 40.55,72.95 40.55,87.53 38.93,89.16 38.21,89.16
  IN1 w1.016: 27.37,63.69 27.37,49.89 27.62,49.64 27.62,41.84 29.76,39.7 29.76,33.99 43.39,20.36
  IN3 w1.016: 203.52,37.47 208.01,32.98 238.1,32.98 239.63,31.45 246.77,31.45 256.51,41.19 271.5,41.19 273.14,42.84 273.14,47.13 273.51,47.49 273.51,52.67 272.61,53.57 272.61,57.44 273.13,57.96 273.13,61.72 274.91,63.5 275.06,63.5 276.26,64.7 278.32,64.7 ; 201.36,37.19 201.36,35.6 197.44,31.68 193.31,31.68 188.86,27.23 188.86,18.19
  vias: v1(23.34,5.06) v1(23.34,4.36) v1(23.99,5.09) v1(23.99,4.4) v1(24.68,5.09) v1(24.68,4.4) v1(28.41,65.66) v1(28.43,64.98) v1(28.79,11.38) v1(31.9,12.35) v1(31.92,12.99) v1(32.09,13.7) v1(32.56,12.99) v1(32.55,12.34) v1(44.26,18.47) v1(44.26,17.79) v1(188.33,17.25) v1(189.01,17.25) v1(279.26,64.9) v1(279.97,64.9) v3(116.04,17.12) v3(116.83,17.15) v3(117.59,17.15) v3(118.35,17.18) v3(119.11,17.18) v3(119.88,17.18) v3(120.64,17.18) v3(199.87,38.96) v3(200.89,38.96)
+5V_SUS: length 400.9
  TOP w0.762: v3(123.46,39.2) 124.61,40.34 124.61,41.85 124.28,42.17 124.28,47.94 124.69,48.35 124.69,52.85 v3(126.02,54.19)
  IN1 w0.635: v3(113.94,118.44) 115.19,119.69 115.19,133.96 109.35,139.8 108.44,139.8 107.63,140.61 107.63,144.61 106.78,145.46 v3(105.96,145.46)
  IN1 w0.762: v3(31.47,78.45) 31.47,77.12 32.07,76.51 32.07,67.31 v3(30.04,65.27) ; v3(126.02,54.19) 127.56,55.72 134.19,55.72 135.31,56.85 v3(141.77,56.85)
  IN2 w0.762: v3(42.72,129.34) 41.97,128.59 36.53,128.59 34.83,126.88 34.83,125.27 34.52,124.96 34.52,118.55 33.02,117.05 33.02,115.79 33.82,114.99 34.19,114.99 35.07,114.12 35.07,112.28 35.52,111.83 35.8,111.83 36.55,111.09 37.53,111.09 38.67,109.95 39.39,109.95 41.42,107.93 41.42,106.29 40.77,105.65 40.77,102.41 38.46,100.11 38.33,100.11 37.51,99.29 v3(37.51,98.27) ; v3(123.46,39.2) 122.43,38.16 115.83,38.16 112.02,34.35 104.02,34.35 102.87,35.5 101.54,35.5 98.73,32.68 v3(98.73,32.29)
  IN3 w0.762: 120.95,27.92 123.32,30.29 123.32,32.78 124.26,33.73 124.26,34.17 124.4,34.31 124.4,36.74 123.05,38.09 123.05,38.79 v3(123.46,39.2) ; v3(31.47,78.45) 31.26,78.66 31.26,79.57 32.17,80.48 32.17,86.98 35.77,90.58 36.33,90.58 38.57,92.83 38.57,97.24 37.54,98.27 v3(37.51,98.27)
  IN4 w0.762: v3(98.73,32.29) 95.97,29.53 63.92,29.53 60.95,32.5 38.03,32.5 37.33,31.81 34.25,31.81 30.19,35.87 30.19,58.08 29.21,59.06 29.21,64.44 v3(30.04,65.27)
  BOTTOM w0.203: PU17.26 39.6,124.96 39.53,125.03 39.53,125.65 40.25,126.37 41.01,126.37 41.22,126.58 ; PU16.26 110,143.86 ; PU24.26 140.98,52.75 141.05,52.82 141.05,53.9 141.39,54.24 141.39,54.28
  BOTTOM w0.381: PC9106.1 108.54,143.86 110,143.86 ; 141.39,54.28 141.39,54.99 PC9254.1
  BOTTOM w0.508: PR305.2 41.22,128.09 PC9146.1 41.22,126.58 ; PC9207.2 125.04,54.14 124.46,53.56 PU20.1 ; PC9106.1 108.13,144.45 107.67,144.91 106.53,144.91 106.23,144.61 PR254.2 v3(105.96,145.46) ; PC9254.1 141.45,55.66 PR397.2
  BOTTOM w0.533: 118.78,69.72 119.61,68.89 PU30.8 119.61,66.11 119.29,65.79
  BOTTOM w0.635: v3(113.94,118.44) 112.38,116.88 112.38,92.36 109.6,89.59 109.6,77.98 116.58,71 118.75,71 118.78,70.97 118.78,69.72 ; PR305.2 41.63,128.27 42.7,129.34 v3(42.72,129.34) ; 119.29,65.79 118.29,64.78 116.47,64.78 115.02,63.34 115.02,60.91 115.19,60.75 115.19,60.44 ; PC9207.2 125.04,54.44 125.77,54.44 v3(126.02,54.19) 126.02,55.08 123.33,57.77 119.57,57.77 118.93,58.42 PR455.2
  BOTTOM w0.762: PR397.2 141.58,56.85 v3(141.77,56.85) ; 44.97,124.08 45.02,124.08 45.31,124.37 45.31,128.36 v1(44.33,129.34) v3(42.72,129.34)
  vias: v3(119.4,26.57) v3(119.88,27.34) v3(120.29,26.58)
+15V_ALW: length 378
  TOP w0.508: PD7.1 v1(52.47,18.4) 52.47,18.4 57.78,18.4 59.58,20.2 v1(59.58,31.58)
  IN2 w0.254: v1(147.97,38.3) 150.23,38.3 151.82,36.71 153.18,36.71 153.99,37.52 159.42,37.52 160.3,36.64 165.18,36.64 167.03,38.5 175.27,38.5 v1(176.31,37.46)
  IN2 w0.508: v1(147.97,38.3) 147.69,38.02 146.47,38.02 144.99,39.5 126.77,39.5 124.14,42.13 112.27,42.13 106.41,36.27 101.22,36.27 96.9,31.96 59.96,31.96 v1(59.58,31.58)
  IN3 w0.508: v1(145.85,6.26) 144.75,7.37 144.75,11.94 133.81,22.88 v1(133.81,26.33) 133.81,26.41 137.44,30.04 145.04,30.04 146.4,31.4 146.4,34.37 147.97,35.93 v1(147.97,38.3)
  IN4 w0.254: v1(176.31,37.46) 176.31,37.81 176.89,38.38 207.89,38.38 209.05,37.22 242.74,37.22 v1(251.75,46.23)
  IN4 w0.508: v1(31.06,73.97) 31.06,72.45 30.17,71.56 30.17,70.69 28.78,69.3 28.78,68.04 26.84,66.09 26.84,50.56 29.24,48.15 29.24,35.52 34.26,30.5 37.87,30.5 38.95,31.58 v1(59.58,31.58)
  BOTTOM w0.254: v1(251.75,46.23) 258.98,46.23 265.09,52.34 R393.1
  BOTTOM w0.508: PD6.1 PR62.2 144.65,7.02 144.89,6.78 PC87.1 145.34,6.78 v1(145.85,6.26) ; v1(176.31,37.46) 176.31,37.46 R417.1 ; v1(133.81,26.33) 133.81,26.53 PR485.1 ; v1(31.06,73.97) 31.43,73.97 31.97,74.51 33.45,74.51 35.38,76.43 PR178.1
+5388VCC: length 2.8
  BOTTOM w0.203: 23.56,42.22 23.56,42.02 23.18,41.64 PU9.9
  BOTTOM w0.508: 23.56,42.22 v1(23.56,43.01) 23.97,43.42 PC138.2
+VCCRTC_2: length 1.2
  TOP w0.508: RTCD1.2 272,4.3 RTCR1.2
+VDDBT_RTC: length 30
  TOP w0.381: R621.1 C875.1 104.77,109.49 103.54,109.49 102.63,108.59 Q37.3 101.33,108.59 100.06,107.32 v1(100.06,105.26) 100.06,104.68 99.55,104.17 97.07,104.17 95.58,102.68 86.51,102.68 85.78,103.41 83.87,103.41 C873.1 82.82,102.87 v2(82.58,102.63)
  BOTTOM w0.381: U18.AR17 82.95,103 v2(82.58,102.63)
+VDDCI: length 60.1
  IN3 w0.254: v1(147.68,48.98) 147.68,48.98 148.34,49.64 148.34,51.1 149.47,52.24 159.89,52.24 162.42,54.77 162.42,66.79 160.49,68.72 160.49,71.67 156.87,75.29 v1(156.15,75.29)
  BOTTOM w0.254: U22.L13 U22.N11 ; PR390.1 v1(147.68,48.98)
  BOTTOM w0.3: U22.AG35 132.3,98.4 v1(132.3,98.3) ; v1(135.03,102.66) 135.01,102.66 134.41,103.25 U22.W32 ; v1(135.01,98.65) 134.55,98.65 U22.AG32 134.35,99 v1(135.01,99.66) ; v1(133.28,98.35) 133.55,98.07 U22.AJ34 ; U22.AC32 134.94,101.64 v1(135.03,101.64)
  BOTTOM w0.305: v1(133.28,98.35) 132.78,98.85 U22.AG35 ; U22.L17 141.87,106.67 v1(140.81,106.67) ; U22.AJ32 134.35,97.5 v1(134,97.15) ; v1(134,97.15) 133.55,96.7 U22.AL34 ; v1(134,97.15) 134,97.3 U22.AJ34 ; v1(144.8,100.65) 145.3,100.15 U22.AE11
  BOTTOM w0.381: U22.L21 v1(139.89,106.69) ; U22.L29 136.84,107.64 v1(137.7,107.64) ; U22.L13 144.07,106.87 v1(144.07,106.65) ; U22.N11 v1(144.83,105.63)
  BOTTOM w0.4: U22.U11 144.86,104.64 144.71,104.64 v1(144.68,104.66) ; U22.L25 138.67,106.83 v1(138.67,106.65) ; v1(144.77,102.65) 144.82,102.6 144.9,102.6 U22.AA11
  vias: v1(145.79,97.6) v1(155.64,74.86) v3(149.16,75.93) v3(149.16,75.16) v3(149.16,74.4) v3(149.16,73.64) v3(149.92,75.93) v3(150.81,75.93) v3(151.7,75.93) v3(152.72,76.81) v3(152.72,75.93) v3(153.86,76.81) v3(153.86,75.93) v3(153.86,74.91) v3(154.88,76.81) v3(154.88,75.93) v3(154.88,74.91)
+VDDCR_CPU: length 41
  TOP w0.381: C809.1 76.81,112.01 v1(76.74,112.08) ; C1109.1 78.63,109.96 v1(78.04,109.37)
  TOP w0.508: CS8.2 69.66,119.17 v1(69.61,119.22) 68.88,119.22 68.63,118.97 CS1.2 ; CS2.1 87.08,117.88 v1(87.05,117.91)
  IN3 w0.203: v3(88.71,128.88) 89.11,128.49 89.53,128.49 89.85,128.81 89.85,131.12 92,133.27 94.84,133.27 97.28,130.83 107.19,130.83 108.51,132.16 112.12,132.16 115.28,135.32 v1(116.02,135.32)
  BOTTOM w0.254: v1(116.02,135.32) 115.18,134.48 PR294.1
  vias: v1(69.39,110.83) v1(69.53,100.62) v1(70.42,109.45) v1(70.55,101.24) v1(70.64,110.74) v1(70.65,99.04) v1(71.37,101.01) v1(71.43,99.73) v1(71.66,108.17) v1(71.82,105.19) v1(71.9,102.76) v1(72.16,105.74) v1(72.12,104.6) v1(72.16,101.04) v1(72.16,99.86) v1(72.81,104.68) v1(72.98,105.4) v1(73,99) v1(73.04,108.63) v1(73.01,102.83) v1(73.16,111.77) v1(73.11,110.03) v1(73.13,103.46) v1(73.88,103.43) v1(74.14,111.77) v1(74.22,102.79) v1(74.32,105.4) v1(74.35,104.67) v1(75.12,104.7) v1(75.26,103.48) v1(75.41,108.63) v1(75.49,105.24) v1(75.42,102.84) v1(75.47,99) v1(75.79,108.09) v1(75.79,105.91) v1(75.71,104.44) v1(75.81,100.9) v1(75.92,103.45) v1(76.4,105.67) v1(76.5,102) v1(76.52,103.18) v1(76.6,100.5) v1(76.62,108.41) v1(76.65,107.76) v1(78,117.86) v1(77.94,117.21) v1(80.25,128.05) v1(80.29,111.82) v2(82.21,122.03) v3(71.39,131.45) v3(71.39,130.69) v3(71.39,129.93) v3(71.39,129.11) v3(72.15,131.45) v3(72.15,130.69) v3(72.15,129.93) v3(72.15,129.11) v3(72.91,131.45) v3(72.91,130.69) v3(72.91,129.93) v3(72.91,129.11) v3(73.67,130.69) v3(73.67,129.93) v3(73.67,129.11) v3(73.7,131.55) v3(74.45,131.48) v3(75.27,131.48) v3(76.65,131.48) v3(77.43,131.48) v3(78.17,131.3) v3(78.17,130.41) v3(78.17,129.52) v3(78.17,128.63) v3(78.93,131.3) v3(78.93,130.41) v3(78.93,129.52) v3(78.93,128.63) v3(79.82,131.3) v3(79.82,130.41) v3(79.82,129.52) v3(79.82,128.63) v3(80.71,131.3) v3(80.71,130.41) v3(80.71,129.52) v3(80.71,128.63) v3(81.6,131.3) v3(81.6,130.41) v3(81.6,129.52) v3(81.6,128.63) v3(82.36,131.3) v3(82.36,130.41) v3(82.36,129.52) v3(82.36,128.63) v3(85.54,131.45) v3(86.3,131.45) v3(87.03,132.24) v3(87.05,131.41) v3(87.8,131.43) v3(87.82,132.24) v3(87.83,130.4) v3(87.82,129.65) v3(87.82,128.88) v3(88.48,131.12) v3(88.72,130.4) v3(88.71,129.65) v3(89.22,131.23)
+VDDCR_FCH_ALW: length 85.8
  TOP w0.381: v1(104.92,111.4) 104.67,111.14 101.25,111.14 100.22,110.12 94.05,110.12 93.42,109.49 91.13,109.49 90.13,108.48 R619.1
  IN4 w0.635: v1(117.71,66.05) 117.71,67.73 v1(120.3,70.32)
  BOTTOM w0.508: v1(104.92,111.4) 107.21,109.11 v1(107.21,104.89) 111.53,100.58 111.53,92.5 108.91,89.88 108.91,77.2 112.11,73.99 112.11,73.97 114.1,71.98 114.1,69.5 PC9302.1
  BOTTOM w0.635: v1(120.3,70.32) 121.17,69.45 PC9303.1 121.17,68.54 121.1,68.46 PC9304.1 v1(121.1,66.78) 121.44,66.43 PQ64.3 ; v1(117.71,66.05) 115.45,66.05 115.08,66.42 115.08,69.28 114.87,69.5 PC9302.1 114.1,66.7 113.83,66.43 PQ68.3
+VDDCR_FCH_S5: length 21.7
  BOTTOM w0.254: PC9205.1 118.77,51.18 119.27,50.68 119.27,46.84 119.81,46.3 124.08,46.3 124.76,45.61 PR366.2
  BOTTOM w0.635: PQ67.3 113.2,58.28 v1(114.81,56.67) 115.13,56.35 115.13,55.57 115.53,55.17 PQ65.3
  vias: v1(118.83,53.68)
+VDDCR_FCH_S5_R: length 8.1
  TOP w0.381: R619.2 87.86,108.48 v1(87.65,108.27) 87.63,108.27 87.62,108.26 87.08,108.26 C843.1 86.81,108.06 85.86,108.06 C842.1 C844.1 84.81,108.01 84.79,107.98 83.14,107.98 82.59,107.43 v2(82.59,107.42)
  BOTTOM w0.381: U18.AP13 82.35,106.4 U18.AR12 82.95,107.06 v2(82.59,107.42)
+VDDCR_GFX: length 38.7
  TOP w0.508: CS1.1 67.86,118.95 v1(67.46,119.35)
  IN3 w0.254: v1(32.45,118.6) 32.59,118.46 33.15,118.46 33.79,117.82 35.14,117.82 35.69,117.28 37.31,117.28 37.6,117.57 42.12,117.57 43.04,116.65 44.26,116.65 46.66,114.25 50.38,114.25 51.61,115.49 51.61,116.95 v1(52.01,117.35)
  IN4 w0.254: v1(56.3,119.09) 56.01,119.38 54.38,119.38 52.35,117.35 v1(52.01,117.35)
  BOTTOM w0.254: PR338.1 31.69,118.6 v1(32.45,118.6)
  BOTTOM w0.305: v1(59.97,108.96) 60.35,108.59 U18.G11
  BOTTOM w0.356: U18.N7 64.81,111.06 v1(64.64,111.06) 64.28,110.7 U18.L8
  BOTTOM w0.381: U18.L8 64.05,110.7 63.25,111.5 U18.K7 ; U18.N7 65.36,111.39 65.54,111.39 v1(65.8,111.13) 66.02,111.13 U18.P8 66.76,111.01 v1(67.01,111.01) 67.27,111.01 67.65,111.4 U18.T7
  vias: v1(59.16,104.11) v1(60.08,106.32) v1(60.01,104.09) v1(62.3,106.31) v1(62.28,105.13) v1(62.32,104.18) v1(62.45,110.29) v1(62.75,109.35) v1(63.85,102.24) v1(64.4,107.17) v1(64.42,99.84) v1(64.51,102.24) v1(64.65,103.77) v1(64.61,103.12) v1(64.72,105.37) v1(65.88,103.43) v1(65.83,102.78) v1(65.86,99) v1(65.93,105.39) v1(66.54,103.43) v1(67.11,102.68) v1(67.2,103.43) v1(68.04,101.04) v1(68.19,99.73) v1(68.25,107.67) v1(68.26,102.75) v1(68.21,100.38) v1(68.52,103.43) v3(57.06,128.7) v3(57.11,131.74) v3(57.11,130.98) v3(57.11,130.21) v3(57.11,129.45) v3(57.86,131.72) v3(57.86,130.96) v3(57.86,130.2) v3(57.87,129.45) v3(57.87,128.7) v3(58.74,131.48) v3(59.02,128.07) v3(59.49,131.53) v3(60.72,131.45) v3(61.37,128.02) v3(61.46,132.2) v3(61.47,131.45) v3(62.09,128.2) v3(62.2,132.02) v3(62.26,131.27) v3(62.28,130.35) v3(62.29,129.35) v3(62.79,128.8) v3(62.86,130.82) v3(62.86,129.86) v3(62.83,128.05) v3(63.57,131.09) v3(63.56,130.34) v3(63.56,129.59) v3(63.56,128.8) v3(63.59,128.05) v3(64.33,131.09) v3(64.32,130.34) v3(64.32,129.59) v3(64.32,128.8) v3(64.36,128.05) v3(65.09,131.09) v3(65.09,130.34) v3(65.08,129.59) v3(65.08,128.8) v3(65.12,128.05) v3(65.85,131.09) v3(65.85,130.34) v3(65.84,129.59) v3(65.84,128.8) v3(65.88,128.05) v3(66.7,131.48) v3(67.46,131.48) v3(68.7,131.48) v3(69.46,131.48) v3(70.27,131.1) v3(70.27,130.34) v3(70.27,129.58) v3(70.27,128.81)
+VDDCR_NB: length 127.1
  TOP w0.254: v1(117.6,150.12) 117.6,149.73 PR246.1
  TOP w0.508: v1(90.34,117.15) 89.71,117.78 CS2.2
  IN4 w0.254: v1(117.6,150.12) 117.6,150.04 119.08,148.56 119.08,146.81 117.64,145.36 117.64,138.59 116.88,137.83 116.88,133.86 115.64,132.62 108.51,132.62 103.92,128.02 v3(101.46,128.02)
  BOTTOM w0.508: v1(109.67,105.95) 109.69,105.93 CS4.1
  BOTTOM w0.533: 117.07,63.28 PU30.3 117.07,60.98 117.02,60.94 PR458.2
  BOTTOM w0.635: PQ63.3 122.2,61.76 121.64,61.76 119.49,63.91 ; 117.07,63.28 117.69,63.91 119.49,63.91 ; 119.49,63.91 119.49,64.66 120.32,65.49 120.32,69.23 119.54,70.01 119.54,71.28 119.06,71.76 116.9,71.76 110.37,78.3 110.37,89.27 113.14,92.05 113.14,116.56 114.9,118.32 114.9,122.29 112.42,124.76 105.38,124.76 PC9110.1
  vias: v1(79.13,106.7) v1(79.46,105.85) v1(79.61,98.58) v1(79.73,107.04) v1(80.19,106.58) v1(80.19,102.69) v1(80.23,107.52) v1(80.24,101.37) v1(80.25,100.7) v1(80.25,98.69) v1(80.48,105.98) v1(80.67,107.02) v1(80.92,104.55) v1(81.06,103.31) v1(81.25,105.91) v1(103.34,130.21) v3(98.41,128.91) v3(98.41,128.02) v3(98.41,127.01) v3(99.17,128.91) v3(99.17,128.02) v3(99.17,127.01) v3(99.94,128.91) v3(99.94,128.02) v3(99.94,127.01) v3(100.7,128.91) v3(100.7,128.02) v3(100.7,127.01) v3(101.46,128.91) v3(101.46,127.01) v3(105.09,128.38) v3(105.09,127.49) v3(105.09,126.47) v3(105.98,128.38) v3(105.98,127.36) v3(105.98,126.47) v3(106.87,128.38) v3(106.87,127.36) v3(106.87,126.47)
+VDDP_GFX: length 32.8
  IN4 w0.381: 100.45,103.64 98.59,103.64 97.52,104.71 97.52,104.97 97.18,105.31 90.73,105.31 90.3,105.74 90.3,105.74 89.38,106.66 87.31,106.66 87.03,106.94 87.03,107.71 86.56,108.18 77.99,108.18 77.16,109.01 76.2,109.01 75.96,109.25 75.96,110.47 76.11,110.62 76.11,112.16 v1(75.44,112.82)
  BOTTOM w0.381: U18.AE5 75.13,112.82 75.35,112.82 ; 75.35,112.82 74.85,112.32 U18.AE6 ; 75.35,112.82 v1(75.44,112.82)
  vias: v1(102.93,103.31) v1(103.29,101.86) v1(104.13,102.65)
+VDDP_S5: length 1.2
  BOTTOM w0.305: U18.AN12 80.88,107.57 v2(81.49,107.57) 82.02,107.57 U18.AP12
  vias: v1(82.08,107.73)
GND: length 1857.6
  TOP w0.191: v1(267.57,67.15) 268.02,67.15 268.31,66.85 U5.35 ; U5.15 v1(274.66,66.45) ; U5.8 v1(272.28,63.35)
  TOP w0.203: U34.91 235.35,22.21 v1(235.19,22.05) ; v1(219.65,24.67) 219.65,24.44 219.87,24.21 U34.1 ; v1(225.13,24.71) 224.77,25.07 U34.122 ; U34.49 228.77,11.28 v1(228.92,11.44) ; U34.27 221.84,13.81 v1(221.9,13.87) ; U29.9 v1(264.38,53.57) ; U34.113 228.37,24.7 v1(228.36,24.69)
  TOP w0.254: CN5.3 20.51,23.3 20.42,23.3 v1(20.4,23.31) ; C1073.2 176.41,116.14 v1(176.28,116.14) ; v1(173.92,116.94) 173.29,116.31 C1063.2 ; CN5.15 23,17.3 v1(23.08,17.38) ; v1(200.17,25.15) 200.17,24.95 199.29,24.07 Q13.4 ; v1(99.55,115.29) 99.55,114.48 99.84,114.2 103.56,114.2 103.9,114.53 v1(103.9,116.14) ; v1(23.36,21.58) 23.14,21.8 CN5.6 ; v1(21.17,10.77) 21.2,10.8 CN5.28 ; R786.2 169.47,105.4 170.34,106.27 v1(170.34,106.37) ; CN5.12 22.98,18.8 v1(23.44,19.26) 23.44,19.66 22.8,20.3 CN5.9 ; v2(85.63,117.9) 85.67,117.86 85.67,117.26 85.43,117.02 84.41,117.02 84.14,117.29 84.14,117.86 v2(84.25,117.97) ; Q13.1 197.99,20.67 v1(198.41,20.25) ; Q16.4 v1(199.03,16.12) ; v1(88.46,127.73) 88.22,127.73 87.93,127.44 PC9142.2 ; v1(23.15,15.98) 22.96,15.8 CN5.18 ; v1(54.21,13.95) 54.21,13.47 54.33,13.36 PQ43.1 ; Q16.1 v1(200.33,20.25) ; PQ43.4 56.18,12.06 v1(55.84,12.39)
  TOP w0.305: R591.2 74.99,109.89 75.54,109.89 75.88,109.55 C803.2 ; R535.2 84.83,110.94 v1(85.09,111.21) ; v1(264.19,45.61) 264.21,45.58 U7.14 ; v1(70.79,97.32) 71.3,96.8 C782.2 ; v1(136.3,85.25) 136.75,84.81 R1014.1 ; C821.2 83.62,101.1 v1(83.29,101.44) ; C802.2 71.1,102.81 71.51,103.23 v1(71.51,103.29) ; J3.6 v1(205.4,29.94) ; R540.2 R578.2 87.64,111.81 87.26,112.19 v1(87.26,112.6) ; R583.2 90,107.52 v1(90.04,107.57) ; v1(86.52,105.36) 87.09,105.36 87.74,104.71 R541.2 ; C1048.1 147.29,129.16 v1(147.17,129.04) ; R606.1 76.11,111.95 76.63,111.43 v1(76.69,111.43) ; R534.2 87.56,113.77 v1(87.62,113.83) ; PC9366.2 41.41,116.53 v1(42.4,116.53)
  TOP w0.356: C836.2 63.16,108.6 v1(63.5,108.94)
  TOP w0.381: v1(158.89,134.22) 158.5,134.61 R777.1 ; R793.1 151.97,126.4 v1(152.36,126.01) 151.97,125.62 C1028.1 ; v1(116.96,150.09) 116.95,150.09 PC9094.1 ; C352.1 275.55,84.82 v1(275.67,84.7) ; R544.2 R607.1 83.51,114.65 v1(83.29,114.44) 83.41,114.32 R538.2 ; C391.2 276.83,69.72 v1(277.16,70.05) ; v1(167.56,89.75) 167.68,89.87 C1050.1 ; C760.1 99.27,112.15 97.7,112.15 v1(97.14,111.58) ; C1004.2 132.9,109 v1(133.29,109.38) ; v1(150.58,134.52) 150.06,134.01 R781.2 ; C880.2 C881.2 89.46,110.21 v1(89.99,110.75) 90.06,110.81 90.06,111.28 89.91,111.43 R542.2 ; v1(143.01,95.75) 143.38,95.37 C1008.2 ; C839.2 63.16,104.21 v1(62.49,103.55) ; v1(85.58,105.29) 85.48,105.4 C884.2 ; v1(175.56,114.55) 175.37,114.37 C1044.1 ; C1033.1 R802.1 163.63,116.47 v1(163.76,116.6) ; v1(233.41,30.58) 232.74,31.24 R1074.1 ; C873.2 83.32,101.75 83.29,101.72 v1(83.29,101.44) ; C1057.1 155.47,133.45 v1(156.24,134.21) ; v1(148.95,136.71) 148.66,137 C1041.1 ; C1083.2 126.16,130.19 v1(126.18,130.22) ; C1061.2 127.61,135.74 v1(127.12,136.22) ; PC9364.2 118.56,141.68 v1(118.92,142.04) ; v1(40.94,109.5) 40.41,109.5 PR495.1 ; v1(141.97,95.95) 142.18,96.16 C1010.1 ; v1(274.68,64.4) 274.69,64.4 275.52,64.4 C415.2 ; C984.2 140.25,96.94 v1(139.86,96.55) ; v1(77.67,113.55) 77.67,114.3 R572.1 ; v1(117.72,147.11) 118.04,146.79 PR280.1 ; R834.2 261.73,51.74 v1(261.73,51.88) ; C1031.1 128.66,126.76 v1(128.35,126.44) 129.05,125.74 R800.1 ; v1(81.33,106.67) 81.36,106.7 C883.2 ; v1(133.91,101.72) 134.38,102.19 C987.2 ; v1(83.81,112.98) 83.4,112.57 R579.1 R537.2 ; R783.2 173.21,93.65 v1(173.11,93.75) ; C1055.1 125.91,138.32 v1(126.16,138.07) ; v1(146.94,97.19) 146.9,97.15 C1007.2 ; v1(166.24,106.36) 165.91,106.03 C1085.2 ; v1(133.55,135.42) 133.16,135.81 C1075.2 ; v1(275.58,68.06) 275.09,68.55 C661.1 ; v1(156.14,132.73) 156.3,132.88 C1062.2 ; v1(103.7,108.81) 104.38,108.81 R622.2 104.5,108.82 105.28,108.04 C875.2 ; v1(119.59,139.04) 119.59,139.1 118.89,139.81 PC9365.1 ; C1054.1 166.34,98.43 v1(166.34,97.89) ; C831.2 87.71,99.37 v1(87.56,99.22) ; C1092.2 v1(179.38,86.95) ; C878.2 C879.2 81.72,104.98 v1(81.43,105.26) ; v1(61.42,114.53) 61.64,114.31 C848.2 ; R924.1 v1(118.93,107.3) ; v1(165.96,89.75) 165.82,89.89 165.82,90.42 C1082.2 ; C1087.2 177.11,109.75 v1(177.12,109.74) ; v1(149.03,102.69) 148.74,102.4 C1003.2 ; v1(274.79,89.68) 275.05,89.42 C345.2 ; v1(274.87,87.2) 275.26,86.81 C347.2 ; C1098.2 v1(132.43,137.69) ; v1(58.45,104.11) 58.45,104.62 C845.2 ; C1081.2 175.32,110.37 175.32,109.14 v1(175.52,108.94) ; R937.1 137.65,93.55 v1(137.44,93.35) ; PC9349.2 40.79,107.36 v1(40.64,107.21) ; C1059.1 177.09,89.76 v1(177.11,89.75) ; v1(75.59,116.75) 75.59,116.67 76.08,116.18 R569.1 ; C9384.2 155.84,77.83 v1(156.02,77.65) PC9247.2 ; v1(123.64,141.84) 123.23,141.43 C1089.1 ; v1(172.65,111.81) 172.61,111.77 R782.2 ; v1(120.39,141.83) 120.59,142.04 C9394.2 ; v1(165.15,96.15) 164.5,95.51 C1045.1 ; PC9285.1 v1(136.63,48.94) 137.22,48.35 PC9375.1 ; C1080.2 144.67,128.42 v1(144.59,128.5) ; v1(43.58,111.03) 43.58,111.3 42.76,112.12 C9405.2 ; R670.2 139.96,129.56 140.74,130.34 R666.1 141.31,130.34 v1(141.55,130.58) ; C853.2 58.92,105.75 58.62,105.45 v1(58.32,105.45) 58.32,105.4 57.72,104.81 C751.2 ; v1(268.21,92.44) 268.42,92.65 EC18.1 ; v1(147.43,110.26) 147.45,110.24 C1017.2 ; EU1.8 v1(271.26,53.87) ; R719.1 v1(118.94,103.87) ; v1(118.86,104.86) 118.78,104.93 R717.1 ; v1(88.88,115.75) 88.32,116.31 EC90.1 ; R492.1 44.87,95.1 v1(44.92,95.05) ; C9366.2 v1(241.75,20.3) ; v1(63.9,103.43) 63.77,103.43 C838.2 ; EC91.1 124.28,148.6 v1(124.75,149.07) 124.28,149.54 EC26.2 ; v1(80.29,114.38) 80.29,113.92 R605.2 ; v1(171.99,97.92) 172,97.93 C1066.2 ; v1(129.57,129.8) 129.83,129.54 C1047.1 ; C1030.1 164.26,89.07 v1(164.13,88.94) 163.77,88.94 163.24,89.47 R795.1 ; v1(55.94,24.3) 55.94,23.21 55.57,22.84 U19.2 ; R939.1 v1(118.94,110.72) ; C1052.1 152.57,129.69 v1(152.72,129.84) ; C854.2 68.62,110.99 69.12,111.48 v1(69.41,111.48) 69.54,111.48 69.91,111.84 C804.2 ; v1(126.15,76.18) 125.87,76.46 PC9279.2 ; v1(136.01,150) 136.01,149.57 135.77,149.33 U20.4 ; C1013.2 C1014.2 140.17,110.47 v1(139.9,110.2) ; C1086.2 166.16,86.36 v1(166.18,86.38) ; v1(141.54,132.01) 141.36,132.2 C1231.2 ; EU1.3 v1(273.58,53.87) ; C770.2 v1(122.88,144.51) ; v1(73.05,94.2) C814.2 ; v1(87.61,101.06) 86.94,101.06 C822.2 ; PC9373.1 34.17,116.48 34.68,116.48 ; C413.1 266.07,65.06 v1(265.92,64.91) ; C1071.2 126.71,139.86 v1(127.16,139.41) ; C1060.1 168.47,105.85 v1(167.95,106.37)
  TOP w0.4: C1078.2 138.33,132.48 138,132.81 v1(137.71,132.81) ; v1(135.15,129.02) 135.15,129.21 134.94,129.42 134.54,129.81 C1069.2 ; C1070.1 125.63,136.62 v1(126.18,136.62) ; C1091.2 177.48,118.63 178.16,117.95 v1(178.4,117.95)
  TOP w0.457: v1(268.21,92.44) 268.09,92.44 267.47,93.06 C336.2
  TOP w0.508: v1(78,48.66) 78.18,48.48 C900.2 ; C526.2 7.33,18.42 v1(7.53,18.62) ; v1(167.92,48.66) 167.92,48.9 168.1,49.09 C478.2 ; EC33.1 v1(25.46,8.79) ; R809.1 156.83,135.56 156.12,136.28 C1036.1 156.12,137.16 v1(156.12,137.16) ; v1(135.31,81.03) 134.7,81.64 Q45.1 ; EC164.1 200.99,20.78 v1(200.99,20.25) ; PC88.2 60.64,8.98 v1(60.53,9.1) ; R1096.1 v1(116.78,111.49) 116.5,111.77 Q64.1 ; v1(134.38,52.79) 134.39,52.79 PC9275.1 ; R943.1 v1(116.78,110.47) C9378.2 ; v1(43.58,111.03) 43.25,110.7 C573.2 44.04,110.34 44.39,110 R263.1 ; C892.2 76.98,49.41 v1(76.57,49.41) 76.15,49.41 C895.2 ; C913.2 74.89,45.55 v1(75.45,46.11) 75.77,46.42 C890.2 ; v1(125.95,73.72) 125.95,74.01 C985.2 ; R397.2 v1(239.42,11.45) ; v1(40.02,19.21) 40.2,19.03 CN13.17 ; R110.2 179.44,45.36 v1(179.03,44.96) ; v1(38.72,23.09) 38.43,22.8 R515.1 38.41,22.41 R517.1 R518.1 ; v1(40.25,26.52) 40.37,26.65 CN13.5 ; v1(40.25,26.52) 39.19,25.46 C754.2 ; v1(40.25,26.52) 40.25,27.75 40.41,27.92 CN13.3 ; v1(40.25,26.52) 40.25,25.66 40.53,25.38 CN13.7 ; CS3.2 81.61,26.65 v1(81.72,26.76) ; v1(103.9,116.14) 103.9,116.84 C762.2 ; v1(36.06,87.58) 34.9,88.74 FAN1.3 ; v1(268.04,42.63) 268.1,42.56 C688.1 ; v1(23.81,7.47) 23.95,7.61 C9370.2 ; v1(277.56,85.83) 276.71,86.69 Y1.2 ; C370.1 172.5,80.53 v1(172.48,80.51) 172.03,80.05 C371.2 ; v1(167.16,58.4) 166.91,58.65 EC160.2 ; CN2.1 v1(31,61.73) ; R941.1 R1013.1 116.78,116.57 v1(116.76,116.59) ; R920.2 R919.2 104.71,56.24 v1(104.55,56.08) ; C334.2 39.79,91.38 v1(39.79,91.11) ; R916.2 106.27,50.83 v1(106.27,49.94) ; J1.6 v1(100.25,39.9) ; PR361.2 136.49,33.01 v3(136.71,33.23) ; v1(67.98,62.09) 68.29,62.09 68.72,62.51 C930.2 ; C487.1 v1(271.45,42.95) ; v1(135.45,94.04) 135.29,94.2 C992.1 ; v1(108.57,37.51) 108.3,37.51 C502.2 ; R778.1 174.93,118.62 174.32,118.02 v1(174.32,117.91) ; PR325.2 43.49,117.56 v1(44.08,117.56) ; v1(23.22,34.6) PR382.2 ; L15.2 v1(242.18,16.74) ; v1(178.76,111.21) C1029.1 R794.1 ; R967.2 v1(216.76,25.68) ; C911.2 v1(80.98,46.84) ; EC166.1 196.95,24.87 196.71,25.11 196.71,25.13 v1(196.58,25.25) ; R446.2 v1(240.12,14.43) ; v1(55.19,101.1) 55.28,101.2 C1119.2 ; C925.2 76.19,64.22 v1(75.55,64.22) C944.2 ; C1181.2 v1(214.53,10.45) ; C910.2 68,45.8 v1(68,46.31) ; v1(154.12,35.92) 154.36,35.68 C9392.2 ; C844.2 C842.2 C843.2 87.36,108.8 v1(87.63,109.08) ; C946.2 66.31,62.89 v1(66.31,62.89) 66.75,62.89 C935.2 ; v1(48.54,21.31) 49.08,20.78 C756.2 ; R926.1 141.95,95.94 v1(141.97,95.95) ; C517.2 v1(250.86,26.19) ; J2.3 v1(247.8,26.08) ; Q12.1 v1(245.96,21.71) ; PR242.2 v1(58.98,12.14) ; v1(137.47,45.84) 136.84,46.46 PR425.1 ; PR400.1 v1(147.59,50.82) ; v1(277.11,82.5) 276.68,82.5 C360.1 ; C1190.2 v1(215.96,19.82) ; C763.2 99.55,116.81 v1(99.55,115.29) ; C489.2 v1(183.83,42.33) ; C9393.2 171.51,42.52 171.77,42.27 v1(171.77,40.62) ; C339.1 38.97,90.47 v1(39.76,90.47) ; R780.2 132.12,133.24 v1(131.98,133.11) ; v1(154.29,78.52) C1024.2 ; v1(143.44,74.4) 142.83,75 C994.1 142.22,74.77 C986.2 ; C1211.1 223.03,29.29 v1(222.48,29.83) 221.84,29.2 R963.1 ; EC20.2 v1(273.61,56.49) ; PC9261.2 136.05,96.53 v1(135.85,96.73) ; Q42.1 211.48,18.9 v1(212.52,19.94) R872.1 ; v1(173.69,53.01) 173.77,52.94 C458.2 ; R178.2 103.41,35.19 v1(103.84,35.62) ; v1(208.47,28.49) 208.47,29.56 EC165.1 ; C912.2 68.73,48.51 v1(68.5,48.28) ; C1176.1 227.75,29.44 v1(227.41,29.78) ; v1(52.22,10.23) 52.9,10.91 PR244.2 ; C1117.2 60.93,111.56 v1(61.05,111.44) ; v1(275.7,71.53) 275.52,71.53 C662.1 ; FAN2.3 173.15,75.88 173.83,75.19 v1(175.05,75.19) ; v1(78.91,49.76) 79.65,49.02 C914.2 80.73,49.02 v1(80.81,49.1) ; C490.1 271.1,42.07 v1(271.34,42.31) ; v1(132.11,138.95) C1027.1 ; EC44.2 17.21,43.02 17.77,43.58 v1(17.77,44.06) ; PR334.2 v3(53.79,135.24) ; v1(26.99,17.84) 26.4,17.26 EC28.1 ; v1(2.26,47.2) 2.26,47.69 5.07,50.5 H12.1 6.35,53.05 v1(8.31,55.01) ; v1(55.02,25.19) 55.45,25.62 C9376.1 ; R133.1 R128.1 v1(261.76,45.06) ; v1(64.62,95.05) 64.36,94.79 C783.2 ; C1178.1 v1(239.96,22.59) ; Q8.1 v1(186.63,44.35) ; v1(146.96,38.67) 146.1,37.81 PC9368.2 ; v1(126.85,45.29) 126.84,45.28 C9365.2 ; C627.2 v1(276.09,90.53) ; C755.2 v1(51.89,26.77) ; v1(101.53,32.37) Q11.1 ; v1(73.83,49.51) 74.2,49.88 C915.2 C901.2 ; EC24.1 v1(164.05,34.65) ; PR313.2 v1(71.18,135.01) ; C1182.1 v1(215.35,25.73) ; 142.4,48.53 142.41,48.52 143.03,48.52 143.27,48.28 PC9374.1 ; v1(171.6,47.92) 172.1,48.41 Q6.1 ; C917.2 106.6,65.2 v1(107.04,64.76) ; R1002.2 v1(246.64,21.71) ; v1(105.25,49.99) R915.2 ; EC32.1 24.11,11.36 v1(23.8,11.67) ; C970.2 140.71,92.61 v1(140.82,92.5) ; EC25.1 v1(165.19,34.65) ; EC162.1 v1(249.17,21.61) ; CN5.42 21.67,3.9 21.02,4.55 v1(21.02,4.88) ; CN5.41 v1(22.12,26.21) ; v1(106.63,39.68) 106.95,39.68 107.65,40.38 J1.5 ; R112.2 172.29,50.19 171.42,49.32 C479.2 170.85,48.88 v1(171.04,48.68) ; Y1.4 v1(278.41,90.24) 278.12,90.53 R58.2 ; v1(177.12,114.54) 177.23,114.43 C1049.1 ; C903.2 70.78,49.66 v1(71.29,49.66) 71.75,49.2 C904.2 ; C1022.2 134.52,100.17 v1(135.01,100.65) ; C876.2 v1(243.51,7.4) ; R971.1 v1(240.06,13.35) ; R1003.2 269.13,82.47 v1(269.13,81.95) ; C486.2 v1(185.99,43.92) ; CN4.5 v1(168.5,32.26) ; PC9240.1 146.93,47.36 v1(146.66,47.08) ; U21.2 v1(245.23,12.16) ; v1(55.01,104.34) 55.28,104.08 C833.2 ; C837.2 59.82,108.29 59.74,108.37 C1131.1 58.82,108.37 58.45,108 v1(58.45,107.47) ; C9377.2 v1(116.78,112.5) ; C874.2 v1(241.72,8.47) ; R117.2 v1(180.29,48.79) ; v1(266.36,66.5) 265.93,66.93 265.93,67.81 R94.2 ; v1(64.69,113.11) 64.46,113.11 C841.2 ; R836.2 v1(264.97,57.39) ; EC163.1 v1(246.05,24.74) ; C753.1 v1(51.33,22.5) ; R792.1 v1(131.09,138.95) ; C919.2 v1(107.2,66.3)
  IN1 w0.152: 85.37,117.9 v2(85.63,117.9) 85.74,117.79 85.74,117.25 85.48,117 84.34,117 84.09,117.25 84.09,117.81 v2(84.25,117.97) 85.3,117.97 85.37,117.9
  IN1 w0.508: v1(8.31,55.01) 6.35,53.05 H12.1 5.07,50.5 2.27,47.7
  IN2 w0.254: 84.1,117.82 84.1,117.27 84.4,116.97 85.43,116.97 85.69,117.23 85.69,117.67 85.63,117.73 v2(85.63,117.9) 85.43,118.1 84.37,118.1 v2(84.25,117.97) 84.1,117.82
  IN2 w0.508: v1(8.31,55.01) 6.35,53.05 H12.1 5.07,50.5 2.27,47.7
  IN3 w0.152: v2(84.25,117.97) 84.44,118.17 85.36,118.17 v2(85.63,117.9) 85.76,117.76 85.76,117.42 85.38,117.04 84.4,117.04 84.15,117.29 84.15,117.87 v2(84.25,117.97)
  IN3 w0.203: v1(88.46,127.73) 88.86,128.14 89.66,128.14 90.19,128.67 90.19,130.93 92.19,132.92 94.7,132.92 97.13,130.49 107.33,130.49 108.65,131.81 110.74,131.81 v1(110.89,131.66)
  IN3 w0.254: v1(126.15,76.18) 125.87,76.46 125.34,76.46 124.7,75.82 124.7,71.06 124.1,70.46 124.1,58.69 130.4,52.39 132.56,52.39 134.19,50.75 v1(134.37,50.75) ; v1(51.99,117.99) 51.67,117.99 51.17,117.49 51.17,115.6 50.21,114.65 46.82,114.65 44.43,117.04 43.21,117.04 42.29,117.96 37.44,117.96 37.15,117.67 35.85,117.67 35.31,118.21 34.36,118.21 33.38,119.19 v1(32.72,119.19)
  IN3 w0.508: v1(8.31,55.01) 6.35,53.05 H12.1 5.07,50.5 2.27,47.7
  IN4 w0.152: v2(84.25,117.97) 84.32,118.05 85.25,118.05 85.39,117.9 v2(85.63,117.9) 85.63,117.17 85.46,117 84.32,117 84.14,117.18 84.14,117.86 v2(84.25,117.97)
  IN4 w0.254: v1(59.35,117.13) 56.71,119.77 54.1,119.77 52.33,117.99 v1(51.99,117.99) ; JCARD1.5 260.19,22.33 v1(258.2,22.33) 258.18,22.31 v1(257.14,22.31) 256.39,21.56 256.39,18.58 256.84,18.14 v1(256.84,16.73) 256.84,15.87 v1(257.39,15.33) 258.65,15.33 v1(258.84,15.51) 260.15,15.51 JCARD1.8
  IN4 w0.508: v1(8.31,55.01) 6.35,53.05 H12.1 5.07,50.5 2.27,47.7
  BOTTOM w0.114: CN17.188 87.97,58.41 88.16,58.6 88.16,59.08 v1(87.71,59.53)
  BOTTOM w0.127: v1(90.39,101.22) 90.19,101.22 89.92,100.96 88.99,100.96 U18.BC20 ; 68.29,115.1 68.06,115.33 68.06,115.56 68.18,115.68 68.18,116.12 68.12,116.18 68.12,116.6 68.34,116.82
  BOTTOM w0.178: U18.AV9 85.58,109.4 86.25,110.06 86.44,110.06 v1(86.49,110.11) ; U18.V1 U18.V2 68.29,115.1 67.83,114.64 67.83,114.08 U18.T4 ; v1(72.2,13.55) 72.41,13.34 72.41,13.17 72.27,13.04 PU15.22
  BOTTOM w0.191: PU27.11 119.44,24.82 v1(119.25,24.63) ; PU28.11 162.79,23.7 v1(162.7,23.61) ; PU29.11 v1(153.73,24.13)
  BOTTOM w0.203: v1(120.2,81.97) 120.17,82 U27.6 ; v2(145.37,92.4) 145.37,91.97 U22.AY12 ; v2(145.37,92.4) 145.7,92.4 U22.AW11 ; v2(145.37,92.4) 144.9,92.4 U22.AW13 ; PR301.2 112.1,134.48 110.89,133.27 v1(110.89,131.66) ; U18.BC12 89.87,107.4 v1(90.04,107.57) ; U18.K4 U18.K2 U18.K1 ; U18.F1 59.65,116.83 v1(59.35,117.13) ; U18.AF1 75.65,116.69 v1(75.59,116.75) ; 22.35,15.33 22.34,15.34 ; v1(17.77,44.06) 19.02,42.81 19.02,41.64 PU9.32 ; U209.9 22.38,21.45 ; v1(20.93,43.67) 20.82,43.56 PU9.4 ; U18.P2 U18.P1 66.05,116.91 v1(66.08,116.94) ; v1(18.28,40.95) 18.39,40.84 PU9.30 ; U18.D6 v1(57.59,111.84)
  BOTTOM w0.229: v1(57.17,50.46) 57.1,50.46 56.23,51.33 CN16.69 ; v1(89.97,60.04) 89.81,60.04 88.98,59.2 CN17.192 ; CN16.188 87.98,46.58 87.64,46.92 v1(87.46,46.92) ; v1(89.49,46.84) 89.37,46.84 88.98,46.45 CN16.192 ; CN17.69 56.22,63.78 56.96,63.05 v1(57.12,63.05) ; CN10.1 7.63,2.68 v1(7.47,2.83) ; v1(57.17,51.76) 57.23,51.82 CN16.73 ; CN17.43 49.73,64.73 49.51,64.51 49.51,63.63 48.94,63.06 v1(48.72,63.06) ; v2(72.54,116.99) 72.46,116.91 72.46,115.91 U18.AB1 ; CN17.73 57.23,64.45 v1(57.12,64.34)
  BOTTOM w0.25: U18.BC8 89.85,110.6 v1(89.99,110.75) ; U22.J40 129.75,108.55 U22.K40 ; U22.J40 U22.J39 130.7,109 v1(130.7,109.3) 130.7,109.6 U22.G39 ; U22.J40 U22.J41 v1(128.67,108.37) ; 130.71,107.05 130.59,106.92 130.59,106.68 U22.N39 ; 130.71,107.05 131.01,107.05 131.14,107.18 v1(131.6,107.18) ; 130.71,107.05 130.71,107.39 U22.L39 ; U18.AY24 v1(87.55,97.8) ; U18.F33 59.73,90.81 59.73,90.21 v1(59.76,90.19) ; U18.AP33 v1(82.05,89.9) ; v1(58.41,98.03) 58.18,97.8 U18.D24 ; U22.A5 v1(149.15,114.15) ; v1(135.48,90.66) 135.76,90.66 U22.BA29 U22.AY29 U22.AW29 ; v1(67.78,92.41) 67.65,92.54 U18.T30 ; U22.G3 150.25,109.72 150,109.47 v1(150,109.3) 150,109.25 150.25,109 U22.J3 ; v1(57.29,94.54) 57.35,94.6 57.38,94.6 57.38,94.6 U18.D28 ; U22.AW23 139.45,92.45 140.15,92.45 U22.AW21 140.57,92.25 v1(140.82,92.5) 141.2,92.5 U22.AW19 ; U22.AW23 U22.AY23 U22.BA23 ; U22.AW23 138.99,92.51 v1(138.76,92.51) 138.41,92.51 U22.AW25 137.9,92.5 137.3,92.5 U22.AW27 136.8,92.5 v1(136.58,92.5) 136.2,92.5 U22.AW29 ; U18.BC16 89.84,104.2 v1(89.93,104.29) ; U22.AW29 135.73,92.47 v1(135.48,92.47) 135.31,92.47 135.09,92.25 U22.AW31 ; U22.A29 v1(135.95,114.15) ; U18.K33 62.97,90.78 v1(62.97,90.19) ; U18.D22 57.83,99.4 v1(57.47,99.03) ; U18.K30 62.85,92.68 v1(62.55,92.38) ; U22.N3 150.25,106.77 150,107.01 v1(150,107.1) 150,107.4 U22.L3 ; v1(150.05,92.75) 150.02,92.75 149.52,92.25 U22.AW5 ; v1(150.05,92.75) 150.05,92.75 150.25,92.55 U22.AW3 ; v1(150.05,92.75) 150.05,92.95 150.25,93.15 U22.AU3 ; U22.AR3 150.04,94.66 150.04,94.92 v1(150,94.96) 150,95.04 150.25,95.29 U22.AN3 ; U18.AY28 87.51,94.6 v1(87.57,94.66) ; U22.AW35 133.01,92.25 133.33,92.56 v1(133.35,92.56) 133.44,92.56 U22.AW33 ; U22.BA17 142.55,91.1 U22.AY17 U22.AW17 ; U22.C37 131.15,112.05 v1(130.65,111.55) ; U18.A12 55.87,107.32 54.98,107.32 v1(54.92,107.37) ; v1(147.01,90.16) 146.95,90.22 U22.BA9 U22.AY9 U22.AW9 147.2,92.5 v1(147.5,92.5) 147.66,92.34 147.75,92.25 U22.AW7 ; U22.AY40 U22.AW39 130.48,92.28 131.19,92.28 131.22,92.25 U22.AW37 U22.AY37 131.68,91.42 131.68,90.98 U22.BA37 v1(131.55,90.16) ; U22.U1 152.13,104.35 v1(152.22,104.26) ; U18.H30 61.49,92.9 62.27,93.67 v1(62.27,94.23) ; U22.E1 v1(152.22,110.95) ; U22.C21 140.15,112.05 v1(139.9,111.8) 139.5,111.8 U22.C23 139,111.8 v1(138.8,111.8) 138.55,112.05 U22.C25 ; U22.C33 133.58,112.05 133.33,111.8 v1(133.13,111.8) 133.02,111.8 132.77,112.05 U22.C35 ; U22.AJ39 130.45,97.44 v1(130.72,97.17) 130.45,96.91 U22.AL39 ; v2(66.08,90.38) 66.05,90.41 U18.P33 ; U22.AL3 150.25,96.81 150,97.06 v1(150,97.2) 150,97.5 U22.AJ3 150,98 v1(150,98.37) 150,98.6 U22.AG3 ; v1(130.7,101.7) 130.7,101.3 U22.AC39 ; U22.AE3 150.25,100.19 150,100.44 v1(150,100.57) 150,100.58 150.25,100.83 U22.AC3 150.25,101.33 150,101.58 v1(150,101.67) 150,101.9 U22.AA3 ; v1(86.55,92.5) 86.95,92.9 U18.AY30 ; U22.C17 142.39,111.89 v1(142,111.89) 141.7,111.89 141.54,112.05 U22.C19 ; v1(60.06,93.23) 59.74,92.9 U18.F30 ; U18.D30 57.58,93 v1(57.33,92.75) ; v1(53.68,97.7) 53.68,97.61 54.09,97.2 54.57,97.2 55.16,97.79 55.94,97.79 U18.A24 ; U22.E41 v1(128.38,110.95) ; v1(143.1,111.89) 143.49,111.89 U22.C15 ; U18.D26 57.78,96.03 57.52,95.77 v1(57.52,95.76) ; U22.A37 131.55,113.65 v1(131.55,114.15) ; U22.C7 147.8,112.05 147.55,111.8 v1(147.5,111.8) 147.2,111.8 U22.C9 ; U18.AY20 87.02,101.07 87.59,101.07 v1(87.61,101.06) ; U22.A17 142.55,113.65 v1(142.55,114.15) ; v1(150.03,103.8) 150,103.82 150,104.1 U22.U3 ; U18.A32 55.25,91.1 v1(54.62,91.1) ; U22.AE1 v1(152.35,99.95) ; v1(84.94,93.32) 85.25,93.02 U18.AV30 ; U18.M30 64.86,92.49 65.52,92.49 65.72,92.28 v1(66.11,92.28) 66.11,92.62 66.05,92.67 U18.P30 ; v1(88.74,89.9) 88.74,90.21 U18.BB33 ; U22.A13 v1(144.75,114.15) ; v1(83.78,92.31) 83.78,92.31 83.65,92.43 U18.AT30 ; U22.C11 145.6,111.8 v1(145.25,111.8) ; v1(86.45,107.47) 86.52,107.4 U18.AY12 ; v1(87.56,99.22) 87.13,99.22 U18.AY22 ; U22.A33 v1(133.75,114.03) ; v1(128.55,95.63) 128.63,95.55 U22.AN41 129.15,95.65 129.65,95.65 U22.AN40 U22.AN39 130.45,95.24 v1(130.73,94.96) 130.73,94.94 130.45,94.66 U22.AR39 ; U22.AE39 130.45,99.68 130.7,99.43 v1(130.7,99.4) 130.7,99.29 130.45,99.04 U22.AG39 U22.AG40 129.65,98.95 129.15,98.95 U22.AG41 ; v1(90.13,94.54) 90.06,94.47 89.9,94.47 89.77,94.6 89.74,94.6 89.73,94.6 U18.BC28 ; U18.AY26 v1(87.63,96.2) ; v1(136.6,111.8) 136.8,111.8 U22.C27 ; U22.N1 v1(152.35,106.55) ; v1(150.05,104.92) 150.05,105.25 U22.R3 ; U18.BC24 90.03,97.8 v1(90.15,97.93) ; U18.A28 54.84,94.6 v1(54.27,94.03) ; v1(56.6,89.53) 56.45,89.68 U18.B33 ; U22.AN1 v1(152.35,95.55) ; U22.AJ1 v1(152.35,97.75) ; U22.A25 v1(138.15,114.15) ; U22.AA1 v1(152.35,102.15) ; U22.W39 130.76,103.56 v1(130.76,103.95) 130.76,104.04 U22.U39 130.45,104.7 v1(130.75,105) 130.75,105.15 U22.R39 ; U22.BA5 v1(149.15,90.15) ; U22.A9 v1(146.95,114.15) ; U22.AU1 v1(152.45,93.35) ; v1(85.14,90.22) 85.14,90.79 U18.AV33 ; U22.A21 v1(140.35,114.15)
  BOTTOM w0.254: CN17.205 92.23,64.22 91.57,63.57 v1(91.47,63.57) 91.23,63.57 90.94,63.87 90.94,64.41 91.23,64.7 CN17.201 ; CN17.35 47.73,63.49 46.65,62.41 v1(46.24,62.41) ; CN16.14 42.48,46.44 42.06,46.86 v1(41.99,46.86) 41.89,46.86 41.48,46.45 CN16.10 ; v1(85.98,46.25) CN16.180 ; CN16.226 97.48,46.74 v1(98.31,47.57) ; CN16.23 44.73,50.95 43.41,49.62 v1(43.27,49.62) ; v1(103.72,62.97) 103.67,62.97 102.72,63.92 CN17.247 ; CN16.65 55.23,51.46 54.89,51.12 v1(54.72,51.12) 54.51,51.12 54.06,51.57 54.06,51.94 54.23,52.1 CN16.61 ; CN16.9 v1(41.23,51.77) ; CN17.210 93.48,59.02 93.1,59.39 v1(92.98,59.39) 92.82,59.39 92.48,59.04 CN17.206 ; v1(85.89,64.14) 86.23,64.47 CN17.181 ; U18.F2 59.65,114.78 v1(59.92,114.52) 59.92,114.17 U18.F4 59.54,113.9 59.44,113.8 59.28,113.8 59.01,113.52 v1(58.48,113.52) 58.2,113.8 U18.D4 ; Q36.4 89.45,123.03 89.35,122.92 R581.2 ; C9389.2 39.48,116.18 v1(39.48,115.17) ; v1(58.42,63.68) 58.4,63.68 58.23,63.85 CN17.77 ; CN17.82 59.48,59.01 60.55,60.09 v1(60.7,60.09) ; v1(179.88,34.93) 179.89,34.94 Q25.1 ; v1(96.71,51.79) 96.73,51.81 CN16.223 ; CN9.3 168.6,49.34 v1(167.92,48.66) ; v1(23.36,21.58) 23.36,21.57 23.24,21.45 22.38,21.45 ; v1(84.65,51.77) 84.73,51.85 CN16.175 ; U18.G7 60.99,111.5 v1(61.05,111.44) ; CN16.218 95.48,46.48 95.85,46.84 v1(95.97,46.84) 96.08,46.84 96.48,46.44 CN16.222 ; CN16.19 43.73,51.44 v1(43.24,50.96) 42.73,51.47 CN16.15 ; CN16.247 102.73,51.29 103.57,50.45 v1(103.7,50.45) ; CN16.231 98.73,52.08 98.91,51.89 98.91,50.06 99.17,49.8 v1(100.12,49.8) ; Q36.1 91.7,124.33 91.12,124.91 v1(89.95,124.91) ; 68.34,116.82 68.79,117.27 68.79,119.55 69.76,120.53 69.76,122.18 70.27,122.69 70.27,124.95 v2(70.39,125.07) ; v1(221.9,14.57) 221.71,14.76 220.89,14.76 220.73,14.93 Q41.1 ; CN17.176 84.97,59.38 85.82,60.22 v1(85.87,60.22) ; CN16.103 64.73,54.56 ; v1(91.47,58.76) 91.48,58.75 CN17.202 ; CN17.223 96.72,64.42 v1(96.79,64.36) ; U18.AP30 82.45,93.3 83.07,93.3 83.47,92.9 U18.AT30 ; CN17.172 83.97,58.89 83.43,59.43 v1(83.32,59.43) 83.09,59.43 82.76,59.1 82.76,58.62 82.97,58.4 CN17.168 ; v1(60.48,46.21) CN16.86 ; v3(142.05,38.03) 142.19,37.9 PU19.19 ; CN16.77 58.23,51.84 v1(58.29,51.78) ; CN17.2 39.48,59.18 39.76,59.47 v1(39.94,59.47) 40.14,59.47 40.48,59.13 CN17.6 ; v1(31.69,8.48) 31.69,8.3 31.42,8.03 CN12.10 ; CN17.68 55.97,59.14 56.95,60.11 v1(57.17,60.11) ; CN17.180 85.97,58.78 v1(85.89,58.86) ; CN17.167 82.73,64.05 83.08,63.7 v1(83.22,63.7) 83.31,63.7 83.73,64.11 CN17.171 ; PU18.3 35.5,109.32 35.84,109.66 v1(35.9,109.66) 36,109.56 PU18.4 ; CN16.6 40.48,46.48 40.11,46.86 v1(39.99,46.86) 39.88,46.86 39.48,46.46 CN16.2 ; v1(87.46,46.92) 87.32,46.92 86.98,46.59 CN16.184 ; U22.BA23 138.92,90.85 v1(138.77,90.7) ; v1(256.84,16.73) 257.55,17.44 257.55,17.63 258.28,18.36 v1(258.82,18.36) 258.82,17.44 JCARD1.8 258.77,14.13 v1(257.87,14.13) 257.39,14.61 v1(257.39,15.33) ; CN16.98 63.48,45.99 v1(63.08,46.39) ; CN16.168 82.98,46.2 v1(82.97,46.21) ; CN16.171 83.73,51.49 83.34,51.1 v1(83.22,51.1) 83.13,51.1 82.73,51.5 CN16.167 ; v1(85.97,47.61) 84.98,46.62 CN16.176 ; CN16.18 43.48,46.22 v1(43.5,46.23) ; v1(180.89,50.97) 181.1,50.97 181.6,50.47 CN9.29 ; CN12.4 28.42,8.17 27.98,8.61 v1(26.96,8.61) 27.42,8.15 CN12.2 ; v1(33.19,8.4) 33.42,8.17 CN12.14 ; v1(89.98,58.73) 89.98,58.73 CN17.196 ; v1(51.96,60.2) 52.98,59.18 CN17.56 ; v1(39.15,51.8) 39.23,51.87 CN16.1 ; U18.AB1 U18.AB2 ; CN17.1 39.22,63.1 39.95,62.37 v1(40.21,62.37) ; CN16.44 49.98,46.43 49.58,46.83 v1(49.49,46.83) 49.38,46.83 48.98,46.43 CN16.40 ; CN16.5 40.23,50.29 v1(39.91,49.96) ; CN16.82 59.48,46.67 60.34,47.53 v1(60.46,47.53) ; v1(10.62,16.54) 10.37,16.8 9.77,16.8 9.65,16.68 CN10.57 ; Q31.1 233.08,17.14 v1(232.83,17.39) ; CN16.52 51.98,47.81 v1(52.46,48.29) ; CN17.185 87.23,64.13 87.63,63.72 v1(87.72,63.72) 87.81,63.72 88.23,64.14 CN17.189 ; CN16.94 62.48,45.87 v1(61.96,46.39) 61.48,45.9 CN16.90 ; v1(91.24,51.78) 91.23,51.79 CN16.201 ; CN16.193 89.23,51.45 89.62,51.06 v1(89.72,51.06) ; CN16.209 93.23,51.52 v1(92.52,50.81) 92.05,51.28 92.05,51.86 92.23,52.05 CN16.205 ; v1(52.48,46.88) 52.98,46.39 CN16.56 ; CN17.9 41.22,64.65 41.06,64.48 41.06,62.5 41.73,61.83 v1(42.22,61.83) ; v1(150.05,104.92) 150.05,104.55 U22.U3 ; CN17.85 60.23,64.7 60.6,64.33 v1(60.69,64.33) ; v1(126.18,136.62) VRAM1.E14 126.75,136.59 v1(127.12,136.22) ; CN17.39 48.73,64.35 v1(48.72,64.35) ; CN16.51 51.73,51.5 v1(51.89,51.34) ; v1(88.88,115.75) 88.88,115.78 88.45,116.21 U18.BB1 ; CN9.20 177.1,51.22 v1(177.18,51.3) ; CN17.72 56.97,58.62 v1(57.17,58.81) ; CN16.72 56.98,46.17 v1(57.01,46.2) ; CN17.51 51.73,64.37 v1(51.83,64.27) ; U18.L24 63.9,98 63.23,97.33 ; CN17.26 45.48,58.43 45.33,58.57 45.33,59.05 46.11,59.84 v1(46.25,59.84) ; Q25.4 v1(178.59,39.08) ; CN17.47 50.73,64.04 50.21,63.53 v1(50,63.53) ; v1(94.48,46.22) CN16.214 ; CN16.234 99.48,46.67 100.35,47.53 v1(100.48,47.53) ; v1(47.99,58.81) 47.98,58.79 CN17.36 ; v1(98.35,46.17) 98.48,46.04 CN16.230 ; CN16.189 88.23,51.47 87.88,51.12 v1(87.72,51.12) 87.58,51.12 87.23,51.47 CN16.185 ; v1(60.69,63.03) 60.52,63.03 59.23,64.32 CN17.81 ; v1(100.48,46.22) CN16.238 ; v1(218.89,16.95) 219.24,16.95 219.43,17.14 Q41.4 ; v1(180.1,50.88) CN9.26 ; v1(260.29,55.03) 260.65,55.4 Q23.1 ; U18.V4 69.45,113.7 69.45,113.45 v1(69.46,113.44) 69.19,113.44 U18.U5 ; CN17.217 95.23,63.31 96.33,62.21 v1(96.8,62.21) ; CN17.227 97.72,64.22 98.22,63.72 v1(98.29,63.72) 98.4,63.72 98.82,64.14 98.82,64.62 98.72,64.72 CN17.231 ; CN17.5 v1(40.22,64.34) ; CN17.184 86.97,58.88 87.63,59.53 v1(87.71,59.53) ; v1(175.76,48.92) 175.6,49.09 CN9.17 ; CN17.22 44.48,58.7 v1(44.42,58.75) ; CN16.31 46.73,51.24 v1(45.28,49.79) ; v1(61.42,114.53) 61.42,114.07 U18.H4 61.65,113.5 U18.J5 ; U18.AY14 86.95,105.78 v1(86.52,105.36) ; U22.C5 149.15,111.75 v1(149.38,111.52) 149.55,111.35 U22.E4 ; v1(101.66,58.81) 101.66,58.83 101.98,58.51 CN17.244 ; CN16.43 49.73,51.51 50.19,51.05 v1(50.44,51.05) 50.67,51.05 50.91,51.29 50.91,51.94 50.73,52.13 CN16.47 ; v1(84.46,46.91) 84.33,46.91 83.98,46.56 CN16.172 ; v1(98.31,60.17) 97.48,59.33 CN17.226 ; CN16.244 101.98,46.17 v1(101.96,46.19) ; v1(55.19,101.1) 55.29,101 U18.A20 ; CN16.196 89.98,46.51 89.65,46.84 v1(89.49,46.84) ; v1(49.21,51.11) 48.96,51.11 48.55,51.52 48.55,51.94 48.73,52.13 CN16.39 ; PU25.19 171.77,64.1 v1(171.96,64.29) ; v1(261.73,51.88) 261.95,52.1 Q23.4 ; U18.D18 57.95,102.59 58.32,102.22 58.32,102.02 58.45,101.9 v1(58.45,101.65) 57.95,101.15 U18.D20 ; v1(46.52,46.21) 46.48,46.17 CN16.30 ; v1(23.15,15.98) 23.15,15.83 22.65,15.33 22.35,15.33 ; v1(91.24,50.48) 91.05,50.48 90.23,51.29 CN16.197 ; CN17.251 v1(103.72,64.34) ; CN17.19 43.73,64.23 43.75,64.23 v1(44.39,63.59) 44.53,63.59 44.9,63.96 44.9,64.55 44.73,64.72 CN17.23 ; U18.L28 63.68,94.5 v1(63.41,94.23) 63.41,93.73 63.87,93.27 64.12,93.27 64.45,92.94 U18.M30 ; CN17.57 53.22,63.3 52.03,62.11 v1(51.85,62.11) ; Q31.4 v1(232.79,15.84) ; CN16.89 61.23,50.86 60.83,50.46 v1(60.64,50.46) ; CN17.234 99.48,58.85 100.09,59.47 v1(100.17,59.47) 100.34,59.47 100.66,59.15 100.66,58.59 100.48,58.4 CN17.238 ; v1(87.72,49.83) 87.4,49.83 86.23,51 CN16.181 ; U22.C17 142.71,111.89 v1(143.1,111.89) ; U18.T4 67.24,114.31 67.24,116.03 67.34,116.14 67.34,116.99 67.94,117.59 67.94,119.77 67.51,120.21 67.51,120.76 66.77,121.49 C767.1 ; CN16.27 45.73,51.49 45.34,51.1 v1(45.23,51.1) ; CN17.197 90.23,64.23 89.65,63.66 v1(89.55,63.66) ; CN17.235 99.72,64.7 99.63,64.61 99.63,64.04 99.97,63.7 v1(100.12,63.7) ; PQ70.1 32.18,79.1 v1(32.03,79.25) ; CN17.48 50.98,59.03 50.25,59.75 v1(49.97,59.75) 49.52,59.3 49.52,58.86 49.98,58.4 CN17.44 ; U18.K4 63.11,113.9 63.91,113.1 U18.L5 64.67,113.1 v1(64.69,113.11) 64.69,113.66 U18.M4 ; v1(42.23,60.23) 41.48,59.48 CN17.10 ; CN17.214 94.48,58.45 94.77,58.74 94.77,59.15 94.28,59.63 v1(94.27,59.63) ; v1(60.64,51.76) 60.48,51.76 60.23,52.01 CN16.85 ; U22.K40 130.1,108.02 130.45,107.67 U22.L39 ; CN17.243 101.72,64.71 102.05,64.39 102.05,63.82 101.72,63.5 v1(101.58,63.5) 101.35,63.5 100.72,64.12 CN17.239 ; CN17.222 96.48,59.14 96.12,59.49 v1(95.97,59.49) 95.8,59.49 95.48,59.17 CN17.218 ; CN16.235 99.73,52.05 99.61,51.92 99.61,51.47 99.97,51.1 v1(100.12,51.1) 100.23,51.1 100.73,51.6 CN16.239 ; v1(51.91,49.19) 52.27,49.19 53.23,50.15 CN16.57 ; v1(50.01,61.17) 49.8,61.17 48.79,60.16 48.79,58.62 48.98,58.44 CN17.40 ; v1(43.52,47.61) 44.48,46.65 CN16.22 ; v1(55.01,104.34) 55.1,104.26 55.89,104.26 U18.A16 ; v1(47.36,50.99) 47.84,51.47 47.84,51.99 47.73,52.1 CN16.35 ; CN16.227 97.73,51.56 98.17,51.12 v1(98.29,51.12) ; CN17.27 45.73,64.05 46.06,63.71 v1(46.24,63.71) 46.42,63.71 46.73,64.01 CN17.31 ; v1(31.04,8.48) 30.92,8.35 CN12.9 ; CN17.14 42.48,58.61 v1(42.25,58.83) ; CN16.252 103.98,45.83 104.23,46.08 104.23,46.64 103.9,46.97 v1(103.7,46.97) 103.52,46.97 102.98,46.43 CN16.248 ; CN16.99 63.73,52.14 63.34,51.75 v1(63.18,51.75) ; CN17.175 84.73,62.83 84.23,62.34 v1(83.22,62.34) ; CN17.15 42.73,64.43 v1(42.23,63.94) ; v1(58.4,58.86) 58.48,58.79 CN17.78 ; v1(58.45,104.11) 58.37,104.19 57.96,104.19 U18.D16 ; CN17.230 98.48,58.65 v1(98.35,58.77) ; v1(65.88,113.36) 65.88,113.73 U18.P4 ; v1(47.98,46.18) CN16.36 ; CN16.102 64.48,45.85 v1(63.97,46.36) 65.06,46.36 65.48,45.94 CN16.106 ; CN16.93 62.23,51.76 v1(62.24,51.75) ; CN17.65 v1(55.22,64.36) ; CN17.18 43.48,59.28 44.25,60.05 v1(44.41,60.05) ; CN16.206 92.48,46.45 v1(92.95,46.92) 93.03,46.92 93.48,46.47 CN16.210 ; CN17.213 94.23,64.67 94.3,64.6 94.3,64.11 93.88,63.7 v1(93.72,63.7) 93.57,63.7 93.23,64.04 CN17.209 ; v1(91.48,46.21) 91.48,46.21 CN16.202 ; CN16.78 58.48,46.2 v1(58.48,46.21) ; PQ71.4 132.43,28.67 132.85,29.08 132.85,29.72 133.09,29.97 PQ71.1 134.42,29.97 134.6,30.15 134.6,31.24 v1(134.3,31.54) ; v1(50.48,46.92) 50.61,46.92 50.98,46.55 CN16.48 ; v1(45,46.84) 45.12,46.84 45.48,46.49 CN16.26 ; CN17.193 89.23,64.71 89.04,64.52 89.04,62.74 89.42,62.36 v1(89.55,62.36) ; CN16.251 103.73,51.75 v1(103.72,51.75) ; v1(94.24,50.45) 94.44,50.45 95.23,51.24 CN16.217 ; CN16.243 101.73,51.78 v1(101.92,51.59) ; PQ70.4 33.48,75.43 v1(33.19,75.14) ; v1(57.01,47.5) 56.86,47.5 55.98,46.63 CN16.68 ; CN16.60 53.98,46.56 54.31,46.88 v1(54.47,46.88) 54.59,46.88 54.98,46.49 CN16.64 ; PU18.19 33.43,106.29 33.08,105.94 v1(33.08,105.8) ; CN12.17 v1(34.92,8.4) ; CN17.252 103.98,58.4 104.23,58.65 104.23,59.19 103.9,59.52 v1(103.7,59.52) 103.57,59.52 102.98,58.92 CN17.248 ; v1(51.95,58.83) 51.98,58.81 CN17.52 ; v1(67.11,122.5) 66.32,122.5 66.04,122.78 66.04,126.05 66.35,126.35 69.04,126.35 69.31,126.08 Y4.4 ; v1(94.23,51.77) 94.23,51.77 CN16.213 ; CN17.64 54.97,59.04 54.57,59.44 v1(54.47,59.44) 54.37,59.44 53.98,59.05 CN17.60 ; CN12.8 30.42,8.38 ; CN17.30 46.48,58.65 46.75,58.92 46.75,60.02 47.59,60.86 v1(47.99,60.86) ; CN12.20 36.42,8.25 v1(36.57,8.4) ; PR446.2 v1(134.37,50.75) ; CN17.86 60.48,58.57 v1(60.7,58.79) ; v1(59.35,50.32) 59.35,50.32 59.35,52 59.23,52.12 CN16.81 ; CN17.61 54.22,63.9 55.08,63.05 v1(55.23,63.05) ; v1(178.6,50.9) CN9.23 ; 65.73,54.3 CN16.107
  BOTTOM w0.3: VRAM2.A1 145.17,126.95 144.76,126.55 v1(144.76,126.5) ; U22.L7 147.95,107.78 v1(148.37,108.19) ; VRAM3.F5 v1(173.12,110.54) VRAM3.G5 ; VRAM1.R1 137.61,128.62 v1(137.72,128.52) ; U22.AL35 132.75,96.55 132.33,96.13 v1(132.22,96.13) ; v1(135.4,110.2) 135.75,110.55 U22.E29 ; v1(152.23,90.67) 152.23,91.05 151.82,91.45 U22.AY1 151.05,91.45 U22.AY2 ; VRAM1.U14 126.75,126.54 v1(126.81,126.48) ; U22.AM23 139.65,96.55 v1(139.86,96.55) ; v1(127.95,138.57) 128.15,138.37 128.16,138.37 128.31,138.22 VRAM1.C12 ; v1(133.35,97.23) 132.83,97.75 U22.AJ35 ; VRAM4.A14 164.33,86.57 164.33,86.41 v1(164.3,86.38) ; VRAM2.A14 155.7,126.91 v1(155.7,126.12) ; v1(154.37,140.24) VRAM2.U12 ; VRAM3.E12 174.37,115.74 v1(174.72,116.09) ; v1(134.46,110.15) 134.85,109.76 U22.G31 ; v1(135.46,93.33) 135.87,93.75 U22.AU29 ; VRAM1.N3 v1(135.95,130.62) ; U22.R35 133.3,106 v1(133.89,106) 134.1,106 134.35,106.24 U22.N32 ; VRAM4.R11 v1(175.51,88.95) ; v1(138.7,94.95) 138.3,94.55 U22.AR25 ; v1(137.72,130.3) 137.72,130.25 137.69,130.22 VRAM1.N1 ; VRAM1.U1 137.32,126.85 v1(137.32,126.48) ; v1(174.32,117.91) VRAM3.E14 174.13,117.15 v1(173.92,116.94) ; U22.B1 151.95,113.15 v1(152.15,113.15) ; U22.AA32 134.33,102.15 v1(133.91,101.72) ; v1(148.4,107.1) 148.75,106.75 U22.N5 ; VRAM2.E14 156.19,130.24 v1(156.24,130.29) ; U22.AJ5 148.75,97.55 v1(148.4,97.2) 148.4,97.1 U22.AL7 147.95,96.6 v1(148.35,96.2) 147.95,95.8 U22.AN7 147.95,95.42 v1(147.6,95.07) 147.95,94.72 U22.AR7 148.08,94.45 148.63,93.9 v1(148.63,93.87) ; v1(168.04,97.89) 168,97.85 168,97.44 VRAM4.E1 ; U22.A2 151.07,113.45 v1(151.5,113.88) ; v1(166.72,108.94) VRAM3.R3 v1(165.92,108.14) ; VRAM2.C14 155.64,128.57 156.07,128.57 v1(156.2,128.44) ; v1(168.06,86.32) 168.06,86.8 VRAM4.E14 ; VRAM4.M5 v1(173.11,93.75) VRAM4.L5 ; U22.E25 137.95,110.55 v1(137.6,110.2) ; VRAM3.L5 v1(169.12,109.74) VRAM3.M5 ; VRAM2.C4 v1(147.17,129.04) ; v1(131.6,107.18) 131.6,106.9 U22.N37 ; VRAM3.N1 167.95,106.91 v1(167.95,106.37) ; VRAM2.R1 145,138.07 v1(144.62,138.07) ; U22.G23 139.15,109.75 138.8,109.4 v1(138.77,109.4) ; v1(146.64,126.45) 146.77,126.57 VRAM2.A3 ; VRAM3.U1 164.68,106.9 v1(164.17,106.9) ; VRAM1.N12 128.31,130.22 v1(127.9,130.62) ; v1(153.97,126.39) VRAM2.A12 ; VRAM4.H13 VRAM4.H14 170.7,86.56 v1(170.7,86.37) ; VRAM1.H13 VRAM1.H14 126.26,134.22 v1(126.18,134.3) ; U22.AA5 148.75,102.05 148.4,101.7 v1(148.4,101.67) ; U22.C39 130.45,111.75 130.65,111.55 v1(130.65,111.55) 130.65,111.15 U22.E39 ; v1(166.34,97.89) 166.34,97.59 166.31,97.57 VRAM4.C1 ; U22.AR35 132.75,94.74 v1(132.98,94.97) 132.98,95.32 U22.AN35 132.75,95.56 v1(133.32,96.13) ; v1(129.55,137.02) VRAM1.D10 ; v1(147.6,106) 147.6,105.8 U22.R7 ; VRAM2.C12 154.38,128.23 154.4,128.23 154.4,128.23 v1(154.4,128.23) ; v1(145.3,110.2) 144.8,110.55 U22.E13 ; U22.E17 142.94,110.16 v1(143.02,110.16) ; v1(145.4,95.75) 145.15,95.75 U22.AP13 ; VRAM2.E1 144.63,130.24 144.6,130.27 v1(144.6,130.29) ; v1(154.4,130.64) 154.41,130.64 154.01,130.24 VRAM2.E12 ; v1(144.59,128.5) 144.61,128.52 145.05,128.52 VRAM2.C1 ; v1(126.16,138.07) 126.19,138.09 126.62,138.09 VRAM1.C14 ; VRAM4.D10 167.16,90.15 v1(167.56,89.75) ; U22.E3 U22.E4 ; VRAM4.C11 166.36,89.35 v1(166.71,89) 166.31,88.6 VRAM4.C12 v1(165.91,88.15) ; VRAM1.K13 v1(127.15,133.02) VRAM1.K14 ; U22.AG7 147.95,98.75 147.6,98.4 v1(147.6,98.37) ; U22.AA39 130.7,101.9 v1(130.7,101.7) v1(131.5,101.7) ; VRAM3.C12 175.92,115.78 v1(176.28,116.14) ; VRAM4.E3 168.16,96 v1(168.31,96.15) ; v1(139.9,110.2) 140.25,110.55 U22.E21 ; v1(128.74,129.01) VRAM1.R12 ; 129.65,112.85 U22.B41 v1(129.05,113.42) ; 129.65,112.85 U22.A40 129.65,113.59 129.16,114.07 v1(129.06,114.07) ; 129.65,112.85 U22.B40 ; U22.U5 148.75,104.45 148.45,104.75 v1(148.45,104.9) ; v1(165.96,89.75) 165.56,90.15 VRAM4.B10 ; v1(126.18,128.47) 126.26,128.55 126.68,128.55 VRAM1.R14 ; U22.BA2 151.39,90.85 v1(151.58,90.67) ; v1(164.13,88.94) 164.32,88.94 VRAM4.A12 ; VRAM3.T5 v1(165.12,109.74) ; v1(166.18,86.38) 166.23,86.43 166.23,86.87 VRAM4.C14 ; VRAM4.U3 v1(177.91,95.35) ; U22.BA40 v1(128.85,90.85) 129.05,91.05 U22.AY41 129.32,91.45 129.42,91.55 U22.AY40 ; 142.95,95.75 v1(143.01,95.75) ; v1(147.97,127.44) VRAM2.B5 ; VRAM4.B5 v1(165.11,94.55) ; v1(128.35,126.44) VRAM1.U12 ; VRAM3.R1 166.24,106.86 v1(166.24,106.36) ; v1(132.35,100.66) 132.75,100.26 U22.AE35 ; U22.AE32 134.97,100.57 134.98,100.57 135.01,100.6 v1(135.01,100.65) ; v1(177.11,94.55) VRAM4.T5 ; v1(144.3,109.42) 143.97,109.75 U22.G15 ; U22.J5 148.75,108.95 v1(148.4,109.3) 148.4,109.4 U22.G7 ; U22.AR21 140.3,94.55 v1(139.9,94.15) 139.5,93.75 U22.AU23 ; VRAM2.E3 146.82,130.24 v1(147.21,130.64) ; VRAM2.N12 v1(154.39,137.06) ; VRAM3.B5 v1(177.12,109.74) ; VRAM3.A12 v1(177.92,116.14) ; VRAM4.E12 v1(168.31,88.15) ; v1(127.95,140.22) VRAM1.A12 ; VRAM3.U3 v1(164.07,108.54) ; v1(165.91,96.15) VRAM4.C3 v1(166.71,95.35) VRAM4.C4 ; VRAM4.N3 v1(174.71,95.35) ; VRAM1.E12 v1(127.95,137.02) ; v1(146.33,110.1) 146.33,110.03 146.05,109.75 U22.G11 ; VRAM4.N12 v1(174.71,88.15) ; VRAM3.B10 v1(177.12,114.54) ; VRAM3.N3 167.92,108.59 v1(168.32,108.99) ; v1(126.18,130.22) VRAM1.N14 ; VRAM4.T10 v1(177.11,89.75)
  BOTTOM w0.305: v1(149.03,102.69) 148.51,102.69 U22.W7 ; U18.AD18 73.65,102.54 73.9,102.29 v1(73.9,102.23) ; U22.AW15 143.32,92.25 143.08,92.49 143.01,92.49 v1(143,92.5) 142.7,92.5 142.55,92.35 U22.AW17 ; U18.W19 69.62,101.6 v1(69,100.98) 68.85,100.83 U18.U21 ; v1(86.58,103.76) 86.95,104.14 U18.AY16 ; U18.U12 U18.W13 ; v1(144.77,98.65) 145.27,98.15 U22.AJ11 145.17,97.96 145.17,97.33 U22.AL11 ; v1(10.13,18.62) 9.68,18.18 CN10.63 ; U18.P21 U18.N22 65.06,99.01 v1(64.62,99.01) ; U22.U32 134.35,104.34 v1(135.03,103.66) ; VRAM1.C4 v1(135.15,138.62) VRAM1.C3 v1(135.95,137.82) ; CN10.51 10.04,15.18 v1(10.05,15.19) ; v1(74.3,99) 74.49,99.2 U18.AE22 ; U18.AG12 76.05,107.29 v1(75.79,107.03) ; VRAM1.R12 128.3,128.62 v1(127.91,128.23) ; v1(71.79,106.27) 71.92,106.4 U18.AB13 ; U22.AR19 141.5,94.55 v1(142.02,95.07) ; v1(65.88,113.36) 66.19,113.36 U18.P5 ; v1(150.03,103.8) 150.25,103.58 U22.W3 ; v1(60.8,97.97) 60.8,98.15 U18.G23 60.05,98.9 v1(60.05,99.07) ; U18.J22 62.24,99.51 62.24,99.03 v1(62.48,98.79) 62.85,99.16 U18.K22 63.08,99.2 v1(63.38,98.9) ; CN10.75 v1(10.01,21.18) ; v1(152.14,37.23) 151.8,37.23 151.63,37.41 151.63,37.66 151.8,37.84 U205.3 ; v1(164.18,97.3) 164.23,97.35 VRAM4.A1 ; U22.BA40 129.65,91.45 U22.AY40 ; v1(140.6,107.65) 140.35,107.89 U22.K21 ; U22.R32 134.22,105.32 v1(134.22,104.89) ; PR326.1 36.61,116.48 v1(36.61,115.93) ; v1(64.42,108.34) 64.05,107.97 U18.L12 ; U18.K10 63.36,108.8 v1(63.5,108.94) ; U22.U37 132.35,104.75 v1(132.35,104.75) 132.35,105.05 U22.R35 ; U18.AP22 82.05,98.67 82.68,98.04 82.68,97.67 U18.AR25 ; v1(74.26,108.63) 74.68,108.63 U18.AE10 ; v1(74.26,108.63) 74.26,109.29 U18.AD9 ; v1(74.26,108.63) 73.65,108.02 U18.AD12 ; v1(77.96,101.86) 77.51,101.86 U18.AH19 ; U22.C13 145,111.8 v1(145.25,111.8) ; U18.AV15 85.58,104.83 v1(85.58,105.29) 85.06,105.29 U18.AU14 ; VRAM3.R4 v1(166.72,108.94) ; U22.C31 135.1,111.8 v1(135.45,111.8) 135.7,111.8 U22.C29 ; U22.AR27 U22.AR25 ; U18.AG9 76.35,109.6 v1(76.55,109.6) 77.25,108.89 U18.AH10 ; v1(74.6,103.31) 74.6,103.75 U18.AE16 ; v1(70.74,100.62) 70.95,100.4 U18.Y21 ; U18.Y12 71.66,107.6 v1(71.79,107.47) ; U18.W10 70.05,108.39 v1(70.51,107.93) ; U22.AE10 146.32,99.95 v1(145.85,99.48) ; v1(62.26,95) 62.56,95.3 U18.K27 ; VRAM2.N3 v1(147.17,137.04) ; U22.J1 v1(152.35,108.75) ; U18.AU11 84.98,107.77 v1(84.98,107.41) 85.35,107.04 U18.AV12 ; v1(75.8,99.69) 76.05,99.95 U18.AG21 ; CN10.69 v1(10,19.68) ; v1(134.25,107.1) 134.3,107.15 U22.L31 ; v1(147.47,94.1) 147.82,94.45 U22.AR7 ; v1(154.64,39.68) 154.64,39.4 154.36,39.11 U203.3 ; VRAM1.R4 v1(135.15,129.02) VRAM1.R3 v1(135.95,128.22) ; U18.U15 68.45,105.2 v1(68.05,105.6) 67.65,106 U18.T13 ; v1(128.74,129.01) 129.12,128.62 VRAM1.R11 129.55,128.22 v1(129.58,128.22) 129.95,127.85 VRAM1.T10 ; U18.W16 70.05,104.16 v1(70.57,104.68) 70.73,104.68 U18.Y15 ; U18.AY8 86.95,110.57 v1(86.49,110.11) ; v1(77.96,103.07) 78.23,102.8 U18.AK18 ; v1(145.84,107.41) 145.58,107.15 U22.L11 ; U24.3 118.34,88.77 118.13,88.97 118.13,89.52 v1(118.48,89.87) ; v1(160.91,37.21) 160.61,37.5 U202.3 ; U18.Y18 71.25,103.03 v1(71.51,103.29) ; U18.AL19 80.23,102.18 v1(80.85,102.18) U18.AN18 ; v1(71.9,101.71) 72.34,101.71 U18.AB19 ; U18.AY10 87.55,109 v1(87.63,109.08) ; CN10.7 v1(7.49,4.18) ; U18.AH22 77.94,99.89 v1(77.94,100.61) 78.24,100.61 U18.AK21 ; v1(69.5,99.04) 69.66,99.2 U18.W22 ; U18.AB22 72.05,99.2 v1(71.91,99.07) ; VRAM1.E3 v1(135.95,136.22) ; v1(137.6,110.2) 137.15,109.75 U22.G27 ; v1(156.14,132.73) 156.06,132.64 VRAM2.H14 VRAM2.H13 ; v1(55.92,115.86) 56.38,115.4 U18.B2 56.75,115.4 57.15,115 U18.C3 ; U18.T4 68.45,113.1 U18.U5 ; VRAM2.R4 v1(147.17,137.84) VRAM2.R3 ; VRAM4.R3 v1(176.31,95.35) VRAM4.R4 ; U18.AL16 79.96,104 v1(80.31,104.35) 80.31,104.66 U18.AN15 ; U18.AD21 74.32,101.07 U18.AE19 74.55,101.9 v1(74.55,102.23) ; VRAM3.C14 v1(175.52,116.94) ; U18.AB16 v1(72.45,103.41) ; U18.U18 68.85,102.55 68.28,101.98 v1(68.28,101.64) 68.23,101.6 U18.T19 ; U18.AD15 73.48,105.03 v1(73.48,104.61) ; v1(58.32,105.45) 58.3,105.45 U18.D14 ; v1(134.35,127.42) VRAM1.T5 ; U18.L21 64.05,100.45 v1(64.42,100.82) ; U18.AB10 72.45,108.8 v1(71.81,108.8) ; U18.AH13 77.31,106.4 v1(78.01,105.7) 78.45,105.26 U18.AK15 ; U18.G26 60.11,96.44 60.11,96.74 60.03,96.81 ; U18.AG15 76.43,104.82 v1(76.43,104.56) 76.99,104 U18.AH16 ; VRAM1.C1 137.27,138.1 v1(137.82,138.1) ; VRAM1.U3 v1(135.95,126.62) ; CN10.45 v1(10,13.68) ; CN10.18 v1(3.61,6.93) ; CN10.39 v1(10,12.18) ; CN10.33 v1(10,10.68)
  BOTTOM w0.33: VRAM4.F5 168.71,93.97 v1(169.11,93.57) 169.51,93.97 VRAM4.G5 ; U22.AU9 146.81,93.75 146.46,94.1 v1(146.32,94.1) 145.86,94.55 U22.AR11 ; VRAM1.C14 126.79,138.22 127.14,138.56 127.14,138.58 v1(127.15,138.58) ; VRAM4.G10 169.51,90.17 v1(169.11,90.57) 168.71,90.18 VRAM4.F10
  BOTTOM w0.35: U18.AW22 86.45,99.5 v1(86.45,99.2)
  BOTTOM w0.356: v1(67.86,103.43) 67.86,103.79 U18.T16 ; v1(146.37,128.24) VRAM2.C3 v1(147.17,129.04) ; U18.N13 64.87,106.4 v1(64.42,105.94) 64.05,105.58 U18.L15 ; U18.AN25 80.81,96.9 v1(80.43,96.52) ; VRAM2.C11 153.12,128.64 v1(152.72,128.24) 152.37,127.89 VRAM2.B10 ; v1(134.71,97.07) 134.71,96.87 134.48,96.65 U22.AL32 134.35,96.54 v1(133.97,96.16) ; v1(64.67,108.93) 64.81,108.8 65.25,108.8 U18.N10 65.39,108.94 v1(65.9,108.94) 65.9,108.15 U18.P12 ; U18.T10 68.13,108.31 v1(68.27,108.31) 68.58,108.31 68.85,108.04 U18.U12 ; v1(65.22,103.43) 65.22,103.97 U18.N16 ; U18.BC32 89.35,90.91 91.27,88.99 v1(91.42,88.99) ; U18.AL22 80,99.2 v1(80.2,99.4) ; U18.P18 66.49,102.76 v1(66.49,102.24) ; v1(66.97,105.4) 66.65,105.4 U18.P15 ; v1(61.57,105.15) 61.57,104.98 U18.J15 ; U18.J19 62,102.25 v1(62.5,102.25) ; VRAM4.R12 v1(175.51,88.95) ; U18.N19 65.17,101.68 v1(65.17,102.24) ; U18.AN21 80.5,100.05 v1(80.22,100.05)
  BOTTOM w0.38: 60.03,96.81 59.99,96.81 59.55,97.26 U18.F25 59.55,97.73 v1(59.28,98) ; U18.AT19 83.29,101.74 v1(83.29,101.44) ; U18.AR25 83.14,97.21 83.14,97.06 v1(83.51,96.69) ; U18.AU20 84.55,100.92 85,100.47 v1(85,100.44) ; U18.J25 61.95,97.63 v1(61.58,97.99) ; U18.U24 68.85,98 68.25,97.4 v1(68.25,97.3) ; v1(59.73,102.82) 59.73,102.48 59.55,102.3 U18.F19 60.05,101.7 60.05,101.67 60.03,101.65 ; v1(63.23,97.43) 63.23,97.23 63.56,96.9 U18.L25 ; v1(70.79,97.32) 70.79,97.54 U18.Y24 ; 60.03,101.65 60.03,101.32 U18.G20 ; 60.03,101.65 v1(60.03,101.72) ; v1(62.26,95) 62.26,95 61.76,94.5 U18.J28 ; v1(64.62,95.05) 65.01,95.05 U18.N27 ; v1(60.86,104.05) 60.64,103.82 60.64,103.69 U18.G17 ; v1(60.05,99.07) 60.05,99.23 59.55,99.73 U18.F22 ; v1(85.69,96.68) 85.69,96.76 85.35,97.1 U18.AV25 84.55,98.2 U18.AU23 84.55,98.72 v1(84.05,99.21) ; U18.AU27 84.29,95.14 v1(83.82,95.14) 83.78,95.14 83.25,94.6 U18.AR28 ; U18.AP27 81.89,95.14 v1(81.47,95.14) 81.37,95.05 80.85,94.53 U18.AN28 80.72,94.5 v1(80.24,94.02) ; U18.AD24 73.65,97.62 v1(73.46,97.42)
  BOTTOM w0.381: U18.T22 67.3,99.2 v1(67.11,99) ; U22.L27 137.5,107 137.64,107 v1(138.01,106.62) 138,106.62 137.53,106.15 U22.N27 ; EC64.1 v1(170.24,55.3) ; U22.AE17 v1(141.85,100.65) U22.AC19 v1(140.85,101.65) ; R950.1 v1(123.13,108.44) ; v2(70.39,125.07) 70.15,125.3 Y4.4 ; v1(148.35,99.53) 148.35,99.55 U22.AE5 ; R587.1 73.39,121.48 v2(73.91,122) ; R956.1 v1(123.13,107.29) ; v1(75.79,107.03) 75.16,106.4 U18.AE13 ; v1(19.35,24.75) 19.48,24.88 R982.1 ; v1(63.9,103.43) 63.9,102.95 U18.L18 ; v1(23.08,17.38) 22.57,17.89 R986.1 ; v1(159.55,124.08) R646.2 ; v1(23.43,18.4) 22.95,18.88 R981.1 ; U22.AU9 147.12,93.75 v1(147.47,94.1) ; v1(114.85,88.13) 114.97,88.24 C965.2 ; v1(162.98,124.06) R673.2 ; v1(275.67,84.7) 275.21,84.24 U207.2 ; v1(84.39,122.19) 84.39,120.88 ; 84.39,120.88 84.78,120.49 R1092.2 ; 84.39,120.88 84,120.49 R1093.2 ; U22.K29 135.95,108.16 v1(135.41,108.7) ; v1(123.81,89.74) 124.16,89.74 R711.2 ; C978.2 115.88,79.98 v1(115.47,79.57) ; R784.2 140.64,133.97 v1(141.19,134.52) ; v1(103.7,108.81) 103.21,108.81 C769.1 ; R720.1 v1(123.13,102.72) R651.2 ; v1(140.6,107.65) 140.85,107.65 U22.L19 ; R952.1 v1(118.83,108.44) ; v1(113,70.52) 112.9,70.41 PC9302.2 ; v1(35.33,110.99) 35.11,111.22 PC9186.2 ; Y6.2 112.12,84.3 v1(112.71,84.89) ; v1(17.53,20.26) 17.68,20.1 18.38,20.1 18.75,20.48 C1227.1 ; v1(115.35,85.82) 115.58,86.06 116.34,86.06 R1007.2 ; PC9177.2 32.46,114.27 v1(32.57,114.16) ; R945.1 v1(123.13,110.72) 123.13,111.37 123.49,111.74 R674.2 ; U22.G35 132.82,109.85 v1(133.29,109.38) 133.55,109.12 U22.J34 ; U22.E21 140.65,110.55 U22.G19 ; C973.1 145.03,85.61 145.42,85.22 145.42,84.47 ; PC9350.2 32.13,111.9 v1(32.37,112.14) ; U22.L23 139.15,107.15 v1(138.68,107.62) U22.K25 ; v1(118.93,107.3) 118.75,107.48 R954.1 ; v1(168.2,26) 168.7,25.5 PC9321.2 ; PC9253.2 PC9254.2 140.67,54.46 v3(140.76,54.36) ; C1236.1 258.1,14.37 v1(257.87,14.13) ; PC9144.1 111.97,135.5 PC9131.1 ; U22.R19 141.84,105.64 141.84,105.66 142.33,106.15 U22.N17 U22.L15 ; PR287.1 108.8,137.68 v1(109.29,137.18) ; U22.AJ10 146.39,97.75 v1(146.94,97.19) 146.4,96.65 U22.AL10 ; R490.2 v1(49.71,110.01) R489.2 ; v1(40.64,107.21) 40.79,107.36 PC9349.2 ; v1(148.4,101.67) 148.4,101.66 147.95,101.21 U22.AC7 ; PC9283.1 136.4,48.72 v1(136.63,48.94) ; R608.1 R531.1 80.51,122.62 80.35,122.46 v2(80.35,122.03) 80.35,121.7 C761.1 ; U22.AR31 134.95,94.55 v1(135.45,94.04) ; v1(160.69,124.06) R667.1 ; v1(118.94,103.87) R932.1 R935.1 ; R398.2 v1(172.53,55.25) ; v1(67.77,122.5) 67.77,122.84 Y4.2 ; U22.AA10 145.83,101.62 v1(145.83,101.51) ; v1(124.02,87.23) 123.89,87.1 C964.2 R707.2 ; U18.AG18 76.05,102.69 75.76,102.41 v1(75.76,102.09) ; v1(137.85,101.65) U22.AA27 v1(137.85,102.65) ; v1(137.85,101.65) U22.AA25 v1(137.85,102.65) ; v1(137.85,101.65) U22.AC25 v1(137.85,100.65) ; PR327.2 43.62,117.56 v1(44.08,117.56) ; C9367.2 149.6,40.35 v1(149.33,40.08) ; v1(124.14,100.81) 124.13,100.82 R649.1 ; PU21.8 122.49,39.04 122.12,39.41 PR375.2 122.12,40.49 v1(121.5,41.11) ; C752.2 50.42,102.4 v1(49.7,102.4) 49.02,102.4 R507.1 ; PR331.1 33.96,126.21 v1(34.05,126.12) ; R958.1 118.83,106.15 v1(118.86,106.13) ; C1225.2 18.52,13.54 v1(18.52,13.54) ; v1(121.91,89.92) 121.91,89.88 R1067.2 ; C1144.1 v1(269.69,54.13) ; PR256.1 113.45,149.64 v1(112.98,150.12) 113.37,150.51 PC9099.1 ; v1(120.02,149.15) 119.93,149.05 119.93,149.05 119.6,148.73 PC9111.2 ; R493.1 v1(47.43,105.75) ; v1(237.57,23.65) 237.57,24.21 C691.2 ; v1(23.7,45.85) 23.7,46.02 24.69,47 PC9361.2 ; v1(67.21,7) 67.58,7.36 PR229.2 ; U22.AG11 v1(144.85,99.65) ; R472.2 R485.2 49.69,113.77 v1(49.73,113.73) 49.77,113.77 R483.2 R476.2 ; v1(143.01,95.75) 142.61,96.15 U22.AM17 ; v1(49.6,101.53) 49.05,101.53 R491.1 ; U22.J37 132.24,108.46 v1(132.24,108.24) 132.75,107.72 U22.L35 ; v1(137.85,102.65) U22.W25 v1(137.85,103.65) ; v1(137.85,102.65) U22.W27 ; v1(123.2,78.39) 123.65,77.94 C9372.2 ; v1(87.2,122.19) 87.2,122.66 87.46,122.92 R581.2 ; C768.1 104.02,107.27 v1(104.09,107.33) ; v1(141.86,104.66) 142.35,104.17 U22.U17 ; U22.AP17 142.95,95.75 ; R506.1 v1(47.47,106.76) ; R574.1 77.34,121.42 77.34,121.96 v2(77.4,122.02) ; v1(99,109.55) 98.51,109.55 C757.1 ; PC9305.2 125.71,27.11 v1(125.89,26.93) ; v1(94.93,106.36) 95.45,106.36 R604.2 ; R681.1 v1(123.13,106.15) ; R547.2 97.12,115.17 97.29,115.34 v1(97.29,115.36) 97.29,115.41 96.52,116.18 R548.2 ; R602.2 v1(94.93,107.27) ; PC9145.2 39.74,127.09 39.98,126.85 PC9146.2 40.44,127.55 v3(40.43,127.56) ; v1(165.15,96.15) 164.74,95.75 VRAM4.A3 ; R948.1 v1(118.86,109.58) ; PR347.2 31.95,119.96 v1(32.72,119.19) 32.81,119.28 32.81,119.94 33.99,121.12 PC9178.1 ; R922.1 v1(123.13,103.87) ; R928.1 v1(123.13,105.01) ; U22.W19 v1(141.85,102.65) ; PC9105.2 106.69,143.97 v3(106.69,144.02) 106.93,144.26 PC9106.2 ; C766.1 68.49,121.84 68.74,122.09 v1(68.74,122.5) ; v1(123.63,136.15) 123.63,135.62 R776.1 ; v1(136.6,111.8) 136.2,111.8 U22.C29 ; v1(119.82,143.08) 119.98,143.24 PR281.1 ; U22.G7 147.84,109.85 v1(147.43,110.26) 147.14,110.55 U22.E9 146.79,110.55 v1(146.33,110.1) ; EC63.1 v1(169.1,55.3) ; R488.2 v1(49.71,112.76) R487.2 ; C767.1 66.77,121.77 67.11,122.12 v1(67.11,122.5) ; R650.1 v1(120.05,99.62) ; R652.2 124.17,90.53 v1(123.81,90.89) ; R946.1 v1(123.13,109.58) ; v1(118.86,104.86) 118.34,104.86 R930.1 ; U22.W11 v1(144.85,103.65) ; C969.2 149.1,85.33 v1(148.52,85.91) ; U22.R11 v1(145.76,105.56) ; R1008.2 96.63,112.09 v1(97.14,111.58) 96.62,111.07 R1009.2 ; R497.2 v1(49.71,111.61) ; U22.AG17 141.85,99.65 ; C1232.2 v1(161.84,124.06) ; R499.2 v1(47.43,104.73) ; v1(94.7,108.67) R603.2
  BOTTOM w0.4: U22.AA19 v1(140.85,101.65) ; U22.AA19 141.85,101.65 ; U22.AA19 v1(141.85,102.65) ; v1(141.85,103.65) U22.W19 ; v1(141.85,103.65) U22.U19 v1(141.86,104.66) U22.R17 U22.N19 ; v1(141.85,103.65) U22.U17 ; v1(141.85,103.65) U22.W17 v1(141.85,102.65) ; v1(84.05,99.21) 84.05,99.5 U18.AT22 ; 137.35,106.15 137.85,105.65 ; 137.85,105.65 137.85,105.65 U22.R25 ; 137.85,105.65 U22.R27 v1(137.85,104.65) ; 137.85,105.65 U22.N25 138.6,105.9 138.6,105.4 U22.R25 ; v1(137.85,104.65) U22.U27 v1(137.85,103.65) ; v1(137.85,104.65) U22.R25 ; v1(137.85,104.65) U22.U25 ; v1(137.85,99.65) U22.AG25 138.6,99.4 138.6,99.9 U22.AE25 ; v1(137.85,99.65) U22.AE25 ; v1(137.85,99.65) U22.AG27 137.14,99.36 137.14,99.94 U22.AE27 ; v1(137.85,99.65) U22.AE27 ; U22.AE25 v1(137.85,100.65) ; v1(137.85,100.65) U22.AE27 ; v1(137.85,100.65) U22.AC27 ; v1(137.85,103.65) U22.W27 ; v1(137.85,103.65) U22.U25 ; v1(141.85,102.65) U22.AA17 141.85,101.65 ; 141.85,99.65 U22.AG19 ; 141.85,99.65 U22.AE17 ; 141.85,99.65 U22.AE19 v1(141.85,100.65) U22.AC17 141.85,101.65 ; 141.85,101.65 U22.AC19 ; U22.R25 v1(138.85,104.65) U22.U25 ; U22.AC27 137.14,101.36 137.14,101.94 U22.AA27 ; U22.AC27 v1(137.85,101.65) ; U22.AC11 v1(144.85,101.65)
  BOTTOM w0.432: U9.5 v1(45.19,107.51)
  BOTTOM w0.508: v1(120.25,81.33) 120.56,81.33 R766.1 ; PQ36.1 38.21,11.66 v1(37.76,12.12) PQ31.1 ; v1(70.3,7.07) 69.87,6.64 PC251.2 ; PC9213.2 117.41,33.18 v1(117.62,33.38) ; v1(184.06,34.38) 183.93,34.25 CS6.1 ; PC87.2 144.69,5.58 v1(144.33,5.94) 144.02,6.25 143.73,6.25 PR62.1 ; Q55.3 59.55,127.31 v1(59.24,127.01) ; R821.2 v1(248.09,12.73) ; PC9318.1 v1(168.7,23.61) PC9322.2 ; PR204.2 v1(153.25,14.91) ; PC239.2 51.02,9.2 v1(50.37,8.55) ; PD2.2 53.48,12.78 53.23,13.04 v1(53.23,13.44) ; v1(119.22,28.44) 118.69,28.97 PC9210.2 117.58,28.97 PC9211.2 ; Q58.3 136.71,23.48 v1(136.52,23.29) ; PC9308.2 v1(126.01,22.41) ; PR195.2 v1(62.44,17.5) ; R767.1 C9373.2 131.22,83.01 v1(131.31,82.92) ; PR454.2 v1(169.13,58.4) ; v1(156.77,36.15) 156.27,35.66 C1239.2 ; PQ28.1 v1(56.15,17.63) ; v1(177.34,37.55) 177.51,37.38 C689.2 ; v1(121.03,111.3) 121.47,111.74 C968.2 ; v3(202.6,46.79) 201.3,48.1 H13.1 197.8,50.38 v3(195.59,52.58) ; v1(264.38,53.57) 264.37,53.56 C1237.1 ; v1(26.94,12.04) 26.52,11.62 C735.2 ; C743.2 31.49,11.28 v1(31.88,11.67) ; v1(152.14,37.23) 152.14,36.68 151.78,36.32 151.78,34.98 152.43,34.33 C9391.2 ; PC9353.2 38.42,86.01 v1(37.91,86.52) 37.46,86.07 PC191.2 ; PC9327.2 PC9334.2 v1(152.34,29.97) ; PC9117.2 73.68,126.22 73.05,125.59 v2(72.99,125.59) ; PC9117.2 PC9119.2 PC9143.2 ; PC9117.2 PC9138.2 ; v1(122.22,69.9) 122.22,69.27 PC9303.2 ; v1(116.1,60.58) 116.1,60.95 115.8,61.25 PU30.4 ; v1(14.34,10.87) 13.91,10.44 Q57.3 ; v1(107.2,66.3) 107.21,66.3 C937.2 C936.2 C938.2 ; PC224.2 PR199.2 v1(74,15.01) ; PC90.2 142.82,11.12 143.21,10.73 v1(143.21,10.33) ; v1(36.11,78.03) PC188.2 ; v1(125.04,47.02) 124.96,47.11 PR370.1 PC9208.2 ; PC82.2 75.71,15.48 v1(76.32,15.48) ; PC248.2 v1(149.21,5.77) ; PR113.1 v1(18.61,45.95) PC147.2 ; C1238.2 PC9355.2 127.84,26.94 v1(127.87,26.9) ; U208.4 v1(139.07,81.54) ; PC9255.2 147.14,46.6 v1(146.66,47.08) ; v1(143.06,41.15) 143.83,40.39 PC9202.2 ; v1(21.17,5.63) 20.41,6.39 C746.2 ; v1(149.83,14.9) 149.83,16.56 148.64,17.75 PC86.2 ; CN12.22 37.47,8.06 37.13,8.4 v1(36.57,8.4) ; Q54.3 81.18,127.36 v2(81.32,127.5) ; v1(149.63,44.12) 149.17,43.67 PR424.1 ; PQ66.1 v1(116.42,49.08) ; v1(151.52,14.84) 151.52,14.63 151.16,14.26 PR206.2 151.07,14.24 PC225.2 PR210.1 ; v1(173.66,81.72) 173.66,82.15 R779.1 C1038.1 R811.1 ; v1(147.69,34) 147.21,33.52 EC151.2 ; PR236.2 68.69,5.58 v1(69.08,5.97) ; PC9214.2 118.51,43.22 118.61,43.13 v1(118.77,43.13) ; v1(176.01,64.33) 175.11,63.43 PC9298.2 ; v1(120.39,141.83) 120.39,141.84 PC9141.2 ; PR225.2 178.25,10.14 v1(177.99,10.39) ; Q50.1 119.85,84.23 119.67,84.05 v1(119.08,84.05) ; C1132.1 252.69,10.77 252.93,11.01 v1(252.93,11.27) ; C745.2 20.84,8.03 v1(20.83,8.02) ; C747.2 C748.2 150.85,33.35 v1(150.19,34.01) ; C9401.2 v1(93.28,145.01) ; v1(57.59,17.58) C724.2 ; PC9284.2 136.29,42.5 v1(136.74,42.06) ; v1(25.52,60.42) R352.2 26.78,60.97 Q21.1 ; v1(44.74,120.95) 44.72,120.97 PR307.1 PR310.1 ; v1(136.49,26.5) 136.49,26.94 136.09,27.33 PC9354.2 PC9363.2 ; PC9328.2 156.02,29.94 156.02,29.95 v1(156.02,29.98) ; v1(117.41,54.13) 117.99,53.56 PC9206.2 PC9205.2 ; v1(148.75,37.58) 148.66,37.66 PC9201.2 ; v1(25.54,55.76) 25.6,55.69 PC9237.2 ; C1135.1 v1(248.82,20.64) ; v1(28.61,55.35) 29.02,55.35 C887.2 ; v1(117.71,56.93) 117.44,56.93 PR460.1 ; C9395.2 42.86,99.93 44.13,98.66 44.13,95.84 v1(44.92,95.05) ; v1(50.06,16.89) 49.82,16.65 PR186.2 ; C725.2 v1(232.47,14.03) ; PC9264.1 138.44,42.49 v1(138.87,42.06) ; C1183.2 v1(222.55,15.46) ; C9398.2 v1(21.02,4.88) ; PC9207.1 123.7,53.87 v1(123.7,53.69) 123.28,53.27 PC9204.1 ; v1(149.9,5.98) 150.55,5.98 PC247.2 ; v1(277.11,82.5) 277.72,82.5 C648.2 ; v1(110.98,135.86) PC9131.1 ; v1(125.45,51.79) 125.41,51.83 PU20.2 ; CS4.2 109.93,105.15 v1(109.78,105) ; PC9362.2 30.82,79.35 31.92,79.35 v1(32.03,79.25) ; v1(89.95,124.91) 89.94,124.9 C764.2 ; v1(127.5,45.12) 127.95,45.57 C9364.2 128.17,45.47 128.17,44.75 128.54,44.38 Q60.3 ; C9371.2 122.84,80.23 v1(122.21,80.85) 121.86,80.5 C979.1 ; ESD1.2 v1(114.54,14.05) ; PC245.2 73.27,7.25 v1(73.87,6.64) ; PC250.2 v1(73.8,5.97) ; v1(76.21,12.35) 76.13,12.27 PC226.2 ; C728.2 225.56,13.69 v1(225.63,13.61) ; PC9288.2 v1(167.16,58.4) ; PC9136.1 115.61,135.95 v1(116.12,135.95) ; v1(232.63,27.54) C1188.2 ; v1(21.17,10.77) 21.37,10.98 R985.1 ; C744.2 26.52,9.06 v1(26.96,8.61) 26.6,8.61 25.87,7.88 CN12.21 ; PC238.2 65.28,10.6 v1(65.28,11.58) ; v1(23.7,45.85) 24.14,45.41 PC142.1 ; PC9244.1 v1(149.22,50.93) ; PC9296.2 v1(171.08,58.4) ; v1(154.29,29.97) 154.42,29.85 154.42,29.83 154.9,29.35 PC9335.2 PC9333.1 ; v1(117.71,69.38) 116.77,69.38 PC9300.2 ; v1(28.51,66.86) 27.98,67.39 Q59.3 ; Q61.3 126.45,44.89 v1(126.85,45.29) ; v1(119.67,28.91) 120.08,29.31 PC9212.2 ; v1(172.96,58.4) 173.06,58.51 PC9297.2 ; PC9304.2 121.91,67.82 v1(122.42,68.32) ; C712.2 v1(231.94,19.64) ; v1(8.31,55.01) 6.35,53.05 H12.1 5.07,50.5 2.27,47.7 2.27,47.21 v1(2.26,47.2) ; v1(134.65,26.33) 134.68,26.29 135.45,26.29 Q52.3 ; C714.2 224.95,17.06 225.49,17.61 v1(225.64,17.61) Q30.1 ; R921.2 v1(147.13,85.81) ; v1(120.32,13.71) 120.32,14.49 C9375.1 ; Y6.4 113.82,80.91 v1(113.27,80.36) ; C716.2 v1(231.11,18.48) ; v1(264.62,54.89) 264.99,55.26 C681.2 ; PR208.1 v1(146.75,14.86) ; PC9209.1 122.43,49.08 v1(123.3,49.08) PC9203.2 ; C9363.2 14.06,13.03 v1(14.44,13.41) ; R1072.2 217.48,15.92 v1(217.76,15.64) ; C9402.2 v1(157.93,54.59) ; C509.2 v1(171.25,32.26) ; PC81.2 v1(75.67,17.59) ; PC144.2 21.25,45.81 v1(21.25,45.94) ; v1(115.87,85.44) 116.02,85.29 C977.2 ; PC246.2 68.59,7.35 v1(68.22,6.99) ; C9400.2 v1(92.14,145.04) ; v1(108.16,123.85) 107.35,123.03 Q53.3 ; R346.2 277.38,66.55 v1(277.46,66.63) ; v1(242,38.84) 242,39.73 241.62,40.11 U33.4 ; PC9369.1 v1(137.91,44.42) ; R1068.2 v1(181.03,12.2) ; PR430.1 v1(134.38,52.79) ; C9403.2 v1(157.95,55.72) ; PD1.2 v1(58.89,17.53)
  BOTTOM w0.635: JBAT1.5 v3(117.6,8.81)
  vias: v1(0.76,22.97) v1(0.76,21.7) v1(0.76,20.43) v1(0.76,19.16) v1(0.76,17.89) v1(0.76,16.62) v1(0.76,15.35) v1(0.76,14.08) v1(0.76,12.81) v1(0.76,11.54) v1(0.76,10.27) v1(0.76,9) v1(0.76,7.73) v1(0.76,6.46) v1(0.76,5.19) v1(0.76,3.92) v1(0.76,2.65) v1(0.76,1.38) v1(1.3,0.76) v1(1.49,23.68) v1(2.26,45.93) v1(2.26,44.66) v1(2.26,43.39) v1(2.26,42.12) v1(2.26,40.85) v1(2.26,39.58) v1(2.26,38.31) v1(2.26,37.04) v1(2.26,35.77) v1(2.26,34.5) v1(2.26,33.23) v1(2.26,31.96) v1(2.26,30.69) v1(2.26,29.42) v1(2.26,28.15) v1(2.26,26.88) v1(2.26,25.61) v1(2.22,24.52) v1(2.57,0.76) v1(3.84,0.76) v1(4.43,26.52) v1(5.11,0.76) v1(5.27,26.52) v1(6.01,26.52) v1(6.38,0.76) v1(7.46,3.48) v1(8.94,23.29) v1(9.13,55.73) v1(9.59,23.29) v1(10.05,56.57) v1(10.86,57.31) v1(11.46,0.76) v1(11.7,58.12) v1(11.74,21.56) v1(11.99,43.02) v1(11.99,42.36) v1(11.99,41.7) v1(12,43.67) v1(12.26,14.03) v1(12.28,11.87) v1(12.54,58.96) v1(12.73,0.76) v1(12.89,15.27) v1(13.07,59.59) v1(13.11,28.22) v1(13.17,20.27) v1(13.27,52.43) v1(13.5,7.52) v1(13.73,60.3) v1(13.86,28.21) v1(13.99,34.47) v1(14.01,35.12) v1(14.01,33.81) v1(14,0.76) v1(14.42,61.14) v1(14.66,35.09) v1(14.66,34.44) v1(14.66,33.78) v1(15.07,20.97) v1(15.1,61.96) v1(15.18,13.42) v1(15.18,11.33) v1(15.23,15.5) v1(15.27,0.76) v1(15.43,56.75) v1(15.53,7.14) v1(15.67,25.82) v1(15.79,62.87) v1(16.34,25.82) v1(16.42,63.76) v1(16.54,0.76) v1(17.06,64.72) v1(17.51,26.2) v1(17.72,65.74) v1(17.81,0.76) v1(18.3,66.65) v1(18.5,26.3) v1(18.86,67.57) v1(19.19,26.29) v1(19.24,10.78) v1(19.32,68.46) v1(19.85,69.42) v1(20.08,31.42) v1(20.38,70.46) v1(20.84,71.4) v1(21.15,50.47) v1(21.3,72.42) v1(21.65,50.88) v1(21.73,73.49) v1(21.99,54.99) v1(22.15,50.47) v1(22.21,74.53) v1(22.64,75.7) v1(22.65,55.64) v1(22.64,54.99) v1(22.65,50.88) v1(23.1,76.84) v1(23.2,38.33) v1(23.46,77.86) v1(23.73,40.68) v1(23.73,40.04) v1(23.72,39.39) v1(23.72,38.74) v1(23.72,12.91) v1(23.84,78.92) v1(23.81,25.56) v1(23.94,13.84) v1(24.04,26.2) v1(24.17,80.04) v1(24.37,40.99) v1(24.35,40.31) v1(24.36,39.65) v1(24.34,39.01) v1(24.47,81.01) v1(24.78,82.05) v1(25.08,83.19) v1(25.39,84.28) v1(25.62,85.45) v1(25.9,86.62) v1(26.18,88.02) v1(26.32,21.81) v1(26.43,89.29) v1(26.66,90.58) v1(26.86,91.88) v1(26.84,23.73) v1(27.06,93.12) v1(27.03,37.49) v1(27.01,15.38) v1(27.17,14.43) v1(27.24,94.37) v1(27.37,95.79) v1(27.5,97.01) v1(27.62,98.1) v1(27.72,99.42) v1(27.88,101.86) v1(27.8,100.69) v1(27.95,103.05) v1(28.08,106.56) v1(28.08,105.47) v1(28.03,104.3) v1(28.18,110.19) v1(28.16,109.02) v1(28.13,107.8) v1(28.13,83.42) v1(28.12,20.27) v1(28.21,129.75) v1(28.21,128.48) v1(28.21,127.21) v1(28.21,125.94) v1(28.21,124.67) v1(28.21,123.4) v1(28.21,122.13) v1(28.21,120.86) v1(28.21,119.59) v1(28.21,118.32) v1(28.21,117.05) v1(28.23,115.85) v1(28.23,114.58) v1(28.23,113.49) v1(28.21,112.35) v1(28.21,111.28) v1(28.28,17.82) v1(28.43,64.15) v1(28.52,23.21) v1(28.55,21.71) v1(28.64,91.67) v1(28.99,130.26) v1(28.92,15.34) v1(29.11,19.39) v1(29.19,16.93) v1(29.78,87.61) v1(30.26,130.26) v1(31.07,15.35) v1(31.31,19.83) v1(31.36,16.96) v1(31.53,130.26) v1(32.56,20.68) v1(32.8,130.26) v1(34.07,130.26) v1(34.41,20.68) v1(34.65,63.47) v1(34.65,62.82) v1(34.65,62.17) v1(34.65,61.53) v1(34.83,116.53) v1(35.34,130.26) v1(35.49,43.23) v1(35.49,41.04) v1(35.49,39.92) v1(35.49,38.79) v1(35.49,37.64) v1(35.49,36.55) v1(35.49,35.31) v1(35.5,44.1) v1(35.69,56.28) v1(35.69,55.63) v1(35.69,54.98) v1(35.69,54.34) v1(35.69,53.69) v1(35.69,53.04) v1(35.69,52.39) v1(35.69,51.75) v1(35.97,93.66) v1(35.97,93.02) v1(35.98,92.37) v1(35.98,91.72) v1(36.36,88.21) v1(36.39,21.24) v1(36.61,130.26) v1(36.95,94.48) v1(37.03,88.24) v1(37.88,130.26) v1(37.91,123.17) v1(37.91,121.9) v1(38.04,120.5) v1(39.15,130.26) v1(39.4,121.89) v1(39.43,123.17) v1(39.43,120.5) v1(40.42,130.26) v1(40.83,123.17) v1(40.83,121.9) v1(40.83,120.5) v1(41.21,131.07) v1(41.26,49.64) v1(42.28,131.25) v1(43.3,131.53) v1(44.23,131.91) v1(45.23,132.42) v1(46.11,132.97) v1(46.98,133.66) v1(47.84,134.52) v1(48.43,135.23) v1(48.98,136.05) v1(49,97.04) v1(49.2,116.79) v1(49.49,136.96) v1(49.73,123.92) v1(49.74,121.86) v1(49.78,117.66) v1(49.9,137.88) v1(49.84,119.71) v1(50.13,90.83) v1(50.28,139.04) v1(50.56,140.11) v1(50.64,148.65) v1(50.64,147.38) v1(50.64,146.11) v1(50.64,144.84) v1(50.64,143.57) v1(50.64,142.3) v1(50.64,141.03) v1(50.79,149.89) v1(51.17,93.37) v1(51.22,95.81) v1(51.35,151.08) v1(51.65,90.85) v1(51.73,97.68) v1(51.9,99.06) v1(52.64,138.66) v1(52.64,93.86) v1(52.77,144.63) v1(52.79,123.45) v1(52.79,122.8) v1(52.9,100.57) v1(53.19,95.86) v1(53.25,90.06) v1(53.86,92.11) v1(54.06,85.37) v1(54.11,99.06) v1(54.5,114.53) v1(54.7,112.15) v1(55.18,90.29) v1(55.23,116.21) v1(55.31,116.87) v1(56.84,124.08) v1(56.84,123.43) v1(57.32,85.11) v1(57.46,110.31) v1(57.75,140.85) v1(57.72,139.98) v1(58.38,60.94) v1(58.45,85.06) v1(58.46,48.32) v1(58.54,140.82) v1(58.54,139.93) v1(58.54,139.04) v1(58.97,88.9) v1(59.37,140.82) v1(59.37,139.93) v1(59.37,139.04) v1(59.83,152.96) v1(59.94,123.94) v1(60,87.57) v1(60.04,84.86) v1(60.21,140.78) v1(60.21,139.89) v1(60.21,139) v1(60.26,68.69) v1(60.34,68.04) v1(60.63,69.22) v1(60.67,56.06) v1(60.69,55.33) v1(60.69,54.59) v1(60.88,68.49) v1(61.08,140.82) v1(61.08,139.93) v1(61.08,139.04) v1(61.1,152.96) v1(61.12,69.65) v1(61.33,68.97) v1(61.63,55.55) v1(61.61,54.54) v1(61.78,88.41) v1(61.71,87.2) v1(61.74,69.47) v1(61.81,123.32) v1(61.97,126.52) v1(62.12,151.14) v1(62.19,149.92) v1(62.37,152.96) v1(62.47,152.13) v1(62.62,149.05) v1(62.67,126.52) v1(62.61,87.01) v1(62.65,54.51) v1(63.41,148.37) v1(63.77,126.52) v1(63.82,48.14) v1(64.35,148.04) v1(64.86,123.52) v1(65.39,148.11) v1(65.51,123.52) v1(66.28,148.49) v1(66.88,139.98) v1(66.9,140.85) v1(67.04,149.28) v1(67.35,151.36) v1(67.35,150.12) v1(67.69,140.82) v1(67.69,139.93) v1(67.69,139.04) v1(68.23,98.19) v1(68.36,98.93) v1(68.53,140.82) v1(68.53,139.93) v1(68.53,139.04) v1(69.36,140.78) v1(69.36,139.89) v1(69.36,139) v1(69.59,62.13) v1(70.23,140.82) v1(70.23,139.93) v1(70.23,139.04) v1(70.64,92.44) v1(70.73,113.4) v1(71.32,56.17) v1(71.31,55.5) v1(71.72,62.18) v1(72.63,54.36) v1(73.01,60.93) v1(73.95,54.36) v1(74.38,140.85) v1(74.36,139.98) v1(74.92,60.28) v1(75.17,140.82) v1(75.17,139.93) v1(75.17,139.04) v1(76.01,140.82) v1(76.01,139.93) v1(76.01,139.04) v1(76.85,140.78) v1(76.85,139.89) v1(76.85,139) v1(77.25,92.3) v1(77.71,140.82) v1(77.71,139.93) v1(77.71,139.04) v1(78,104.46) v1(78.5,13.94) v1(79.17,13.92) v1(79.82,13.92) v1(80.21,109.81) v1(80.56,13.91) v1(81.55,13.95) v1(82.16,43.26) v1(82.23,87.35) v1(82.33,13.95) v1(83.17,140.85) v1(83.15,140.04) v1(83.25,61.63) v1(83.27,60.74) v1(83.3,43.26) v1(83.43,14.5) v1(83.45,13.86) v1(83.47,13.21) v1(83.99,140.82) v1(83.99,139.93) v1(83.99,139.04) v1(83.9,85.86) v1(84.01,88.52) v1(84.13,14.5) v1(84.15,13.85) v1(84.15,13.2) v1(84.14,12.55) v1(84.37,55.03) v1(84.35,54.36) v1(84.49,43.24) v1(84.67,49.66) v1(84.86,140.82) v1(84.86,139.93) v1(84.86,139.04) v1(85.64,43.24) v1(85.76,140.82) v1(85.76,139.93) v1(85.76,139.04) v1(85.89,62.01) v1(86.06,87.56) v1(86.55,140.82) v1(86.55,139.93) v1(86.55,139.04) v1(86.7,84.44) v1(86.75,89.89) v1(87.68,87.97) v1(88.27,114.38) v1(88.2,4.42) v1(89.31,87.86) v1(89.75,92.7) v1(90.96,100.16) v1(90.98,96.28) v1(91.15,48.29) v1(91.28,91.27) v1(91.43,60.91) v1(91.55,101.44) v1(91.58,93.11) v1(91.62,87.69) v1(92.16,97.75) v1(92.49,92.14) v1(92.55,112.87) v1(93,94.43) v1(93.54,101.43) v1(93.97,99.87) v1(94.17,125.58) v1(95.1,92.42) v1(95.34,99.41) v1(96.74,49.69) v1(99.99,16.99) v1(100.09,141.74) v1(100.06,140.92) v1(100.27,101.83) v1(100.38,102.48) v1(100.64,16.99) v1(100.9,141.71) v1(100.9,140.82) v1(100.9,139.93) v1(100.91,101.78) v1(101.04,102.55) v1(101.64,60.97) v1(101.77,141.71) v1(101.77,140.82) v1(101.77,139.93) v1(101.92,48.42) v1(102.22,97.77) v1(102.68,141.71) v1(102.68,140.82) v1(102.68,139.93) v1(102.89,97.83) v1(102.93,16.97) v1(103.12,97.21) v1(103.47,141.71) v1(103.47,140.82) v1(103.47,139.93) v1(103.59,97.69) v1(103.58,96.76) v1(103.58,16.97) v1(103.69,39.19) v1(104.05,97.23) v1(104.24,16.97) v1(104.59,146.28) v1(104.89,16.97) v1(105.27,39.68) v1(107.26,94.27) v1(107.46,60.33) v1(107.46,59.67) v1(107.98,46.43) v1(107.98,45.77) v1(108.5,54.39) v1(108.5,53.74) v1(109.3,14.37) v1(109.66,20.13) v1(109.94,14.37) v1(110.59,14.37) v1(111.25,21.1) v1(111.24,14.37) v1(111.39,19.45) v1(111.7,145.14) v1(111.7,143.74) v1(111.7,142.22) v1(111.9,14.37) v1(113.09,145.14) v1(113.09,142.22) v1(113.1,143.66) v1(114.62,145.14) v1(114.62,143.62) v1(114.62,142.22) v1(114.76,96.4) v1(114.78,94.31) v1(114.82,93.6) v1(115.84,107.71) v1(115.9,105.29) v1(116.56,24.01) v1(116.7,91.69) v1(116.76,103.5) v1(116.97,97.67) v1(116.99,21.93) v1(117.2,16.53) v1(117.21,24.01) v1(117.64,21.93) v1(117.82,95.65) v1(117.9,90.94) v1(118.33,99.04) v1(118.48,92.01) v1(119.42,100.85) v1(119.72,97.9) v1(120.51,92.08) v1(120.56,89.97) v1(120.98,23.17) v1(121.04,26.47) v1(121.7,26.47) v1(121.63,23.17) v1(121.88,92) v1(122.57,94.9) v1(123.58,94.54) v1(123.65,136.88) v1(123.84,92.98) v1(125.06,93.76) v1(125.41,92.03) v1(125.44,91.27) v1(125.85,24.43) v1(126.11,63.43) v1(126.11,62.54) v1(126.11,61.65) v1(126.3,94.92) v1(126.51,24.43) v1(126.89,63.43) v1(126.89,62.54) v1(126.89,61.65) v1(127.19,24.43) v1(127.8,63.43) v1(127.8,62.54) v1(127.8,61.65) v1(128.58,82.22) v1(128.67,63.43) v1(128.67,62.54) v1(128.67,61.65) v1(128.78,134.63) v1(129.24,82.22) v1(129.48,61.62) v1(129.55,138.62) v1(129.51,62.44) v1(130.42,138.74) v1(130.42,135.41) v1(130.42,131.42) v1(130.43,82.93) v1(131.13,41) v1(131.82,63.43) v1(131.82,62.54) v1(131.82,61.65) v1(132.05,93.77) v1(132.61,63.43) v1(132.61,62.54) v1(132.61,61.65) v1(133.54,131.43) v1(133.52,63.43) v1(133.52,62.54) v1(133.52,61.65) v1(134.35,139.42) v1(134.39,63.43) v1(134.39,62.54) v1(134.39,61.65) v1(135.2,61.62) v1(135.22,62.44) v1(135.95,140.25) v1(136.76,140.26) v1(136.8,134.62) v1(136.79,133.02) v1(137.46,31.37) v1(137.7,136.31) v1(137.72,134.22) v1(137.97,14.29) v1(138.12,31.37) v1(138.62,14.29) v1(139.27,14.29) v1(139.51,51.03) v1(139.51,49.76) v1(139.51,48.49) v1(139.91,14.3) v1(140.53,30.33) v1(140.56,14.3) v1(140.61,139.72) v1(140.62,135.57) v1(140.78,51.03) v1(140.78,49.76) v1(140.78,48.49) v1(141.47,63.43) v1(141.47,62.54) v1(141.47,61.65) v1(141.72,139.71) v1(141.75,135.51) v1(141.92,150.86) v1(142.05,51.03) v1(142.05,49.76) v1(142.05,48.49) v1(142.26,63.43) v1(142.26,62.54) v1(142.26,61.65) v1(143.17,63.43) v1(143.17,62.54) v1(143.17,61.65) v1(144.04,63.43) v1(144.04,62.54) v1(144.04,61.65) v1(144.6,139.95) v1(144.52,132.83) v1(144.63,136.49) v1(144.6,134.24) v1(144.88,83.6) v1(144.88,62.44) v1(144.85,61.62) v1(145.57,137.09) v1(145.52,134.64) v1(145.52,133.04) v1(145.57,83.59) v1(145.83,103.52) v1(146.37,139.44) v1(146.63,81.42) v1(147.04,83.73) v1(147.17,140.24) v1(147.19,63.43) v1(147.19,62.54) v1(147.19,61.65) v1(147.97,139.44) v1(147.98,63.43) v1(147.98,62.54) v1(147.98,61.65) v1(148.4,22.97) v1(148.69,21.84) v1(148.77,135.44) v1(148.76,131.47) v1(148.88,63.43) v1(148.88,62.54) v1(148.88,61.65) v1(149.36,21.83) v1(149.75,63.43) v1(149.75,62.54) v1(149.75,61.65) v1(150.07,138.71) v1(150.59,62.44) v1(150.57,61.62) v1(150.71,87.91) v1(150.83,138.71) v1(151.29,81.11) v1(151.27,25.77) v1(151.64,21.8) v1(151.84,131.41) v1(151.97,135.44) v1(151.92,25.76) v1(152.22,81.11) v1(152.3,21.8) v1(152.77,139.44) v1(152.77,137.84) v1(152.77,137.04) v1(152.89,81.11) v1(152.98,21.8) v1(153.55,134.62) v1(153.55,81.11) v1(153.67,21.82) v1(154.35,138.66) v1(154.41,133.84) v1(155.22,136.24) v1(155.49,26.21) v1(156.09,139.58) v1(156.07,7.61) v1(156.07,6.94) v1(156.12,137.83) v1(156.16,26.21) v1(158.01,21.82) v1(158.26,7.6) v1(158.26,6.94) v1(158.68,30.09) v1(158.72,21.82) v1(159.96,26.75) v1(159.95,23.61) v1(159.98,20.52) v1(160.08,83.67) v1(160.08,80.5) v1(160.08,25.25) v1(160.64,23.61) v1(160.62,20.53) v1(160.7,26.77) v1(160.96,30.13) v1(161.02,7.24) v1(161.1,124.95) v1(161.35,16.11) v1(162.67,82.91) v1(163.01,32.24) v1(163.33,82.91) v1(163.55,48.75) v1(163.55,47.73) v1(163.55,46.71) v1(163.84,117.57) v1(163.99,82.91) v1(164.35,26.79) v1(164.65,82.91) v1(164.85,20.52) v1(165.01,26.77) v1(165.19,66.23) v1(165.2,65.58) v1(165.31,82.91) v1(165.54,20.52) v1(165.84,66.22) v1(165.85,65.58) v1(165.92,116.14) v1(165.92,114.54) v1(165.97,82.91) v1(165.9,73.22) v1(165.9,72.57) v1(165.9,71.93) v1(166.17,117.91) v1(166.72,115.34) v1(167.52,114.54) v1(167.58,102.98) v1(167.7,121.65) v1(167.93,66.62) v1(167.93,65.96) v1(168.01,117.91) v1(168.27,116.14) v1(168.22,67.21) v1(168.58,66.62) v1(168.58,65.96) v1(168.88,67.22) v1(169.12,113.65) v1(169.23,66.62) v1(169.23,65.96) v1(169.46,85.28) v1(169.41,60.74) v1(169.55,67.19) v1(169.88,66.62) v1(169.88,65.96) v1(169.99,102.34) v1(169.98,60.43) v1(170.12,124.31) v1(170.11,85.28) v1(170.44,117.92) v1(170.45,97.94) v1(170.72,116.94) v1(170.72,107.29) v1(170.71,96.99) v1(170.97,46.55) v1(171.12,122.17) v1(171.52,116.14) v1(171.51,88.15) v1(171.62,46.56) v1(171.76,36.7) v1(171.92,117.9) v1(171.92,106.37) v1(172.06,86.37) v1(172.26,122.19) v1(172.27,46.57) v1(172.32,107.29) v1(172.32,96.99) v1(172.44,36.7) v1(172.63,27.97) v1(172.78,32.24) v1(173.11,90.55) v1(173.92,113.68) v1(173.92,108.96) v1(173.92,108.11) v1(174,86.37) v1(174.32,106.37) v1(174.31,97.92) v1(174.38,85.35) v1(174.31,28.73) v1(174.54,123.78) v1(174.68,114.54) v1(174.72,108.89) v1(174.71,96.95) v1(175.22,123.78) v1(175.56,90.59) v1(175.51,87.35) v1(175.52,79.07) v1(175.88,86.38) v1(175.98,122.99) v1(175.92,106.37) v1(176.02,78.59) v1(176.17,98.08) v1(176.2,73.13) v1(176.2,71.79) v1(176.2,70.67) v1(176.34,76.94) v1(176.34,27.79) v1(176.49,78.12) v1(176.72,79.23) v1(176.95,77.66) v1(177.12,108.14) v1(177.52,106.37) v1(177.74,26.83) v1(177.88,67.06) v1(177.92,108.94) v1(177.92,107.34) v1(177.91,88.15) v1(177.95,86.5) v1(178.05,96.95) v1(178.04,64) v1(178.21,61.84) v1(178.5,122.28) v1(178.92,92.24) v1(178.96,89.79) v1(180.1,66.73) v1(181.29,61.65) v1(181.22,59.37) v1(183.58,52.82) v1(183.58,51.85) v1(183.97,44.18) v1(184.01,43.53) v1(185.66,20.19) v1(185.7,17.25) v1(185.7,27.42) v1(186.39,27.42) v1(186.32,20.22) v1(186.37,17.25) v1(186.5,31.12) v1(186.51,12.11) v1(186.51,11.38) v1(187.19,31.12) v1(187.17,12.09) v1(187.17,11.38) v1(188.34,48.91) v1(188.83,48.36) v1(188.84,47.15) v1(188.83,46.41) v1(188.91,4.42) v1(195.8,12.62) v1(195.9,25.25) v1(195.82,11.94) v1(196.16,28.57) v1(196.48,12.62) v1(196.47,11.94) v1(196.66,30.71) v1(196.82,28.57) v1(196.91,26.78) v1(201.78,28.43) v1(202.52,28.43) v1(209.13,28.49) v1(215.75,13.38) v1(216.4,13.37) v1(234.46,22.81) v1(237.77,21.97) v1(243.85,28.99) v1(244.64,28.96) v1(245.28,14.33) v1(246.88,13.64) v1(246.98,19.18) v1(247.66,19.23) v1(248.32,19.21) v1(252.16,28.94) v1(252.67,16.74) v1(252.79,15.22) v1(252.82,28.94) v1(253.43,15.98) v1(254.06,16.74) v1(254.06,15.22) v1(256.66,49.37) v1(256.71,48.72) v1(258.08,50.21) v1(259.35,51.53) v1(260.74,46.78) v1(261.19,47.23) v1(261.18,43.06) v1(261.53,42.45) v1(261.65,47.69) v1(261.99,43.06) v1(264.92,63.21) v1(265.75,42.52) v1(266.06,108.16) v1(266.37,45.84) v1(266.37,44.83) v1(266.88,45.33) v1(267.17,84.54) v1(267.33,90.49) v1(267.39,45.84) v1(267.39,44.83) v1(267.7,86.37) v1(268.14,2.88) v1(268.63,85.22) v1(268.8,73.84) v1(268.81,71.68) v1(269.08,58.48) v1(269.33,103.82) v1(269.38,100.79) v1(269.34,60.53) v1(269.44,106.27) v1(269.43,101.48) v1(269.58,100.16) v1(269.72,95.77) v1(269.74,59.57) v1(269.84,108.27) v1(269.97,103.82) v1(269.96,57.08) v1(270.06,89.41) v1(270.06,88.4) v1(270.06,87.38) v1(270.23,94.54) v1(270.38,95.77) v1(270.82,48.92) v1(271.08,89.41) v1(271.08,88.4) v1(271.08,87.38) v1(271.38,92.54) v1(271.36,60.53) v1(271.39,58.43) v1(271.49,81.89) v1(271.44,45.6) v1(271.44,44.84) v1(272.09,89.41) v1(272.09,88.4) v1(272.09,87.38) v1(272.18,81.86) v1(272.19,81.19) v1(272.15,44.89) v1(272.61,49.65) v1(275.04,112.73) v1(275.76,112.73) v1(277.48,91.85) v1(277.48,91.19) v1(278.02,74.03) v1(278.01,71.82) v2(72.09,125.61) v2(72.56,123.79) v2(73.95,124.43) v2(74.78,125.58) v2(76.57,125.58) v2(78.62,117.91) v2(81.53,117.76) v2(82.94,117.28) v3(24.45,0.87) v3(25.72,0.87) v3(26.99,0.87) v3(28.26,0.87) v3(28.39,26.51) v3(28.39,25.67) v3(28.51,1.88) v3(29.14,26.52) v3(29.14,25.7) v3(29.53,2.9) v3(30.8,2.9) v3(32.07,2.9) v3(33.34,2.9) v3(34.61,2.9) v3(35.44,104.38) v3(35.79,103.7) v3(35.88,2.9) v3(36.19,104.38) v3(36.54,103.7) v3(36.54,102.95) v3(36.54,102.2) v3(36.94,104.38) v3(37.29,103.7) v3(37.29,102.95) v3(37.32,102.18) v3(37.59,105.19) v3(37.69,104.43) v3(38.34,105.19) v3(40.34,2.84) v3(41.16,13.01) v3(41.16,12.25) v3(41.16,11.49) v3(41.61,2.84) v3(42.88,2.84) v3(44.15,2.84) v3(45.42,2.84) v3(46.69,2.84) v3(47.96,2.84) v3(49.19,13) v3(49.19,12.23) v3(49.19,11.47) v3(49.23,2.84) v3(49.95,13) v3(49.95,12.23) v3(49.95,11.47) v3(50.5,2.84) v3(51.77,2.84) v3(53.04,2.84) v3(54.31,2.84) v3(55.58,2.84) v3(56.59,140.62) v3(56.59,139.86) v3(56.85,2.84) v3(58.12,2.84) v3(59.39,2.84) v3(60.66,2.84) v3(61.9,139.83) v3(61.91,139.04) v3(61.93,2.84) v3(62.5,140.55) v3(62.42,136.89) v3(62.42,136) v3(62.42,135.11) v3(63.18,136.89) v3(63.18,136) v3(63.18,135.11) v3(63.2,2.84) v3(63.24,140.63) v3(63.86,140.21) v3(64.46,140.67) v3(64.47,2.84) v3(65.05,140.21) v3(65.09,136.89) v3(65.09,136) v3(65.09,135.11) v3(65.7,140.62) v3(65.74,139.83) v3(65.74,2.84) v3(65.85,136.89) v3(65.85,136) v3(65.85,135.11) v3(67.01,2.84) v3(67.2,152.68) v3(68.28,2.84) v3(68.9,152.92) v3(69.55,2.84) v3(70.17,152.92) v3(70.82,2.84) v3(71.31,140.31) v3(71.31,139.43) v3(71.31,138.66) v3(71.31,137.91) v3(71.44,152.92) v3(72.07,140.31) v3(72.07,139.43) v3(72.07,138.66) v3(72.07,137.91) v3(72.09,2.84) v3(72.71,152.92) v3(72.82,136.87) v3(72.82,136.12) v3(72.82,135.37) v3(73.36,2.84) v3(73.58,136.87) v3(73.58,136.12) v3(73.58,135.37) v3(73.98,152.92) v3(74.63,2.84) v3(75.25,152.92) v3(75.25,146.16) v3(75.9,2.84) v3(76.01,146.16) v3(76.52,152.92) v3(77.17,2.84) v3(77.79,152.92) v3(78.44,2.84) v3(79.06,152.92) v3(79.46,140.62) v3(79.52,137.9) v3(79.71,2.84) v3(80.1,141.05) v3(80.28,137.9) v3(80.33,152.92) v3(80.73,140.62) v3(80.98,2.84) v3(81.04,137.9) v3(81.37,141.05) v3(81.6,152.92) v3(81.68,136.87) v3(81.68,135.98) v3(81.68,135.09) v3(82.08,141.31) v3(82.06,140.52) v3(82.06,139.76) v3(82.25,2.84) v3(82.44,136.87) v3(82.44,135.98) v3(82.44,135.09) v3(82.87,152.92) v3(83.52,2.84) v3(84.14,152.92) v3(84.79,2.84) v3(85.41,152.92) v3(86.06,2.84) v3(86.68,152.92) v3(87.33,2.84) v3(87.49,140.8) v3(87.49,139.91) v3(87.49,139.02) v3(87.95,152.92) v3(88.25,140.82) v3(88.25,139.93) v3(88.25,139.04) v3(88.6,2.84) v3(89.22,152.92) v3(89.87,2.84) v3(90.49,152.92) v3(91.14,2.84) v3(91.76,152.92) v3(91.91,140.58) v3(91.92,139.82) v3(91.92,139.07) v3(91.92,138.32) v3(92.68,140.6) v3(92.68,139.85) v3(92.68,139.1) v3(93.03,152.92) v3(93.33,140.23) v3(94.3,152.92) v3(95.57,152.92) v3(95.9,140.8) v3(95.96,141.56) v3(96.24,140.04) v3(96.66,140.67) v3(96.71,142.25) v3(96.71,141.43) v3(96.84,152.92) v3(97.42,140.7) v3(98.11,152.92) v3(99.38,152.92) v3(100.65,152.92) v3(101.92,152.92) v3(102.77,2.95) v3(103.19,152.92) v3(103.77,147.48) v3(104.04,2.95) v3(104.46,152.92) v3(104.43,141.74) v3(104.41,140.9) v3(104.41,140.01) v3(104.53,147.48) v3(105.29,147.48) v3(105.31,2.95) v3(105.73,152.92) v3(106.55,6.22) v3(107,152.92) v3(107.97,2.94) v3(108.27,152.92) v3(108.22,129.75) v3(108.22,128.98) v3(108.97,129.75) v3(108.97,128.98) v3(109.24,2.94) v3(109.54,152.92) v3(109.72,129.75) v3(109.72,128.98) v3(110.51,2.94) v3(110.81,152.92) v3(111.78,2.94) v3(112.08,152.92) v3(113.05,2.94) v3(113.35,152.92) v3(114.32,2.94) v3(114.62,152.92) v3(115.59,2.94) v3(115.89,152.92) v3(116.86,2.94) v3(117.16,152.92) v3(118.13,2.94) v3(118.43,152.92) v3(119.4,2.94) v3(119.7,152.92) v3(120.6,9.57) v3(120.6,8.81) v3(120.67,2.94) v3(120.97,152.92) v3(121.94,2.94) v3(122.1,9.57) v3(122.1,8.81) v3(122.24,152.92) v3(122.7,36.42) v3(122.7,35.64) v3(123.21,2.94) v3(123.4,34.84) v3(123.47,35.6) v3(123.51,152.92) v3(123.6,9.57) v3(123.6,8.81) v3(124.67,10.06) v3(124.68,9.15) v3(124.78,152.92) v3(125.48,9.15) v3(125.65,6.24) v3(126.05,152.92) v3(126.28,41.43) v3(127.06,41.38) v3(127.02,2.94) v3(127.32,152.92) v3(127.83,41.38) v3(128.29,2.94) v3(128.33,74.04) v3(128.59,152.92) v3(128.59,41.38) v3(128.84,73.41) v3(129.34,74.04) v3(129.56,2.94) v3(129.86,152.92) v3(129.85,73.41) v3(130.36,74.04) v3(130.87,73.41) v3(130.87,63.35) v3(130.87,62.59) v3(130.87,61.7) v3(130.83,2.94) v3(131.13,152.92) v3(132.1,2.94) v3(132.4,152.92) v3(133.37,2.94) v3(133.67,152.92) v3(134.64,2.94) v3(134.94,152.92) v3(134.92,13.53) v3(135.32,67.67) v3(135.32,66.91) v3(135.57,73.39) v3(135.67,13.53) v3(135.91,2.94) v3(136.21,152.92) v3(136.21,69.32) v3(136.4,63.08) v3(136.4,62.32) v3(136.39,61.57) v3(136.46,73.39) v3(136.42,13.53) v3(136.86,67.5) v3(136.86,66.61) v3(137.17,13.53) v3(137.18,2.94) v3(137.22,69.32) v3(137.35,73.39) v3(137.48,152.92) v3(137.59,65.18) v3(137.81,7.49) v3(138.09,64.48) v3(138.24,73.39) v3(138.24,69.32) v3(138.39,65.18) v3(138.45,2.94) v3(138.57,7.49) v3(138.66,61.57) v3(138.75,152.92) v3(138.88,64.48) v3(139.07,6.34) v3(139.13,73.39) v3(139.28,65.18) v3(139.38,33.38) v3(139.55,61.57) v3(139.52,32.63) v3(139.77,64.48) v3(139.72,2.94) v3(139.82,6.33) v3(140.02,152.92) v3(140.1,65.15) v3(140.1,34.87) v3(140.28,35.6) v3(140.27,34.14) v3(140.28,32.63) v3(140.36,33.38) v3(140.57,6.33) v3(140.99,2.94) v3(141.03,32.63) v3(141.12,33.38) v3(141.29,152.92) v3(141.31,6.33) v3(142.09,6.34) v3(142.26,2.94) v3(142.56,152.92) v3(142.84,7.88) v3(142.84,7.13) v3(142.84,6.37) v3(143.53,2.94) v3(143.83,152.92) v3(144.84,73) v3(144.8,2.94) v3(145.61,35.59) v3(145.86,73) v3(146.07,2.94) v3(146.24,63.35) v3(146.24,62.59) v3(146.24,61.7) v3(146.42,35.59) v3(146.88,73) v3(147.34,2.94) v3(147.89,71.86) v3(147.89,70.97) v3(147.89,70.21) v3(148.61,2.94) v3(148.78,71.86) v3(148.78,70.97) v3(148.78,70.21) v3(149.88,2.94) v3(151.15,2.94) v3(152.42,2.94) v3(152.72,152.38) v3(153.05,3.99) v3(153.41,72.55) v3(153.61,150.22) v3(153.61,4.78) v3(153.73,147.68) v3(153.86,61.45) v3(153.86,60.69) v3(153.86,59.92) v3(153.86,59.16) v3(153.99,152.38) v3(154.17,72.55) v3(154.5,146.54) v3(154.62,5.09) v3(154.75,61.45) v3(154.75,60.69) v3(154.75,59.92) v3(154.75,59.16) v3(154.94,72.55) v3(155.26,152.38) v3(155.64,145.9) v3(155.69,72.55) v3(155.64,61.45) v3(155.64,60.69) v3(155.64,59.92) v3(155.64,59.16) v3(155.89,5.09) v3(156.45,72.55) v3(156.53,152.38) v3(156.91,145.65) v3(157.16,5.09) v3(157.62,63.17) v3(157.8,152.38) v3(157.93,145.65) v3(158.06,15.36) v3(158.2,144.63) v3(158.2,143.36) v3(158.2,142.09) v3(158.33,140.7) v3(158.43,5.09) v3(158.59,139.43) v3(158.84,138.28) v3(158.83,15.36) v3(159.35,137.01) v3(159.59,15.36) v3(159.7,5.09) v3(159.86,136) v3(160.35,15.36) v3(160.62,134.98) v3(160.97,5.09) v3(161.11,15.36) v3(161.25,134.22) v3(161.34,11.99) v3(161.34,11.23) v3(161.34,10.47) v3(161.87,15.36) v3(162.09,11.99) v3(162.09,11.23) v3(162.09,10.47) v3(162.24,5.09) v3(162.84,11.99) v3(162.84,11.23) v3(162.84,10.47) v3(163.51,5.09) v3(164.78,5.09) v3(166.05,5.09) v3(166.71,131.09) v3(167.32,5.09) v3(167.98,130.84) v3(168.59,5.09) v3(169.25,130.71) v3(169.86,5.09) v3(170.52,130.71) v3(171.13,5.09) v3(171.79,130.71) v3(172.4,5.09) v3(173.06,130.71) v3(173.67,5.09) v3(174.33,130.71) v3(174.94,5.09) v3(175.6,130.71) v3(176.21,5.09) v3(176.87,130.71) v3(177.48,5.09) v3(178.14,130.71) v3(179.41,130.71) v3(180.68,130.71) v3(180.89,129.42) v3(180.89,128.15) v3(180.89,126.88) v3(180.89,125.61) v3(180.89,124.34) v3(180.89,123.07) v3(180.89,121.8) v3(180.89,120.53) v3(180.89,119.26) v3(180.89,117.99) v3(180.89,116.72) v3(180.89,115.45) v3(180.89,114.18) v3(180.89,112.91) v3(180.89,111.64) v3(180.89,110.37) v3(180.89,109.1) v3(180.89,107.83) v3(180.89,106.56) v3(180.89,105.29) v3(180.89,104.02) v3(180.89,102.75) v3(180.89,101.48) v3(180.89,100.21) v3(180.89,98.94) v3(180.89,97.67) v3(180.89,96.4) v3(180.89,95.13) v3(180.89,93.86) v3(180.89,92.59) v3(181.01,91.32) v3(181.14,90.05) v3(181.27,88.78) v3(181.5,87.51) v3(181.65,86.24) v3(181.78,84.97) v3(182.06,83.7) v3(182.28,82.43) v3(182.64,81.16) v3(182.87,79.89) v3(183.1,78.62) v3(183.43,77.48) v3(183.68,76.21) v3(184.04,74.94) v3(184.44,73.67) v3(184.82,72.4) v3(185.2,71.13) v3(185.59,69.86) v3(186.09,68.59) v3(186.6,67.44) v3(187.11,66.3) v3(187.62,65.16) v3(188.13,64.01) v3(188.33,2.98) v3(188.63,63) v3(189.14,61.98) v3(189.6,2.98) v3(189.65,60.97) v3(189.75,57.43) v3(189.75,56.29) v3(190.01,55.28) v3(190.13,58.58) v3(190.28,59.82) v3(190.51,54.39) v3(190.87,2.98) v3(191.53,53.5) v3(192.14,2.98) v3(192.8,52.86) v3(193.41,2.98) v3(194.07,52.86) v3(194.68,2.98) v3(195.95,2.98) v3(197.22,2.98) v3(198.49,2.98) v3(199.76,2.98) v3(201.03,2.98) v3(202.3,2.98) v3(203.57,2.98) v3(203.67,46.21) v3(204.84,2.98) v3(205.07,45.45) v3(206.11,2.98) v3(206.46,44.68) v3(207.38,2.98) v3(207.86,44.05) v3(208.65,2.98) v3(209.26,43.41) v3(209.92,2.98) v3(210.91,42.78) v3(211.19,2.98) v3(212.31,42.27) v3(212.46,2.98) v3(213.58,41.89) v3(213.73,2.98) v3(215,2.98) v3(215.23,41.51) v3(216.27,2.98) v3(216.88,41.13) v3(217.54,2.98) v3(218.4,40.87) v3(218.81,2.98) v3(219.93,40.62) v3(220.08,2.98) v3(221.35,2.98) v3(221.48,40.42) v3(222.62,2.98) v3(223.13,40.29) v3(223.89,2.98) v3(224.63,40.24) v3(225.16,2.98) v3(226.15,40.24) v3(226.43,2.98) v3(227.7,2.98) v3(227.8,40.24) v3(228.97,2.98) v3(229.45,40.37) v3(230.24,2.98) v3(231.1,40.62) v3(231.51,2.98) v3(232.75,40.87) v3(232.78,2.98) v3(234.05,2.98) v3(234.28,41.13) v3(235.32,2.98) v3(235.93,41.51) v3(236.59,2.98) v3(237.45,41.89) v3(237.86,2.98) v3(238.98,42.4) v3(239.13,2.98) v3(240.4,2.98) v3(240.5,42.91) v3(241.67,2.98) v3(241.9,43.41) v3(242.94,2.98) v3(243.17,44.05) v3(244.21,2.98) v3(244.44,44.68) v3(245.48,2.98) v3(245.71,45.32) v3(246.75,2.98) v3(246.85,45.95) v3(247.99,46.59) v3(248.02,2.98) v3(249.14,47.48) v3(249.29,2.98) v3(250.41,48.37) v3(250.56,2.98) v3(251.55,49.26) v3(251.83,2.98) v3(252.44,49.87) v3(253.1,2.98) v3(253.45,50.91) v3(254.29,51.36) v3(255.56,51.49) v3(256.83,52.03) v3(257.77,53.04) v3(258.23,56.86) v3(258.23,55.81) v3(258.36,54.67) v3(258.86,57.97) v3(259.5,59.24) v3(260.39,60.52) v3(260.64,38.51) v3(260.64,37.24) v3(260.64,35.97) v3(260.64,34.7) v3(260.64,33.43) v3(260.64,32.16) v3(260.9,61.78) v3(261.53,63.17) v3(261.94,38.28) v3(262.04,64.32) v3(262.42,65.46) v3(262.9,101.43) v3(262.93,66.98) v3(263.21,38.28) v3(263.34,109.45) v3(263.34,108.18) v3(263.34,106.91) v3(263.34,105.64) v3(263.34,104.37) v3(263.34,103.1) v3(263.36,7.02) v3(263.44,68.51) v3(263.67,100.54) v3(263.67,3.05) v3(263.94,69.91) v3(264.33,71.18) v3(264.48,38.28) v3(264.58,72.45) v3(264.61,109.45) v3(264.68,99.65) v3(264.63,7.02) v3(264.83,73.84) v3(264.94,3.05) v3(265.06,76.81) v3(265.09,75.49) v3(265.19,97.77) v3(265.19,96.5) v3(265.19,95.23) v3(265.19,93.96) v3(265.19,92.69) v3(265.19,91.42) v3(265.19,90.15) v3(265.19,88.88) v3(265.19,87.61) v3(265.19,86.34) v3(265.19,85.07) v3(265.19,83.8) v3(265.19,82.53) v3(265.19,81.26) v3(265.19,79.86) v3(265.19,78.34) v3(265.44,98.76) v3(265.75,38.28) v3(265.88,109.45) v3(265.9,7.02) v3(265.95,2.67) v3(266.59,1.78) v3(267.15,109.45) v3(267.5,0.89) v3(268.42,109.45) v3(268.77,0.89) v3(269.2,5.71) v3(269.69,109.71) v3(270.04,0.89) v3(270.32,38.28) v3(270.47,5.71) v3(270.83,110.22) v3(271.59,38.28) v3(271.74,5.71) v3(271.84,110.85) v3(272.61,111.61) v3(272.86,38.28) v3(273.01,5.71) v3(273.24,112.5) v3(273.58,1.45) v3(273.62,113.52) v3(273.75,115.68) v3(273.75,114.66) v3(274.13,38.28) v3(274.85,1.45) v3(275.02,115.68) v3(275.4,38.28) v3(276.12,1.45) v3(276.29,115.68) v3(276.3,5.78) v3(276.67,38.28) v3(276.96,44.08) v3(277.08,60.99) v3(277.56,115.68) v3(277.57,5.78) v3(277.94,38.28) v3(278.23,44.08) v3(278.35,60.99) v3(278.83,115.68) v3(278.84,5.78) v3(279.21,38.28) v3(279.5,44.08) v3(279.49,1.1) v3(279.62,60.99) v3(279.93,91.6) v3(280.1,115.68) v3(280.11,5.78) v3(280.48,38.28) v3(280.77,44.08) v3(280.76,1.1) v3(280.89,60.99) v3(281.37,115.68) v3(281.38,5.78) v3(281.43,7.13) v3(281.78,85.25) v3(281.75,38.28) v3(281.93,68.13) v3(281.9,60.48) v3(282.03,44.58) v3(282.28,1.86) v3(282.7,7.13) v3(282.94,68) v3(283.03,85.43) v3(283.02,38.28) v3(283.17,60.48) v3(283.3,44.58) v3(283.69,108.28) v3(283.93,91.92) v3(284.3,85.43) v3(284.21,68) v3(284.29,38.28) v3(284.44,60.48) v3(284.52,44.58) v3(285.03,91.95) v3(285.18,108.31) v3(285.48,68) v3(285.57,85.43) v3(285.56,38.28) v3(286.3,91.95) v3(287,108.28) v3(287.88,2.01) v3(288.76,60.48) v3(288.86,115.68) v3(288.91,44.48) v3(289.15,2.01) v3(289.62,109.2) v3(290.13,115.68) v3(290.13,114.41) v3(290.13,113.14) v3(290.13,111.87) v3(290.13,110.6) v3(290.21,90.9) v3(290.21,89.92) v3(290.21,88.65) v3(290.21,87.38) v3(290.21,86.11) v3(290.23,43.79) v3(290.23,42.52) v3(290.23,41.25) v3(290.23,39.98) v3(290.23,38.71) v3(290.22,6.8) v3(290.44,2.02) v3(290.59,67.49) v3(290.59,66.22) v3(290.59,64.95) v3(290.59,63.68) v3(290.59,62.41) v3(290.59,61.14)
