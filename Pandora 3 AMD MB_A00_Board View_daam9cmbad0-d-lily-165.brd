# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Nets (continued)
N24357816: R1030.2 U205.2(I0)
N24357876: C9367.1 R1031.2 R1032.2 U205.5(+3V)
N24358102: R1034.1 R1035.2 U205.1(I1)
N24499832: PR474.2 PR492.2 PR495.2
N24502919: PR496.1 PU24.35(PGOOD_NB)
N24606322: D5.1(INA) R1038.1
N24670022: R1040.1 R1042.1 R1043.1 R1044.2
N24670249: R201.1 R202.1 R433.2 R1074.2
N24670478: C9366.1 R1045.1 R1046.2 R1075.1 R1076.1
N24672527: C1237.2 Q23.2(G) R1048.1 R1049.1
N24812312: PC9368.1 PR511.1 PU19.2(EN)
N24814069: PR512.1 PU24.20(PGOOD)
N24862121: PR508.2 PU16.20(PGOOD)
N24881921: PQ65.2 PQ66.3 PR457.1
N24881929: PC9299.1 PQ63.1 PQ64.1
N24881935: PC9301.1 PQ67.1 PQ68.1
N24881987: PC9301.2 PQ67.2 PQ68.2 PR461.1 PU30.7(OUTPUT)
N24882598: C9362.1 Q52.2(G) R1055.2
N24882612: C9363.1 Q52.1(S) Q53.2(G) Q54.2(G) Q55.2(G) Q56.2(G) Q57.2(G) Q58.2(G) Q59.2(G) R1054.2
N24882626: Q53.1(S) R1056.2
N24882655: Q54.1(S) R1057.2
N24882676: Q55.1(S) R1058.2
N24882692: Q56.1(S) R1059.2
N24882721: Q57.1(S) R1060.2
N24882750: Q58.1(S) R1061.2
N24882779: Q59.1(S) R1062.2
N24882921: C9364.1 Q60.2(G) R1064.2
N24882931: C9365.1 Q60.1(S) Q61.2(G) R1063.2
N24882949: Q61.1(S) R1065.2
N25130381: CON1.69(PEDET/GND-SATA) R1068.1
N25456866: PC9334.1 PR467.1 PU29.3(ON1)
N25456868: PC9335.1 PR468.2 PU29.5(ON2)
N25456946: PC9337.1 PU29.10(CT2)
N25456948: PC9336.1 PU29.12(CT1)
N25457219: C9372.1 Q62.2(G) R1079.2
N25457225: C9371.1 Q62.1(S) Q63.2(G) R1078.2
N25457247: Q63.1(S) R1077.2
N28035667: Q20.3(C) R350.1
N28035669: Q20.2(B) Q21.3(D)
N28786240: J3.2 R1109.2
N28786247: J3.3 R1108.2
N28786291: J2.2 R1110.1
N28910756: PQ30.2 PR195.1 PR201.1
N28911104: PC9376.1 PR515.2
N30029303: Q8.3 R118.2
N30866543: PQ31.3(C) PR185.2 PR194.2
N30989079: PC84.2 PC85.2 PQ30.3 PQ40.4(G) PQ41.4(G) PR217.1
N30992906: PC242.2 PR235.1
N30999297: PD3.1 PD4.1 PR234.1
N31000343: PC236.1 PR483.2
N31030974: EL14.2 PC229.1 PD2.1(CATHODE) PQ29.3(D) PR193.1
N31030992: PQ29.1(S) PR202.1
N31031004: PQ28.3(COLLECTOR) PQ29.2(G) PR196.1
N31031010: PQ28.2(BASE) PR186.1 PR193.2
N32053427: TP145.1 U18.AU1(SATA_X2)
N32053441: TP144.1 U18.AU2(SATA_X1)
N32250937: TP255.1 U18.BC18(FANIN0/AGPIO84)
N45706464: TP141.1 U18.AP8(USBCLK/25M_48M_OSC)
N47893673: TP133.1 U18.AH9(USB_OC0_L/TRST_L/AGPIO16)
N124462712: PC83.2 PR60.1
N124462714: PC90.1 PD5.1 PD6.2
N124462746: PR204.1 PU2.5(CS2)
N124462831: PR208.2 PU2.1(CS1)
N124462892: PC89.2 PD5.3
N124462894: PC252.2 PD6.3
N124463006: PC249.2 PR225.1
N124463025: PC235.1 PR227.1
N124463039: PC234.2 PR226.2
N134668295: JBAT1.6(BATT_PRES#) PR221.1
N134668551: PQ31.2(B) PQ36.3(C) PR214.2

Pads without a net: CN2 2 3; CN7 13 14; CN9 7 8 9 24 25 27 28 32 34 35 36; CN10 6 16 17 19 20 21 22 23 24 25 26 27 28 29 30 31 32 34 36 38 40 42 44 46 48 50 58 59 60 61 62 65 67; CN11 A4 B4; CN12 1 3 11 12 13; CN16 87 88 91 92 95 96 97 100 101 104 105 162 165 166; CN17 87 88 91 92 95 96 97 100 101 104 105 162 165 166; CON1 5 6 7 8 9 11 12 13 14 15 16 17 18 19 20 22 23 24 25 26 28 29 30 31 32 34 35 36 37 40 42 44 46 48 50 52 53 54 55 56 58 67 68; ESD1 1; H20 1; J1 3; JBAT1 4; NOREF#4 1; NOREF#8 1; NOREF#9 1; NOREF#10 1; NOREF#11 1; NOREF#13 1; PQ45 2; PQ46 2; PQ47 2; PQ48 2; PQ49 2; PQ59 2; PQ60 2; PQ61 2; PQ62 2; PU2 7; PU9 26; PU15 9 13 14; PU17 35; PU21 5; PU23 5; U7 9; U18 A6 A7 AB5 AB6 AB8 AB26 AB29 AC3 AC4 AC32 AC33 AD5 AD8 AD32 AD33 AH1 AJ2 AJ3 AJ30 AJ32 AK2 AL33 AM33 AN8 AN24 AP9 AW9 AY5 B1 B6 B7 BB2 BB4 BB5 BB6 BC2 BC10 C1 C7 C9 D1 D2 D7 D9 E9 E12 E14 E15 F14 G9 H9 J29 K24 K25 K26 K28 K29 L26 L27 L29 M32 M33 N1 N2 N3 N4 N25 N26 N28 N30 N31 N32 N33 P6 P7 P32 R30 R31 R32 R33 T8 T9 W1 W2 Y1 Y2 Y9; U22 AE34 AG34 AJ8 AM19 AM21 AM29 AN34 AP19 AP21 AP23 AP29 AP31 AR23 AR29 AU19 AU21 AU25 AU27 AU31 AV19 AV21 AV23 AV25 AV27 AV29 AV31 AY10 AY11 AY14 AY15 AY16 AY18 AY19 AY20 AY21 AY22 AY24 AY25 AY26 AY27 AY28 AY30 AY31 AY32 AY33 AY34 AY35 AY36 BA10 BA11 BA14 BA15 BA16 BA18 BA19 BA20 BA21 BA22 BA24 BA25 BA26 BA27 BA28 BA30 BA31 BA32 BA33 BA34 BA35 BA36 BA38 E11 H29 J7 J8 K41 L5 N38 R34 R37 R40 R41 T40 T41 U34 U38 U40 U41 V40 V41; U28 7 9 22 23; U206 3; U207 3; VRAM1 A5 U5; VRAM2 A5 U5; VRAM3 A5 U5; VRAM4 A5 U5

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 5196 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 245 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 1344 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.775V_SUS_PWRGD: length 2.6
  BOTTOM w0.381: R1042.2 127.55,53.6 127.32,53.83 v1(127.12,53.83) 126.71,53.83 126.36,53.48 PU20.3
1.5V_SUS_PWRGD: length 2.4
  BOTTOM w0.381: PU21.1 122.49,31.3 122.11,30.92 R1043.2
1.05V_SUS_PWRGD: length 275
  TOP w0.114: v1(30.4,72.94) 30.63,73.17 30.63,75.03 32.9,77.31 32.9,84.9 29.89,87.91 29.89,96 30.36,96.47 30.36,108.05 31.25,108.94 v1(31.69,108.94) PR514.2 v1(33.97,108.94)
  IN3 w0.127: v1(126.07,47.11) 126.07,47.86 123.48,50.45 120.06,50.45 117.28,53.22 116.2,53.22 115.46,52.48 115.46,38.9 110.43,33.88 96.1,33.88 93.78,31.56 61.25,31.56 60.53,30.84 56.78,30.84 53.79,27.84 53.79,24.44 51.85,22.5 51.85,21.41 38.38,7.94 26.07,7.94 24.75,6.62 13.76,6.62 13.04,7.33 13.04,10.52 12.51,11.05 11.63,11.05 10.8,10.22 9.62,10.22 9.05,10.79 9.05,21.05 10.72,22.72 11.92,22.72 16.51,27.31 24.39,27.31 28.43,31.35 28.43,41.63 27.96,42.11 27.96,66.94 28.94,67.93 29.87,67.93 30.55,68.6 30.55,72.79 v1(30.4,72.94)
  BOTTOM w0.114: PR510.2 126.99,47.75 126.36,47.11 v1(126.07,47.11) ; PU18.1 v1(33.97,108.94)
1.8V_GFX_EN: length 10.9
  BOTTOM w0.254: PR467.2 v1(154.58,32.38) 155.55,33.35 155.55,34.76 155.09,35.22 155.09,38.31 U203.4 156.41,39.11 156.58,39.29 156.58,40.01 R1026.1
1.8V_SUS_PWRGD: length 45.4
  IN2 w0.254: v1(151.49,34.04) 151.49,31.71 149.88,30.09 132.97,30.09 131.86,31.2 131.86,31.63 130.98,32.52 126.08,32.52 v1(125.65,32.95)
  BOTTOM w0.254: PR373.2 121.59,29.19 122.62,29.19 125.13,31.7 125.13,32.32 125.65,32.84 v1(125.65,32.95) ; v1(151.49,34.04) 151.49,34.09 v1(150.62,34.97) 149.46,36.13 147.44,36.13 147.23,36.34 PR513.2 146.86,37.07 145.66,37.07 145.15,36.56 PU19.1
2.5V_SUS_PWRGD: length 18.2
  BOTTOM w0.114: PU23.1 19.98,51.03 20.13,50.88 PR498.2 20.53,49.37 27,49.37 v1(30.48,45.89) 30.68,45.68 30.68,42.86 30.39,42.57 D50.1
3.3V_ALW_ON: length 7.1
  BOTTOM w0.114: R228.1 R448.1 231.93,13.34 v1(232.25,13.34) 232.77,13.34 233.24,13.81 C725.1 234.01,14.71 234.58,15.28 234.58,15.7 234.45,15.84 Q31.3
3.3V_BST: length 2.3
  BOTTOM w0.203: PU2.9 v1(152.24,10.12)
  BOTTOM w0.508: PR226.1 152.85,10.12 v1(152.24,10.12)
3.3V_DH: length 18.8
  TOP w0.762: v3(153.69,8.57) 162.45,8.57 163.39,7.63 TP42.1 167.28,7.63 v3(167.79,7.12)
  BOTTOM w0.203: PU2.10 151.59,9.72 151.78,9.53
  BOTTOM w0.33: PQ39.4 167.73,7.06 v3(167.79,7.12)
  BOTTOM w0.635: v3(153.69,8.57) 152.74,8.57 151.78,9.53
3.3V_DL: length 16.8
  TOP w0.889: v3(161.59,12.88) 160.97,12.88 158.84,10.75 v1(157.09,10.75) 153.99,10.75 152.05,8.82 v3(152.05,7.73)
  BOTTOM w0.203: PU2.11 150.47,8.64 150.61,8.5 151,8.5
  BOTTOM w0.33: PQ35.4 163.16,12.74 163.01,12.88 TP99.1
  BOTTOM w0.508: 151,8.5 151.28,8.5 v3(152.05,7.73)
  BOTTOM w0.635: TP99.1 v3(161.59,12.88)
3.3V_SW: length 18.7
  TOP w0.762: v3(167.78,13.26) 166.84,14.21 160.22,14.21 158.18,12.18 v1(155.54,12.18) v3(153.86,12.18)
  BOTTOM w0.203: 152.15,10.97 151.7,10.52 PU2.8
  BOTTOM w0.635: PC234.1 153.24,11.33 152.51,11.33 152.15,10.97
  BOTTOM w0.762: PC234.1 153.26,11.57 v3(153.86,12.18)
3V3IN:
  vias: v1(249.92,16.34)
3V_GFX_EN: length 9.1
  BOTTOM w0.254: PR468.1 v1(156.05,32.74) 156.05,34.28 157.12,35.35 157.56,35.35 158.77,35.35 159.08,35.65 R1023.1 159.08,37.59 U202.4
5V_BST: length 4.8
  BOTTOM w0.203: PU2.17 147.73,10.12 147.38,9.77
  BOTTOM w0.508: PR227.2 147.98,6.75 147.38,7.35 147.38,7.98 147.63,8.23 v1(147.64,8.23) 147.38,8.49 147.38,9.77
5V_DH: length 15.7
  TOP w0.762: v3(148.07,8.91) 147.19,9.79 147.19,11.26 145.71,12.74 138.17,12.74 TP100.1 v3(136.21,11.98)
  BOTTOM w0.203: v3(148.07,8.91) 147.89,9.09 147.89,9.61 148.01,9.72 PU2.16
5V_DL: length 8.7
  TOP w1.016: 148.3,6.54 147.88,6.54 146.38,5.05 141.84,5.05
  BOTTOM w0.203: v3(148.08,7.71) 148.39,8.01 148.39,8.11 148.87,8.59 PU2.15
  vias: v3(140.06,5.5) v3(140.82,5.5)
5V_SW: length 16.6
  TOP w0.508: v1(135.17,8.09) 135.6,8.52 PC83.1
  TOP w0.762: v3(145.76,9.98) 144.65,11.09 v1(143.6,11.09) 139,11.09 137.62,9.71 v3(134.16,9.71)
  BOTTOM w0.203: PU2.18 147.14,10.52 146.98,10.36
  BOTTOM w0.508: 146.98,10.36 PC235.2 v3(145.76,9.98)
5388VDDQSNS: length 25
  TOP w0.254: SJ7.2 25.92,29.85 25.92,30.26 26.43,30.77 27.81,30.77 28.49,31.45 28.49,40.46 24.77,44.18 v1(21.6,44.18) 20.06,44.18 19.67,43.78 v1(19.67,43.76)
  BOTTOM w0.203: PU9.2 20.02,43.12 19.67,43.47 v1(19.67,43.76)
5388VLDOIN: length 23.5
  TOP w0.889: v3(17.45,41.61) 18.68,42.84 24.16,42.84 25.92,41.08 25.92,38.51 24.73,37.32 v1(24.73,32.09)
  BOTTOM w0.203: 18.23,39.94 18.5,39.94 18.61,40.04 PU9.28
  BOTTOM w0.508: v3(17.45,41.61) PC9230.1 16.54,41.26 17.87,39.94 18.23,39.94
+1.5V_RTC: length 250.9
  TOP w0.381: v1(200.86,7.92) 200.86,7.93 200.51,8.29 195.34,8.29 189.27,14.36 185.05,14.36 180.23,19.18 159.46,19.18 158.14,20.5 132.65,20.5 131.23,21.92 128.08,21.92 125.84,19.68 113.81,19.68 112.95,18.83 108.75,18.83 106.01,21.57 v1(105.98,21.57) 105.49,22.06 103.17,22.06 102.04,23.19 102.04,28.75 102.89,29.6 107.69,29.6 108.6,30.51 108.6,35.68 110.04,37.12 110.04,39.15 111.9,41.01 111.9,44.29 111.15,45.04 111.15,47.82 111.9,48.56 111.9,57.57 111.15,58.32 111.15,66.87 109.16,68.87 109.16,69.57 103.13,75.59 103.13,93.56 105.98,96.41 105.98,107.62 R621.2
  TOP w0.508: U21.1 243.34,10.13 243.07,9.87 C874.1 241.26,9.87 240.93,9.54 v1(240.93,8.87)
  BOTTOM w0.508: v1(200.86,7.92) 202.33,6.46 238.52,6.46 v1(240.93,8.87)
+1.05V_RUN: length 56.9
  TOP w0.381: R461.2 68.9,112.99 68.9,114.02 69.54,114.67 69.54,116.13 70.39,116.98 70.39,117.9 72.07,119.59 73.76,119.59 75.13,120.96 75.13,120.96 v2(75.13,122) 75.13,122.25 75.99,123.11 82.62,123.11 82.94,122.79 85.08,122.79 85.33,122.53 85.33,121.95 85.67,121.62 85.69,121.62 85.93,121.38 v1(89.6,121.38)
  IN2 w0.381: v1(99.79,103) 99.79,103.05 97.74,105.1 97.74,113.89 96.7,114.93 96.7,118.95 95.3,120.36 v1(95.3,121.21)
  BOTTOM w0.381: v2(75.13,122) 75.31,121.82 R1082.1 ; v1(95.3,121.21) 95.3,120.84 95.09,120.63 93.79,120.63 92.69,121.73 90.58,121.73 90.23,121.39 R576.2 89.7,121.27 v1(89.6,121.38)
  vias: v1(31.89,72.14) v1(84.08,101.75) v1(84.17,102.6) v1(84.85,101.73) v1(84.95,102.59) v1(85.64,101.72) v1(85.76,102.59) v1(101.79,99.75) v1(102.83,99.7) v1(103.82,99.7)
+1.05V_SUS: length 156.1
  TOP w0.381: R625.1 83.56,108.83 v2(84.23,108.83)
  TOP w0.508: v3(119.73,51.68) 119.01,52.39 119.01,55.63 118.35,56.3 118.35,61.04 116.58,62.81 116.58,69.89 108.6,77.86 108.6,89.05 111.88,92.33 111.88,116.1 v1(111.68,116.31) 111.5,116.31 v1(105.81,122) 105.48,122.33 91.2,122.33 90.87,122.66 90.53,123 88.46,123 88.1,123.36 83.17,123.36 82.86,123.68 75.53,123.68 74.52,122.67 v2(74.52,122)
  IN2 w0.508: v1(111.68,116.31) 104.35,108.98 104.35,108.51 103.44,107.6 103.44,106.61 103.8,106.25 103.8,103.18 v1(103.44,102.82)
  IN4 w0.381: v2(84.23,108.83) 86.92,108.83 87.25,108.5 90.43,108.5 91.66,107.26 92.58,107.26 93.3,107.98 95.64,107.98 96.06,107.56 99.41,107.56 99.91,107.07 99.91,105.16 100.9,104.16 102.89,104.16 103.51,103.55 103.51,102.89 v1(103.44,102.82)
  BOTTOM w0.254: PR494.2 31.62,94.79
  BOTTOM w0.381: R588.1 74.35,121.67 74.52,121.84 v2(74.52,122)
  vias: v1(33.59,90.78) v3(34.54,86.2) v3(34.54,82.52) v3(35.3,86.2) v3(35.3,82.52) v3(121.71,51.25) v3(122.24,51.91)
+1.5V_SUS: length 366.7
  TOP w0.254: CN5.34 v1(23.07,7.8)
  TOP w0.381: v1(97.22,18.93) 97.19,18.93 95.09,21.04 95.09,23.98 101.55,30.45 107.42,30.45 107.71,30.74 107.71,35.85 109.29,37.43 109.29,39.65 110.98,41.34 v3(110.98,43.13) 110.72,43.13 110.4,43.45 110.4,48.13 111.15,48.87 111.15,57.26 110.4,58.01 110.4,66.56 108.41,68.56 108.41,69.26 102.38,75.29 102.38,93.87 105.23,96.72 105.23,103.02 104.34,103.9 v1(100.27,103.9) 100,103.9 99.76,103.66 97.28,103.66 95.74,102.13 89.92,102.13 R618.1
  IN1 w0.508: v1(23.07,7.8) 23.51,8.23 25.11,8.23 25.59,7.75 40.93,7.75 47.84,14.66 52.25,14.66 57.22,19.63 96.52,19.63 v1(97.22,18.93)
  IN2 w0.508: v3(110.98,43.13) 117.04,43.13 v3(118.94,45.03)
  IN2 w1.524: 125.65,43.32 128.35,43.32 131.02,40.65 140.93,40.65 142.86,42.59 176.71,42.59 181.7,37.6 186.83,37.6 189.35,35.08 245.94,35.08 260.56,49.71 260.56,52.41 262.55,54.4 262.55,56.95
  BOTTOM w0.508: PU21.6 119.95,39.28 ; v1(23.07,7.8) 22.84,8.03 C745.1
  BOTTOM w0.762: 119.95,39.28 119.31,39.93 PR374.1 118.39,40.37 v1(118.1,40.65) 117.79,40.96 PC9214.1
  vias: v1(261.61,58.88) v1(262.24,59.82) v1(262.62,58.86) v1(262.73,60.48) v3(119.72,45.01) v3(120.54,45.01) v3(121.29,45.01) v3(122.04,45.01)
+1.5V_VDD: length 2.8
  TOP w0.191: U5.12 274.3,65.25 274.54,65.49 275.29,65.49 C415.1
  TOP w0.381: C415.1 275.36,65.02 v1(274.88,65.02)
  vias: v1(266.59,70.31) v1(266.72,62.19) v1(266.74,61.53) v1(267.5,63.86) v1(275.76,70.06) v1(275.78,69.4)
+1.8V_GFX: length 127.6
  TOP w0.381: R641.2 R642.2 117.43,107.16 117.79,106.79 v1(118.28,106.79)
  IN2 w0.254: v1(161.76,37.17) 160.74,38.18 153.71,38.18 152.79,37.26 v1(152.79,37.23)
  IN3 w0.254: v1(161.76,37.17) 160.18,35.58 157.28,35.58 156.61,34.92
  IN3 w1.016: 121.79,78.33 122.78,77.33 122.78,74.23 121.24,72.69 121.24,57.43 129.58,49.08 129.58,43.37 131.84,41.11 139.79,41.11 140.12,41.44 140.12,43.11 v1(140.83,43.82) 142.07,42.58 144.24,42.58 145.48,43.82 148.66,43.82 151.48,41 151.48,40.05 156.61,34.92 156.61,32.46 157.06,32.02 157.06,24.69 155.22,22.86 150.74,22.86
  BOTTOM w0.254: v1(152.79,37.23) 152.71,37.15 R1030.1 ; v1(161.76,37.17) 161.74,37.14 161.74,36.52 R1021.1
  BOTTOM w0.305: 144.05,95.75 U22.AM15 ; U22.AP15 144.02,94.98 v1(144.33,94.98) 143.9,94.55 U22.AR15
  BOTTOM w0.381: R951.2 v1(120.99,108.44) R953.2 ; v1(118.28,106.79) 118.54,106.79 118.61,106.72 119.87,106.72 120.34,107.19 R955.2 121.04,107.29 v1(121.07,107.27) 121.1,107.29 R957.2 ; v1(121.04,106.15) 120.86,105.97 R959.2
  BOTTOM w0.4: U22.AP15 144.05,95.75 v1(144.2,95.75) 144.6,96.15 U22.AM13 ; U22.AM15 144.08,96.57 v1(144.2,96.57)
  BOTTOM w0.508: v1(120.16,79.95) C979.2 120.51,80.69 119.99,80.69 119.8,80.88 R763.2 ; PR411.2 140.55,44.1 v1(140.83,43.82) ; v1(145.61,85.84) 145.99,86.23 R705.2 ; R765.2 v1(122.49,81.63)
  vias: v1(121.03,110.63) v1(122.33,79.59) v1(122.48,78.96) v1(142.74,87.44) v1(142.74,86.78) v1(143.41,87.45) v1(143.41,86.79) v1(144.77,96.07) v1(150.06,21.82) v1(150.76,21.82)
+1.8V_RUN: length 551.3
  TOP w0.254: 170.37,41.64 Q9.2 Q9.5
  TOP w0.279: Q33.5 41.62,99.67 41.31,99.37 40.5,99.37 40.32,99.55 v1(40.07,99.55) ; Q33.2 41.62,101.83 41.87,101.58 42.61,101.58 v1(42.91,101.88) ; v1(44.8,104.02) 44.8,103.45 44.39,103.04 Q44.2 Q44.5
  TOP w0.381: PR268.1 119.11,143.36 v1(119.44,143.69) 119.5,143.74 120.34,143.74 C9394.1 ; C753.2 52.4,23.28 52.85,22.84 U19.5 54.12,22.84 54.25,22.96 ; R479.2 45.58,98.6 v1(45.58,99.19) ; R599.2 v1(139.38,149.2)
  TOP w0.508: 53.16,24.97 53.16,26.1 53.15,26.1 53.15,26.45 52.69,26.91 52.69,27.41 52.33,27.77 50.82,27.77 50.46,27.41 R510.2 R509.2 49.86,28.91 48.1,30.67 40.17,30.67 v1(38.89,29.39) 38.04,28.54 38.04,27.29 R508.2 38.66,26.91 38.88,27.13 38.88,28.4 39.57,29.1 40.38,29.1 40.48,29.19 CN13.1 ; 53.16,24.97 53.96,25.78 ; 53.16,24.97 51.91,24.97 R512.2 51.89,24.73 51.53,24.37 50.77,24.37 50.14,25 R514.1 ; R516.1 50.31,23.28 C753.2 ; 50.68,20.92 53.25,20.92 54.25,21.92 54.25,25.49 53.96,25.78 ; 50.68,20.92 49.86,21.75 R520.2 ; 50.68,20.92 50.68,19.47 48.22,17.01 44.05,17.01 43.3,17.76 CN13.19 ; v1(154.61,34.19) 155.14,34.72 C9392.1 155.14,37.45 157.42,39.73 v1(158.13,39.73) 158.69,39.73 159.79,38.62 160.89,38.62 164.79,42.52 C9393.1 170.11,41.9 170.37,41.64 ; 53.96,25.78 53.96,28.13 58.75,32.92 61.21,32.92 74.69,19.44 93.69,19.44 95.97,17.15 98.5,17.15 99.86,15.79 121.05,15.79 v1(121.65,16.39) ; U20.8 R601.2 C770.1 124.28,144.37 124.77,143.87 v1(125.29,143.87) 138.37,143.87 v1(138.76,144.26) R600.1 ; R467.1 50.61,105.39
  IN1 w0.508: v1(38.89,29.39) 35.97,32.32 34.59,32.32 32,34.91 32,40.63 30.41,42.21 30.41,57.09 29.99,57.51 29.99,62.7 34.71,67.42 34.71,75.51 33.76,76.46 33.76,80.22 32.47,81.51 32.47,87.21 35.53,90.27 36.6,90.27 37.52,91.19 37.52,92.05 38.9,93.44 38.9,99.37 39.08,99.55 v1(40.07,99.55)
  IN2 w0.508: v1(98.55,115.26) 98.55,114.65 98.86,114.33 v1(98.86,111.58)
  IN3 w0.508: v1(98.86,111.58) 102.93,107.51 102.93,104.22 102.28,103.57 102.28,101.95 103.06,101.17 103.88,101.17 104.7,100.35 104.7,96.96 104.03,96.29 104.03,84.97 106.08,82.91 106.08,70.08 108.18,67.99 108.18,56.92 107.84,56.58 107.84,52.18 108.83,51.18 108.83,48.22 107.33,46.72 107.33,45.09 106.23,43.99 98.73,43.99 97.85,43.11 88.41,43.11 85.18,39.88 55.17,39.88 45.67,30.38 39.88,30.38 v1(38.89,29.39) ; 122.48,143.73 125.15,143.73 v1(125.29,143.87) ; 122.48,143.73 121.7,142.95 121.7,134.85 119.06,132.21 116.9,132.21 114.49,129.8 114.49,128.01 111.78,125.3 111.78,121.11 v1(112.33,120.56) ; 122.48,143.73 121.63,144.58 120.33,144.58 v1(119.44,143.69) ; v1(44.8,104.02) 40.89,107.93 40.28,107.93 37.57,110.64 37.57,112.09 35.8,113.86 35.8,116.13 36.31,116.64 37.71,116.64 38.01,116.95 v1(38.34,116.95)
  IN4 w0.508: v1(138.76,144.26) 140.25,145.75 140.25,148.34 v1(139.38,149.2)
  BOTTOM w0.203: C9389.1 39.1,117.85 39.2,117.94 PU17.6
  BOTTOM w0.254: C9389.1 38.73,117.34 v1(38.34,116.95)
  BOTTOM w0.279: Q32.2 v1(40.07,99.55) Q32.5
  BOTTOM w0.305: U202.5 158.36,39.06 158.13,39.3 v1(158.13,39.73)
  BOTTOM w0.381: R480.2 v1(49.71,109) R500.2 ; R471.1 v1(49.71,107.78) ; v1(44.8,104.02) 45.19,104.02 45.57,103.65 R475.1 45.9,103.68 R498.2 R477.2 R501.2 ; R496.2 v1(47.57,111.61) ; v1(49.65,104.78) 50.42,104.78 R473.1 ; R474.1 v1(49.71,103.45) ; R554.2 98.37,111.09 v1(98.86,111.58) 98.37,112.07 R555.2
  BOTTOM w0.508: 150.46,28.83 150.46,29.77 153.21,32.53 153.21,33.17 C9391.1 153.21,33.75 153.66,34.19 v1(154.61,34.19) ; v1(121.65,16.39) 121.65,17.77 125.34,21.47 129.64,21.47 131.62,23.45 ; v1(112.33,120.56) 110.79,119.03 99.59,119.03 98.37,117.81 R557.2 R556.2 98.37,115.96 98.55,115.79 v1(98.55,115.26)
  vias: v1(44.03,101.88) v1(81.71,103.25) v1(82.37,103.26)
+1.8V_SUS: length 403
  TOP w0.305: v2(82.92,109.96) 83.42,109.96 83.83,109.55 84.57,109.55 84.8,109.31 86.97,109.31 87.34,109.68 88.06,109.68 C880.1 C881.1 89.66,109.43 91.15,110.93 99.22,110.93 R523.1
  TOP w0.381: R1080.1 263.37,49.7 v1(262.62,48.96)
  IN1 w0.508: v1(19.98,11.13) 17.8,13.31 v1(17.8,13.61) 17.8,13.87 19.33,15.4 v1(19.33,17.04) 18.29,18.08 18.29,20.46 v1(18.01,20.74) 18.01,22.02 21,25.01 v1(21,25.58) 21,26.3 21.93,27.23 24.63,27.23 27.32,29.93 27.32,31.65 v1(27.34,31.68)
  IN2 w0.381: v1(132.78,33.56) 133.21,33.56 134.79,31.98 145.78,31.98 146.72,32.92 146.72,34.47 148.91,36.66 150.79,36.66 154.08,33.36 174.54,33.36 175.01,32.89 224.71,32.89 226.54,31.05 227.31,31.05 230.24,33.99 246.39,33.99 261.35,48.96 v1(262.62,48.96)
  IN2 w0.508: v1(27.34,31.68) 27.34,31.69 27.58,31.93 58.26,31.93 59.55,30.64 100.95,30.64 102.93,32.62 112.71,32.62 114.64,34.55 117.39,34.55
  IN2 w1.016: 129.3,31.73 125.54,31.73 123.48,33.79 119.44,33.79
  IN4 w0.381: v2(82.92,109.96) 83.46,109.41 87.12,109.41 87.39,109.68 88.47,109.68 88.66,109.5 95.18,109.5 96.6,108.08 99.63,108.08 100.7,107.02 100.7,105.12 101.06,104.76 103.04,104.76 104.03,103.76 104.03,102.76 105.7,101.1 105.7,86.18 108.84,83.03 108.84,67.91 110,66.75 110,49.32 109.2,48.52 109.2,42.58 117.73,34.04 v1(117.87,34.04)
  BOTTOM w0.203: 19.58,15.33 19.7,15.33 19.71,15.34 ; 19.74,21.45 19.6,21.45
  BOTTOM w0.254: 19.58,15.33 18.71,15.33 C1225.1 18.3,15.14 17.8,14.64 17.8,13.62 v1(17.8,13.61) ; 19.6,21.45 18.75,21.45 C1227.2 18.72,21.45 v1(18.01,20.74)
  BOTTOM w0.381: v1(21,25.58) 21.31,25.27 R983.2 ; R988.2 20.36,11.5 v1(19.98,11.13) ; v1(19.33,17.04) 19.59,17.3 R987.2 R984.2
  vias: v1(126.05,37.24) v1(130.21,31.96) v1(130.8,31.65) v3(126.94,37.44) v3(127.95,37.44) v3(128.97,37.44) v3(129.86,37.44)
+1.35V_GFX: length 220
  TOP w0.254: C1085.1 166.69,105.97 v1(167.09,106.37)
  TOP w0.305: v1(146.34,130.65) 146.51,130.47 C1048.2 146.51,129.18 v1(146.37,129.04)
  TOP w0.381: v1(176.89,86.33) 176.89,86.09 177.14,85.84 v1(177.79,85.84) 178.3,85.84 C1092.1 ; C1055.2 125.37,137.42 v1(126.18,137.42) ; C1054.2 165.46,98.53 v1(165.46,97.92) ; C1096.1 144.42,137.33 v1(144.62,137.13) ; v1(152.77,138.64) 152.55,138.42 C1090.1 ; C1003.1 147.17,102.4 v1(146.84,102.73) 146.34,102.23 C1002.1 ; v1(165.16,117.91) 165.01,117.75 R798.1 ; C1045.2 165.85,95.29 v1(165.91,95.35) ; v1(152.72,130.64) 152.55,130.47 C1052.2 ; R770.1 173.29,111.65 v1(173.79,111.14) 173.79,111.26 R774.1 ; C1047.2 129.85,130.32 v1(129.58,130.6) ; C1066.1 172.78,97.98 v1(172.71,97.92) ; v1(147.97,138.64) 148.01,138.6 148.01,138.27 147.88,138.15 C1041.2 ; v1(146.05,98.25) 146.19,98.38 C1015.1 ; R799.1 176.22,92.73 R771.1 ; v1(177.15,98.05) 177.16,98.06 177.16,98.4 C1076.1 ; v1(156.07,138.5) 156.81,138.5 R805.1 ; v1(134.35,138.62) 134.06,138.33 C1098.1 133.13,138.42 R788.1 ; v1(176.31,89.75) 176.32,89.76 C1059.2 ; v1(144.6,135.84) 144.29,135.53 C1084.1 ; v1(177.11,96.15) 177,96.26 C1064.1 ; v1(154.42,134.64) 154.83,134.23 C1057.2 ; v1(146.37,137.84) 146.33,137.88 C1043.2 ; v1(174.94,86.36) 174.94,85.93 175.47,85.41 C1040.2 ; v1(137.7,135.01) 137.71,135.01 138.45,135.01 C1056.2 ; v1(166.67,89.75) 166.67,90.35 C1082.1 ; C1012.1 146.45,100.26 v1(146.77,100.57) ; v1(126.18,129.33) 126.1,129.41 C1083.1 ; v1(130.35,136.22) 130.33,136.24 C1079.1 ; C1053.2 172.65,106.3 v1(172.72,106.37) ; C1046.2 173.51,98.38 v1(173.51,97.92) ; v1(174.58,113.67) 175.23,113.03 C1044.2 ; C1080.1 144.81,129.2 v1(144.6,129.4) ; v1(176.32,109.74) 176.33,109.75 C1087.1 176.33,111.51 R790.1 ; C1016.1 145.83,108.05 v1(146.38,108.61) 146.6,108.82 C1017.1 ; v1(141.19,132.9) 140.17,132.9 139.81,132.54 R664.1 ; v1(156.19,132.08) 156.21,132.1 C1062.1 ; R771.1 176.21,94.45 v1(176.31,94.55) ; R771.1 R775.1 ; v1(173.92,115.34) 173.9,115.32 C1063.1 173.29,114.71 v1(173.12,114.54) ; C1005.1 v1(144.85,107.39) ; v1(134.46,108.55) 134.19,108.82 C1004.1 ; R787.2 169.75,98.75 v1(169.75,97.96) ; v1(167.16,86.38) 166.93,86.16 C1086.1 ; v1(140.74,108.56) 141.3,109.11 C1013.1 C1014.1 ; v1(137.83,137.2) 137.84,137.18 C1042.2 ; v1(126.18,139.02) 125.51,139.7 C1071.1 ; v1(167.09,106.37) 167.69,105.78 C1060.2 ; v1(137.72,138.96) 137.75,138.99 138.43,138.99 C1051.2 ; C1073.1 176.43,117.63 v1(176.28,117.77) ; v1(173.92,109.78) 173.92,110.24 C1081.1 ; v1(174.97,106.37) 174.97,106.09 174.68,105.8 C1058.2 ; v1(162.71,89.2) 162.71,89.21 R791.1 ; C1061.1 126.5,135.82 v1(126.18,135.82) ; R768.1 R772.1 132.12,136.18 132.74,136.79 C1075.1 133.78,136.79 v1(134.35,136.22) ; C1072.1 144.53,139.09 v1(144.6,139.01) ; R789.1 152.25,128.56 v1(152.72,129.04) ; v1(168.31,89.79) 168.31,90.31 C1050.2
  TOP w0.4: v1(175.27,117.9) 175.59,117.9 176.2,118.51 C1091.1 ; 134.4,128.27 134.4,129.03 C1069.1 ; 134.4,128.27 v1(134.35,128.22) ; 134.4,128.27 134.45,128.22 v1(135.15,128.22) ; C1078.1 138.24,131.92 137.94,131.92 v1(137.7,132.16) ; v1(176.32,109.74) v1(176.32,108.94) ; v1(147.97,138.64) v1(147.17,138.64) ; v1(176.87,106.38) 176.59,106.1 C1088.1
  TOP w0.508: v1(126.15,135.02) 126.05,134.92 C1070.2 ; R804.1 123.77,132.56 v1(123.7,132.49) ; R796.1 128.94,124.72 v1(128.3,125.36) ; C1094.1 173.36,85.65 v1(173.36,86.38) ; R769.1 149.95,135.41 v1(149.44,135.92) 149.95,136.43 R773.1 ; C1049.2 176.45,114.45 v1(176.37,114.54) ; v1(149.06,138.71) R797.1 ; C1095.1 172.71,85.77 v1(172.71,86.35)
  BOTTOM w0.127: VRAM1.E5 v1(134.35,136.22)
  BOTTOM w0.3: VRAM3.P14 167.12,117.88 v1(167.09,117.91) ; v1(176.89,86.33) 176.89,86.77 VRAM4.T14 ; v1(170.05,86.32) 169.51,86.87 VRAM4.G14 VRAM4.G13 ; v1(169.8,117.93) 169.8,117.62 VRAM3.L14 VRAM3.L13 ; v1(135.95,139.42) VRAM1.B3 ; VRAM3.M14 168.79,117.41 168.79,117.78 v1(168.92,117.91) ; VRAM2.M12 153.94,135.84 v1(153.55,136.23) ; v1(133.55,130.62) VRAM1.N5 ; VRAM2.G1 144.84,132.17 v1(144.66,132.17) ; VRAM4.F14 168.96,86.7 v1(168.96,86.35) ; VRAM2.D1 144.64,129.44 v1(144.6,129.4) ; v1(173.9,88.95) 173.51,88.56 VRAM4.M12 ; VRAM2.P3 v1(146.37,137.84) ; VRAM3.L1 169.68,106.78 v1(169.68,106.37) ; v1(127.95,137.82) VRAM1.D12 ; v1(128.75,136.22) VRAM1.F12 ; v1(129.58,130.6) 129.58,130.59 VRAM1.N10 ; VRAM4.B1 165.51,97.86 v1(165.46,97.92) ; VRAM4.T1 176.71,97.61 v1(177.15,98.05) ; VRAM2.L13 154.77,134.99 154.77,134.99 v1(154.42,134.64) 154.02,134.24 154.02,134.24 VRAM2.K12 ; VRAM3.F12 v1(173.92,115.34) ; VRAM3.P1 167.15,106.91 167.15,106.42 v1(167.09,106.37) ; v1(128.75,128.22) VRAM1.T12 ; VRAM3.B3 v1(176.32,108.94) ; VRAM3.D11 v1(175.52,115.34) VRAM3.D12 ; VRAM3.P3 v1(166.72,108.14) ; VRAM3.D1 175.12,106.53 v1(174.97,106.37) ; VRAM4.P14 174.94,86.78 v1(174.94,86.36) ; U22.AC10 146.35,100.94 146.71,100.57 v1(146.77,100.57) ; v1(137.7,127.65) 137.6,127.75 137.22,127.75 VRAM1.T1 ; VRAM1.P14 126.26,129.42 126.18,129.34 v1(126.18,129.33) ; v1(167.19,97.92) 167.19,97.43 VRAM4.D1 ; VRAM2.M1 v1(144.6,135.84) ; VRAM3.T14 165.49,117.37 165.49,117.49 165.16,117.82 v1(165.16,117.91) ; v1(176.87,106.38) 176.87,106.79 VRAM3.B1 ; v1(147.17,138.64) VRAM2.T3 ; v1(173.12,108.96) 173.52,108.56 VRAM3.F3 173.52,108.54 v1(173.11,108.13) 172.72,107.74 VRAM3.G2 ; v1(129.54,131.42) 129.15,131.82 VRAM1.L11 ; v1(165.91,94.55) 165.91,94.53 166.29,94.15 VRAM4.C5 ; v1(147.97,138.64) VRAM2.R5 ; VRAM2.D3 v1(146.37,129.04) ; v1(173.92,109.78) 174.28,110.14 VRAM3.E5 ; VRAM4.F1 168.79,97.43 168.79,97.78 v1(168.89,97.89) ; VRAM3.D3 v1(175.52,108.14) ; VRAM3.G13 172.32,116.94 v1(172.32,116.94) ; VRAM1.G1 137.16,135.01 v1(137.7,135.01) ; v1(144.85,107.39) 144.75,107.49 U22.K13 ; VRAM1.B12 v1(128.75,139.42) ; VRAM1.M1 137.22,131.09 137.56,131.09 v1(137.69,131.23) ; VRAM2.B3 146.39,127.46 v1(146.36,127.46) ; VRAM3.E10 174.58,113.88 v1(174.58,113.67) ; v1(172.71,97.92) VRAM4.L1 172.75,97.35 v1(173.11,96.99) 172.71,96.59 VRAM4.L2 172.71,96.5 v1(173.1,96.11) ; v1(126.04,127.54) 126.2,127.7 126.63,127.7 VRAM1.T14 ; VRAM1.D3 v1(135.15,137.82) ; VRAM4.G11 169.51,89.36 v1(169.12,89.75) ; v1(173.36,86.38) 173.36,86.8 VRAM4.M14 ; v1(146.34,130.65) 146.34,130.65 146.73,131.04 VRAM2.F3 ; v1(152.73,135.44) 153.12,135.04 VRAM2.L11 ; VRAM3.T1 165.39,106.81 165.39,106.4 v1(165.37,106.37) ; v1(137.7,132.16) 137.49,132.16 VRAM1.L1 ; VRAM4.P12 v1(175.51,88.15) ; v1(146.05,98.25) 146.05,98.55 U22.AG10 ; v1(169.75,97.96) 169.75,97.59 VRAM4.G1 ; U22.W10 146.84,102.76 v1(146.84,102.73) ; v1(173.51,97.92) VRAM4.M1 ; v1(129.5,135.42) 129.15,135.07 VRAM1.G11 ; VRAM4.T12 v1(177.11,88.95) ; v1(156.07,138.5) 156.02,138.5 155.57,138.95 VRAM2.T14 ; VRAM2.D12 154.01,129.44 154.41,129.04 v1(154.4,129.04) ; v1(126.14,131.15) 126.27,131.02 VRAM1.M14 ; VRAM4.C10 166.67,89.79 v1(166.67,89.75) 167.07,89.35 VRAM4.D11 ; v1(172.71,86.35) VRAM4.L14 VRAM4.L13 ; VRAM1.P3 v1(135.95,129.02) ; v1(169.92,109.79) 169.92,109.78 169.52,109.38 VRAM3.L4 ; VRAM4.D3 v1(166.71,96.15) ; VRAM3.B12 v1(177.12,115.34) ; VRAM1.P12 128.3,129.42 v1(127.92,129.03) ; VRAM1.M3 v1(135.15,130.62) ; VRAM4.T3 v1(177.11,96.15) ; v1(155.22,137.04) 155.57,137.39 VRAM2.P14 ; VRAM4.F12 168.71,88.56 v1(168.32,88.95) ; VRAM4.P1 174.96,97.5 v1(174.96,97.92) ; v1(144.59,127.61) 144.7,127.72 145.05,127.72 VRAM2.B1 ; v1(165.2,86.38) 165.2,86.5 165.51,86.81 VRAM4.B14 ; VRAM3.P12 v1(166.72,116.14) ; VRAM4.B12 v1(165.11,88.15) ; v1(172.72,106.37) VRAM3.G1 ; v1(156.19,132.08) 155.81,132.08 VRAM2.G14 ; v1(144.61,131.23) 144.68,131.16 145.05,131.16 VRAM2.F1 ; VRAM3.T3 v1(165.12,108.14) ; v1(126.14,132.44) 126.14,132.43 VRAM1.L14 VRAM1.L13 ; VRAM2.L1 145.13,135.04 v1(144.6,135.04) ; VRAM4.N10 v1(173.91,90.55) ; VRAM3.P11 v1(166.72,114.54) VRAM3.R10 ; VRAM2.M14 155.66,135.84 156.14,135.36 v1(156.14,135.34) ; VRAM2.T12 v1(153.57,139.44) ; v1(137.72,129.42) VRAM1.P1 ; VRAM4.F3 v1(168.31,95.35) ; VRAM3.G11 v1(173.12,114.54) ; v1(173.52,106.37) VRAM3.F1 ; VRAM3.R5 v1(165.92,109.74) ; VRAM4.P3 v1(175.51,95.35) ; v1(173.91,96.15) VRAM4.M3 ; v1(152.77,138.64) VRAM2.R10 ; VRAM3.M3 v1(168.32,108.14) ; v1(134.35,138.62) VRAM1.C5 ; VRAM2.E5 v1(148.77,130.64) ; VRAM3.C5 v1(176.32,109.74) ; VRAM2.B12 v1(153.58,128.23) ; VRAM2.G4 v1(147.97,131.44) ; VRAM4.D12 v1(166.71,88.15) ; v1(156.18,131.22) 156.06,131.22 155.88,131.04 VRAM2.F14 ; v1(156.19,127.44) 155.97,127.44 VRAM2.B14 ; VRAM1.D11 VRAM1.C10
  BOTTOM w0.305: v1(131.03,137.83) 130.63,138.22 VRAM1.C10 ; VRAM3.G1 172.77,106.94 v1(173.12,107.29) ; VRAM1.T3 v1(135.15,128.22) ; VRAM2.L2 145.57,135.44 v1(145.53,135.44) 145.53,135.4 VRAM2.L1 ; v1(136.79,135.42) 137.15,135.77 VRAM1.F1 137.31,135.66 v1(137.7,135.66) ; v1(136.79,135.42) 137.15,135.06 VRAM1.G1 ; v1(136.79,135.42) 136.4,135.02 VRAM1.G2 136.35,135.02 v1(135.96,135.41) VRAM1.F3 ; VRAM2.N5 148.37,136.59 v1(148.02,136.24) ; VRAM2.F12 v1(153.57,130.64) ; v1(173.1,96.11) 173.46,95.75 VRAM4.M3 ; v1(175.52,116.09) 175.17,115.74 VRAM3.D12 ; VRAM2.L4 147.57,135.02 v1(147.19,134.63) 146.81,134.26 146.81,134.24 ; VRAM3.H3 171.92,108.56 v1(172.32,108.96) 172.7,109.34 VRAM3.G4 ; 146.81,134.24 147.2,133.85 v1(147.2,133.85) ; 146.81,134.24 VRAM2.K3 ; v1(176.37,114.54) 175.96,114.14 VRAM3.C10 ; VRAM1.R5 v1(134.35,128.22) ; v1(152.75,131.46) 153.13,131.84 VRAM2.G11 ; v1(173.12,107.29) 172.72,107.69 VRAM3.G2 ; v1(173.12,107.29) 173.47,106.94 VRAM3.F1 ; U22.K23 v1(139.71,107.69) ; U22.K27 v1(136.5,108.7) ; VRAM3.T12 v1(165.92,115.34) ; VRAM3.H12 171.92,115.79 v1(172.32,116.19) 172.37,116.19 VRAM3.G13 ; VRAM4.M1 173.15,96.99 v1(173.11,96.99) ; VRAM2.G1 145.17,131.89 v1(145.52,132.24) 145.92,131.84 VRAM2.G2 ; VRAM1.H3 135.55,134.22 135.15,134.62 v1(135.13,134.62) 135.13,134.64 134.75,135.02 VRAM1.G4 ; VRAM2.L14 155.84,135.04 v1(156.14,135.34) ; VRAM4.E5 167.91,93.94 v1(168.29,93.56) ; VRAM3.G14 172.72,117.34 v1(172.32,116.94) ; v1(147.15,136.24) 146.77,135.86 VRAM2.M3 ; VRAM2.P11 v1(153.55,137.82) 153.93,137.44 VRAM2.P12 154,137.44 v1(154.39,137.83) ; VRAM3.M12 168.72,115.74 v1(169.11,116.13) 169.52,116.54 VRAM3.L13 169.52,116.54 169.93,116.14 v1(169.93,116.14) 170.32,115.74 VRAM3.K12 ; VRAM1.M12 v1(128.75,130.62) ; VRAM4.R5 v1(176.31,94.55) ; VRAM2.C5 v1(147.97,128.24) ; VRAM4.K12 v1(172.31,88.95) VRAM4.L11 ; v1(151.94,136.97) 152.27,136.64 VRAM2.N10 ; VRAM3.L11 169.5,114.94 v1(169.13,114.57) ; VRAM1.L2 136.39,131.82 136.79,132.22 v1(136.8,132.22) ; U22.N10 U22.L10 ; VRAM1.E10 v1(130.35,136.22)
  BOTTOM w0.33: v1(134.38,131.42) 134.75,131.79 VRAM1.L4 ; v1(167.16,86.38) 167.11,86.43 VRAM4.D14 ; VRAM1.K3 v1(135.95,132.22) VRAM1.L2 ; v1(127.9,133.82) 128.3,134.22 VRAM1.H12 ; VRAM4.G13 v1(169.91,88.15) VRAM4.H12 ; VRAM4.K3 VRAM4.L4 VRAM4.M3 ; VRAM4.G2 169.52,96.55 v1(169.91,96.16) 170.31,95.76 VRAM4.H3 ; VRAM2.H12 154.01,132.64 v1(154.41,132.24) 154.77,131.88 VRAM2.G13 ; v1(169.11,94.6) 169.46,94.95 VRAM4.G4 ; VRAM2.H3 146.75,132.64 v1(146.35,132.25) 145.97,131.86 VRAM2.G2 ; v1(168.32,114.53) 167.92,114.14 VRAM3.N10 ; VRAM1.L13 v1(127.93,132.2) VRAM1.K12 ; VRAM3.L2 169.55,107.74 v1(169.92,108.11) 170.32,108.51 VRAM3.K3 ; VRAM4.P11 v1(175.51,89.75) ; VRAM2.D14 155.59,129.42 v1(156.24,129.42) ; VRAM1.R10 129.95,128.65 v1(129.57,129.02) 129.18,129.42 VRAM1.P11
  BOTTOM w0.356: VRAM2.C10 152.37,128.69 v1(152.72,129.04) 153.12,129.44 VRAM2.D11 ; VRAM4.N5 v1(174.71,94.55) ; v1(168.31,89.79) 167.95,90.15 VRAM4.E10 ; v1(152.72,130.64) 152.37,130.28 VRAM2.E10 ; VRAM3.M1 168.82,106.84 v1(168.82,106.37) ; v1(175.51,89.75) VRAM4.R10 v1(176.31,89.75) ; VRAM4.B3 v1(165.91,95.35)
  BOTTOM w0.381: v1(134.46,108.55) 134.85,108.16 U22.K31 ; U22.K19 141.15,108.15 v1(140.74,108.56) ; VRAM3.N5 v1(168.33,109.73) ; U22.L10 146.35,107.67 145.87,108.15 ; 145.87,108.15 U22.K11 ; 145.87,108.15 145.92,108.15 v1(146.38,108.61) ; R665.1 v1(164,124.03) ; R785.2 141.53,134.02 v1(141.2,133.69)
  vias: v1(123.66,138.26) v1(123.69,137.57) v1(135.13,135.4) v1(153.58,129.03) v1(173.52,117.91) v1(174.31,120.96) v1(175.07,120.96) v1(175.78,120.94) v3(167.71,81.47) v3(167.71,80.72) v3(168.47,81.47) v3(168.47,80.72) v3(169.22,81.48) v3(169.22,80.73) v3(169.97,81.48) v3(169.97,80.73) v3(170.71,81.47) v3(170.71,80.73) v3(171.46,81.47) v3(171.46,80.73)
+2.5V_SUS:
  vias: v1(28.48,50.3) v1(32.45,67.11) v1(105.64,68.05) v1(105.65,67.36) v1(106.92,50.46) v1(107.51,50.18)
+3.3V_ALW: length 518.7
  TOP w0.305: J3.4 v1(204.4,29.94)
  TOP w0.381: v1(116.52,30.27) 117.25,30.27 118.52,31.55 127.91,31.55 128.85,30.61 138.23,30.61 139.31,29.53 148.5,29.53 150.89,31.91 150.89,35.7 v1(150.6,35.98)
  TOP w0.508: 230.17,30.95 231.13,30.95 231.76,30.31 v1(231.76,29.65) 231.75,29.65 231.31,29.2 R863.1 ; 230.17,30.95 229.72,30.49 229.72,29.94 229.81,29.85 R864.1 ; 230.17,30.95 228.85,32.27 226.26,32.27 ; 226.26,32.27 226.26,30.34 226.71,29.88 226.71,29.25 R865.1 ; 226.26,32.27 225.34,32.27 224.29,31.23 224.29,29.82 224.92,29.2 R866.1 ; v1(204.4,29.94) 204.4,29.31 v1(204.39,29.3) ; v1(240.09,19.82) 240,19.82 R966.2 ; v1(28.06,6.4) 27.75,6.71 R1088.1 ; R970.2 v1(241.63,13.98)
  TOP w0.762: PR514.1 v1(31.9,107.25) 30.93,106.28 30.93,96.24 30.46,95.77 30.46,88.14 33.47,85.13 33.47,77.07 31.86,75.46 31.86,73.01 30.58,71.74 v3(29.4,71.74) ; PR245.1 57.59,14.83 v3(56.79,14.04) ; v1(114.54,11.64) 117.18,11.64 118.61,13.07 v3(118.61,13.65)
  IN1 w0.762: v3(13.17,25.62) 13.17,24.3 10.97,22.1 10.97,20.25 13.98,17.23 13.98,14.14 13.55,13.7 13.55,10.3 17.45,6.4 v1(28.06,6.4) 28.64,6.98 41.25,6.98 48.16,13.88 52.57,13.88 53.41,14.73 55.03,14.73 55.72,14.04 v3(56.79,14.04) 58.18,14.04 60.12,15.98 60.12,17.36 61.19,18.44 76.18,18.44 77.11,17.51 v3(77.11,15.47) 78.27,15.47 79.99,17.19 96.26,17.19 97.24,16.21 101.32,16.21 102.38,15.16 105.96,15.16 v3(106.86,14.26) 106.86,13.25 107.75,12.36 113.83,12.36 v1(114.54,11.64)
  IN3 w0.508: v1(116.52,30.27) 117.69,29.1 117.69,27.92 118.29,27.32 118.29,21.66 115.33,18.7 115.33,16.83 116.33,15.83 117.47,15.83 118.61,14.69 v3(118.61,13.65)
  IN3 w0.762: v3(13.17,25.62) 13.17,26.79 10.98,28.97 10.98,38.15 14.89,42.05 14.89,46.69 v3(17.96,49.76) v3(17.96,55.96)
  IN3 w1.016: v1(243.96,32.84) v1(245.18,32.84) 246.52,32.84 256.15,42.47 257.7,42.47 264.05,48.82 264.05,51.97 266.42,54.34 266.42,59.13 269.33,62.04 269.33,70.93 270.57,72.18 270.57,75.86 273.87,79.16
  IN4 w0.762: v3(118.61,13.65) 119.16,13.65 120,14.49 123.82,14.49 124.83,15.5 140.45,15.5 141.41,14.55 145.34,14.55 146.89,16.09 156.03,16.09 156.52,16.58 172.53,16.58 175.92,13.2 v3(175.92,11.92)
  BOTTOM w0.381: v1(150.6,35.98) 149.88,36.7 PR513.1 ; RT2.1 236.1,14.35 237.27,15.52 240.09,15.52
  BOTTOM w0.508: ESD1.5 v1(114.54,11.64) ; v3(118.61,13.65) 118.61,12.99 117.81,12.19 117.81,10.31 117.61,10.11 PR222.1 ; RT1.1 111.7,49.28 109.64,47.23 109.64,36.33 108.78,35.47 108.78,33.03 102.6,26.85 102.6,22.28 106.86,18.02 v3(106.86,14.26) ; v1(116.52,30.27) 116.62,30.17 PC9211.1 PC9210.1 118.34,30.6 119.08,31.34 119.61,31.34 119.95,31.69 PU21.3 ; v1(240.09,19.82) 240.09,15.52 v1(241.63,13.98) ; R445.2 223.37,13.69 v1(223.21,13.84) ; PU23.3 17.95,53.57
  BOTTOM w0.762: 17.95,53.57 17.93,53.6 PC9233.1 16.58,54.12 16.8,54.34 PC9234.1 16.84,54.84 v3(17.96,55.96) 17.96,61.03 28.67,71.74 v3(29.4,71.74) ; PR498.1 v3(17.96,49.76) ; PR192.1 76.47,14.37 77.11,15.01 v3(77.11,15.47) ; PR203.1 56.82,14 v3(56.79,14.04)
  vias: v1(169,16.97) v1(215.25,10.34) v1(215.93,10.36) v1(222.64,17.5) v1(223,18.04) v1(273.5,81.65) v1(273.51,80.99) v3(176.98,11.92) v3(177.61,11.41) v3(235.98,28.65) v3(235.98,27.89) v3(236.74,28.65)
+3.3V_ALW_AVCC: length 4.7
  TOP w0.114: U34.74 237.27,15.41 237.43,15.57 238.55,15.57 238.82,15.85 C1210.2 239.4,15.47 v1(239.92,15.47) 240.59,15.47 L14.1
+3.3V_EC: length 70.9
  TOP w0.203: 228.23,27.37 228.23,27.02 227.97,26.75 U34.114 ; U34.121 225.17,26.75 224.34,27.57 223.64,27.57 ; U34.26 219.6,14.21 ; U34.50 229.17,9.15 ; U34.92 237.63,22.61 ; U34.127 222.77,27.04
  TOP w0.508: L14.2 v1(242.18,15.6) ; v1(239.31,21.87) 238.95,21.87 238.56,22.26 C1178.2 238.53,22.61 237.63,22.61 ; 228.23,27.37 228.23,27.94 C1176.2 227.75,28.39 227.47,28.11 v1(227.47,27.82) ; 229.17,9.15 v1(229.17,8.81)
  IN3 w0.508: v1(223,27.79) 223.03,27.82 v1(227.47,27.82) 228.85,26.44 236.09,26.44 239.31,23.22 v1(239.31,21.87) 240.84,20.34 240.84,16.93 v1(242.18,15.6)
  BOTTOM w0.508: v1(218.01,10.2) 218.58,9.63 228.34,9.63 v1(229.17,8.81) 230.29,9.94 239.4,9.94 242.89,13.42 242.89,14.89 v1(242.71,15.07) v1(242.18,15.6)
+3.3V_EN2: length 87.9
  IN1 w0.254: v1(151.99,11.99) 152.51,11.99 156.35,15.83 156.97,15.83 157.18,16.05 179.91,16.05 186.88,9.07 203,9.07 v1(203.86,9.93)
  BOTTOM w0.203: 151.99,11.73 151.57,11.32 PU2.6
  BOTTOM w0.254: R228.2 229.48,12.91 v1(229.02,12.45) 221.62,12.45 220.61,13.46 R226.2 220.08,12.8 219.62,12.35 213.99,12.35 210.71,9.07 204.72,9.07 v1(203.86,9.93) ; 151.99,11.73 v1(151.99,11.99)
+3.3V_RTC_LDO: length 145.7
  TOP w0.508: v1(269.91,3.99) 270.23,4.31 RTCD1.1
  IN1 w0.508: v1(201.75,12.86) 201.2,13.4 183.29,13.4 180.12,16.57 156.97,16.57 156.75,16.35 156.14,16.35 152.82,13.04 v1(149.44,13.04)
  IN3 w0.508: v1(201.75,12.86) 203.91,15.02 211.62,15.02 212.43,15.83 215.17,15.83 219.1,19.75 v1(222,19.75) 222.3,20.06 223.19,20.06 224.25,19 v1(224.25,16.4) 224.8,15.85 v1(229.51,15.85) 231.56,15.85 234.26,13.14 235.71,13.14 236.4,12.45 236.4,11.24 241.77,5.87 245.4,5.87 245.94,6.41 259.22,6.41 260.29,5.34 265.82,5.34 267.06,4.09 267.86,4.09 268.89,3.07 269.42,3.07 269.91,3.56 v1(269.91,3.99)
  BOTTOM w0.203: PU2.3 149.67,12.52 150.03,12.88 PC225.1
  BOTTOM w0.381: v1(149.44,13.04) 149.86,13.46 PC225.1
  BOTTOM w0.508: v1(222,19.75) 221.81,19.94 220.27,19.94 R861.2 ; R435.1 224.25,16.45 v1(224.25,16.4) ; v1(229.51,15.85) R443.2 R447.1 R448.2
+3.3V_RUN: length 657.1
  TOP w0.203: v1(222.52,20.71) 222,20.71 221.51,20.21 U34.11
  TOP w0.254: v1(164.63,56.14) 163.08,57.69 163.08,67.77 164.91,69.6 164.91,73.44 165.79,74.32 165.79,74.94 R75.2 ; R73.2 v1(270.45,81.88) ; v1(21.17,7.3) CN5.35 ; R92.2 266.07,69 265.42,68.36 265.42,66.67 266.25,65.84 C413.2
  TOP w0.381: v1(97.01,102.28) 97.01,102.3 96.37,101.66 96.37,98.74 95.89,98.26 94.13,98.26 93.81,98.58 89.57,98.58 R623.1 ; v1(45.27,104.7) 44.39,104.7 44.09,104.41 R481.1 ; v1(98.97,108.67) 98.28,109.36 94.47,109.36 90.77,105.66 R580.2 R994.1 R582.2 ; R482.1 v1(42.91,98.68) ; R1045.2 v1(242.76,20.3)
  TOP w0.508: v1(200.95,17.25) 200.95,14.83 200.83,14.7 R239.2 ; 40.81,93.3 41.44,93.93 41.44,96.47 v1(39.9,98.01) 38.98,98.93 38.98,102.16 v1(39.92,103.1) ; 40.81,93.3 37.24,93.3 36.23,94.3 35.55,94.3 35.04,93.79 R55.2 ; 40.81,93.3 41.44,92.66 41.44,72.19 32.48,63.23 30.69,63.23 28.77,61.31 v1(25.43,61.31) ; R241.2 R235.2 8.21,16.71 7.55,17.37 5,17.37 5,17.37 ; R918.1 R917.1 104.71,60.84 105.58,61.7 v1(105.58,64.37) 105.52,64.42 C917.1 104.69,64.42 104.24,64.87 104.24,72.62 101.8,75.05 101.8,92.24 98.37,95.67 98.37,101.93 98.04,102.25 97.04,102.25 v1(97.01,102.28) ; v1(234.13,30.58) 234.13,30.9 R201.2 ; R868.1 239.34,25.37 v1(239.77,25.8) ; v1(99.12,106.85) 99.15,106.81 99.15,105.44 v1(99.21,105.39) 97.6,105.39 v1(96.94,104.73) 96.49,104.73 95.02,103.25 R1011.1 ; v1(236.79,30.59) 236.78,30.59 R1089.2 ; R867.1 239.7,23.55 v1(239.95,23.3) ; v1(42.65,111) 42.47,110.83 C573.1 R264.1
  IN1 w0.381: v1(45.27,104.7) 45.5,104.47 45.5,101.81 42.91,99.22 v1(42.91,98.68) 42.24,98.01 v1(39.9,98.01) ; v1(106.83,139.16) 107.44,138.55 109.43,138.55 114.3,133.67 114.3,128.63 111.13,125.46 v1(111.13,122.43)
  IN1 w0.508: v1(239.77,25.8) 239.77,27.6 v1(236.79,30.59) 236.78,30.58 v1(234.13,30.58) ; v1(42.65,111) 42.65,111.3 43.02,111.68 44.53,111.68 45.12,111.08 45.12,110.03 39.92,104.82 v1(39.92,103.1) ; v1(267.41,66.19) 268.66,66.19 270.85,63.99 273.45,63.99 273.82,63.62 v3(277.52,63.62)
  IN2 w0.381: v1(98.97,108.67) 98.46,108.67 98.26,108.87 98.26,114.11 97.87,114.5 97.87,115.61 97.23,116.26 97.23,119.17 95.94,120.45 v1(95.94,121.21)
  IN2 w0.508: v1(99.12,106.85) 99.12,108.51 v1(98.97,108.67) ; v1(39.92,103.1) 39.92,108.33 39.07,109.18 38.11,109.18 36.97,110.31 35.74,110.31 35.71,110.34 34.99,110.34 34.69,110.65 34.69,111.57 34.29,111.96 34.29,112.88 33.26,113.91 33.26,114.45 31.75,115.96 31.75,119.86 32.92,121.03 32.92,124.46 33.4,124.94 33.4,127.56 35.08,129.24 v1(35.59,129.24) ; v1(96.94,104.73) 96.8,104.59 96.8,102.49 v1(97.01,102.28)
  IN3 w0.254: 164.47,51.69 164.45,51.71 149.74,51.71 v1(149.73,51.71) ; v1(157.37,40.81) 158.31,41.75 164.28,41.75
  IN3 w0.508: v1(29.12,21.36) 38.79,31.03 45.4,31.03 54.9,40.53 84.91,40.53 88.14,43.76 97.59,43.76 98.46,44.64 105.96,44.64 106.68,45.35 106.68,46.99 108.18,48.49 108.18,50.92 106.52,52.58 v1(106.52,54.22) 107.19,54.89 107.19,58.03 105.58,59.65 v1(105.58,64.37)
  IN3 w0.762: 244.46,19.69 244.46,27.69 256.94,40.17 271.93,40.17 274.17,42.41 274.17,46.7 274.54,47.07 274.54,58.02 274.16,58.4 274.16,61.29 275.2,62.33
  IN4 w0.508: v1(25.43,61.31) 24.85,60.73 24.85,50.52 25.84,49.53 25.84,35.96 24.75,34.88 24.75,27.93 21.74,24.91 20.63,24.91 20.13,25.42 18.62,25.42 17.56,24.36 v1(12.01,24.36)
  BOTTOM w0.254: R1029.1 157.9,40.31 158.24,40.31 R1027.2 158.02,40.81 v1(157.37,40.81) 157.31,40.87 153.02,40.87 R1032.1 ; v1(106.52,54.22) 106.33,54.41 105.13,54.41 104.73,54.01 CN16.255 ; v1(105.58,64.37) 104.99,64.37 104.72,64.64 CN17.255 ; v1(149.73,51.71) 149.73,51.72 150.04,52.02 Q51.2 ; 269.09,69.09 267.54,70.65 267.54,78.61 270.45,81.52 270.45,81.88 v1(270.45,81.88) 270.63,82.06 R321.2 ; v3(170.24,48.55) 170.1,48.69 CN9.6
  BOTTOM w0.381: v1(35.59,129.24) v1(35.06,128.71) PR509.1 ; v1(106.83,139.16) 106.57,139.16 106.18,138.77 106.18,138 106.5,137.68 PR507.1 ; R1070.2 221.07,22.15 v1(222.52,20.71) ; R525.1 96.94,104.47 v1(96.94,104.73) 96.49,104.73 R524.1 ; v1(99.21,105.39) 100.42,105.39 R527.1 ; R470.1 40.58,102.54 40.02,103.1 v1(39.92,103.1) 39.87,103.1 39.62,102.85 R469.1 ; R592.1 98.7,107.27 v1(99.12,106.85) ; v1(95.94,121.21) 95.97,121.19 109.89,121.19 v1(111.13,122.43) ; R593.1 98.37,108.67 v1(98.97,108.67)
  BOTTOM w0.432: v1(42.65,111) 42.52,111.13 U9.1
  BOTTOM w0.508: v1(267.41,66.19) 268.03,66.19 268.88,67.03 268.88,68.88 269.09,69.09 R345.2 ; R1006.2 96.98,104.69 v1(96.94,104.73) ; v1(99.21,105.39) 98.75,105.39 98.37,105.77 R594.1 98.39,106 99.85,106 R526.1 ; R1012.1 97.95,102.25 97.04,102.25 v1(97.01,102.28) 97.01,102.3 96.82,102.11 R528.2 R965.2 ; v1(5.97,24.01) 6.32,24.36 v1(12.01,24.36) ; v1(42.65,111) 42.95,110.7 42.95,109.57 43.51,109.01 44.45,109.01 44.95,109.51 R262.1 ; v1(21.17,7.3) 20.42,7.3 C746.1 19.88,7.29 19.82,7.22 R1060.1 ; R560.1 92.24,125.86 95.94,122.16 v1(95.94,121.21)
  vias: v1(3.59,20.51) v1(3.57,3.18) v1(4.22,23.73) v1(4.23,3.18) v1(4.65,23.25) v1(5.3,24.01) v1(5.3,23.35) v1(5.58,5.39) v1(5.97,23.35) v1(196.7,17.25) v1(197.41,17.25) v1(198.15,17.25) v1(245.33,19.16) v1(245.35,18.34) v1(246.14,19.16) v3(161.85,20.57) v3(162.6,20.57) v3(163.35,20.57) v3(164.1,20.57) v3(168.72,48.58) v3(169.48,48.58) v3(278.32,63.61)
+3.3V_SSD:
  vias: v1(193.1,18.29)
+3.3V_SUS: length 463.3
  TOP w0.381: R543.2 70.99,116.83 70.89,116.93 70.89,117.69 71.75,118.55 73.44,118.55 ; R543.2 71.2,116.76 71.65,116.32 R596.1 ; R543.2 70.89,116.76 70.1,115.97 R551.1 ; 73.44,118.55 76.2,121.3 v2(76.2,122.04) 76.2,122.28 76.52,122.6 78.94,122.6 79.17,122.37 v2(79.17,122.03) 79.54,122.03 80.11,122.6 82.41,122.6 82.82,122.19 v1(83.13,122.19) 83.21,122.19 84.62,120.78 94.2,120.78 v1(94.64,121.21) ; 73.44,118.55 73.92,118.07 73.92,117.02 R532.1 R533.1 74.94,117.41 R568.2 75.49,118.44 75.81,118.75 76.72,118.75 77.05,118.42 77.05,116.93 R571.2 R1010.1 R1107.1 R595.1 R597.1
  TOP w0.508: v1(227.05,31.64) 227.29,31.64 228.15,30.78 R1040.2 228.15,29.94 228.77,29.32 R1005.2
  TOP w1.016: 111.58,37.48 111.58,39.52 112.73,40.67 112.73,44.63 111.98,45.38 111.98,47.47 112.73,48.22 112.73,57.91 111.98,58.66 111.98,67.22 109.98,69.21 109.98,69.91 103.96,75.93 103.96,93.22 106.8,96.07 106.8,107.02 107.28,107.5 107.28,109.28 106.25,110.32 101.59,110.32 100.23,108.96 100.23,108.68 99.31,107.76 96.75,107.76
  IN1 w0.508: v1(17.06,10.75) 17.06,18.31 16.65,18.71 16.65,25.07 v1(16.66,25.08)
  IN1 w0.762: v1(17.06,10.75) 18.06,9.75 21.76,9.75 22.23,10.23 37.51,10.23 38.64,9.1 40.88,9.1 47.22,15.43 51.93,15.43 56.9,20.4 98.41,20.4 102.61,16.19 106.42,16.19 107.77,14.85 v1(107.77,14.4)
  IN2 w0.381: v3(94.1,106.32) 94.64,105.78 95.2,105.78 95.92,106.51 95.92,114.23 96.18,114.49 96.18,118.74 94.64,120.29 v1(94.64,121.21)
  IN2 w0.508: v1(227.05,31.64) 225.22,33.47 189.32,33.47 186.35,36.45 176.14,36.45 v3(174.93,37.65)
  IN2 w0.762: v3(174.93,37.65) 173.1,35.82 163.87,35.82 162.18,34.13 159.71,34.13
  IN3 w0.508: v1(28.52,46.88) 28.52,42.19 28.89,41.82 28.89,31.16 24.58,26.86 20.83,26.86 19.47,25.49 17.07,25.49 v1(16.66,25.08) ; v3(123.79,40.99) 123.79,44.55 122.54,45.81 v1(119.67,45.81)
  IN4 w1.524: 155.94,37.14 154.67,37.14 153.4,38.41 151.22,38.41 149.23,36.42 147.57,36.42 144.75,39.24 126.42,39.24 125.49,40.18
  BOTTOM w0.381: 83.13,122.79 83.39,123.05 R546.1 R545.1 ; 83.13,122.79 82.59,123.32 R598.1 ; 83.13,122.79 v1(83.13,122.19) 83.13,122.08 82.36,121.32 R550.2 ; R536.2 76.2,121.39 v2(76.2,122.04) 76.2,122.37 76.72,122.88 76.72,123.87 76.93,124.09 R573.2 77.7,124.19 78.48,124.97 R552.2 ; R549.2 R539.2 79.71,121.48 v2(79.17,122.03)
  BOTTOM w0.508: PR111.2 23.13,48.04 25.35,48.04 26.51,46.88 v1(27.27,46.88) v1(28.52,46.88) ; v1(94.64,121.21) 94.43,121.41 R570.2 ; v1(119.67,45.81) 119.04,45.81 PR456.2 ; v1(17.06,10.75) 17.08,10.73 R1054.1
  BOTTOM w0.762: v3(174.93,37.65) Q26.3 172.94,37.65 172.42,38.16 171.35,38.16 170.88,37.69 R415.2 ; v1(107.77,14.4) 107.77,15.16 108.18,15.57 108.18,21.51 110.4,23.73 110.4,31.38 109.85,31.93 v3(109.85,35.18)
  vias: v1(157.77,34.84) v1(158.43,34.84) v1(159.09,34.86) v3(110.59,36.57) v3(110.51,35.7) v3(122.9,39.81) v3(123.44,40.33)
+3.3V_TP: length 11.6
  TOP w0.254: R151.2 R150.2 v1(164.05,40.54)
  TOP w0.508: R171.2 v1(167.27,34.65) ; R172.1 v1(168.47,34.65) ; R170.2 v1(166.26,34.65)
  BOTTOM w0.254: v1(164.05,40.54) 162.9,39.4 162.9,38.11 166.26,34.75 v1(166.26,34.65)
  vias: v1(180.76,34.35) v3(172.97,34.45)
+3V_GFX: length 223.2
  TOP w0.381: 140.13,93.55 140.55,93.97 C970.1 140.96,94.22 R927.2 ; 140.13,93.55 R936.2 138.99,93.55 138.22,92.77 137.2,92.77 136.03,93.95 136.03,94.27 135.41,94.89 v1(135.41,95.59) ; 140.13,93.55 140.13,89.28 138.71,87.87 138.71,85.26 137.63,84.18 137.63,83.36 137.28,83.02 R679.2 ; R925.2 117.43,105.88 117.79,105.52 119.05,105.52 R690.2 ; v1(119.95,111.3) 119.56,111.69 R938.2
  TOP w0.508: R679.2 v1(136.75,82.14) 135.64,82.14 135.25,82.53 133.28,82.53 131.54,84.27 v1(131.54,87.51) ; v1(116.78,114.28) 117.16,114.53 R940.2 ; R1091.2 117.4,113.5 117.16,113.26 v1(116.78,113.26) ; R942.2 v1(116.78,109.45)
  IN2 w0.508: v1(132.57,54.43) 126.77,54.43 123.81,57.39 123.81,65.41 124.65,66.26 124.65,81.13 131.04,87.51 v1(131.54,87.51)
  IN3 w0.254: v1(157.47,36.46) 157.47,37.69 v1(159.66,39.89) 160.54,39.89 162.48,37.94 162.48,24.34 160.66,22.51 157.82,22.51 v1(157.13,21.82)
  IN3 w1.016: 116.58,78.84 115.92,78.18 115.92,65.46 119.81,61.57 119.81,55.68 128.42,47.07 128.42,42.89 131.43,39.89 143.35,39.89 145.7,42.24 148.61,42.24 150.25,40.6 150.25,37.62 152.4,35.47 152.4,31.3 150.36,29.27 150.36,24.83 147.79,22.26 147.79,21.46 148.97,20.29 154.05,20.29 155.02,21.25
  BOTTOM w0.254: v1(159.66,39.89) 159.66,41.22 159.23,41.66 156.5,41.66 R1031.1 ; R1028.1 157.35,36.58 v1(157.47,36.46)
  BOTTOM w0.305: C964.1 122,87.71 121.5,87.71 121.26,87.47 U24.5
  BOTTOM w0.381: R731.1 125.79,87.33 v1(126.35,87.88) ; U22.AM31 v1(135.41,95.59) ; R647.1 v1(122.12,99.62) ; R645.2 120.67,100.85 v1(120.08,100.85)
  BOTTOM w0.508: C964.1 122.48,86.97 v1(121.86,86.97) 121.86,86.61 R960.2 ; R732.1 v1(127.71,87.88) ; v1(136.75,82.14) 137.94,83.33 139.14,83.33 139.66,82.81 U208.3 ; R1016.1 v1(122.24,84.32) ; PR407.2 v1(132.57,54.43)
  vias: v1(117.04,81.13) v1(117.06,80.47) v1(117.13,84.64) v1(121.07,105.06) v1(121.04,103.87) v1(156.4,21.82)
+3V_RTC: length 283.5
  TOP w0.508: v1(245.07,6.66) C876.1 244.29,6.67 U21.3 ; R1087.1 28.84,7.73 29.38,7.19 v1(29.38,4.96) ; R1071.1 v1(217.38,23.56) ; v1(269.14,3.74) 269.62,3.26 C877.1 269.91,2.71 RTCD1.3
  IN1 w0.508: v1(245.07,6.66) 258.98,6.66 260.3,5.33 265.77,5.33 266.96,4.15 268.72,4.15 v1(269.14,3.74)
  IN3 w0.508: v1(245.07,6.66) 242.02,6.66 237.05,11.64 237.05,12.72 235.97,13.79 234.77,13.79 233.83,14.74 233.83,15.72 232.87,16.67 227.52,16.67 220.63,23.56 v1(217.38,23.56) 213.97,23.56 209.79,19.39 194.76,19.39 190.62,15.25 186.2,15.25 180.46,9.5 155.99,9.5 154.04,7.55 153.02,7.55 150.27,4.79 108.97,4.79 106.84,6.92 102.8,6.92 99.38,10.34 99.38,16.13 98.18,17.33 96.51,17.33 94.53,19.31 51.55,19.31 38.72,6.48 30.9,6.48 v1(29.38,4.96)
+3VLANVCC: length 11.2
  TOP w0.203: U2.11 v1(268.07,89) ; 272.08,85.47 U2.23
  TOP w0.508: v1(269.94,79.86) 268.92,79.86 268.64,79.58 Q49.2
  IN3 w0.508: v1(269.94,79.86) 270.07,79.74 272,79.74 272.85,80.58 v1(272.85,84.66)
  vias: v1(272.2,84.66) v1(273.8,91.24) v1(274.21,91.88) v1(274.59,91.34)
+5V_ALW: length 192.7
  TOP w0.254: R132.2 272.2,41.68 270.8,40.29 266.79,40.29 266.38,40.69 R404.2 265.55,41.3 v1(264.76,42.1)
  TOP w0.381: v1(125.33,79.59) 124.86,79.12 124.86,73.18 122.99,71.31 122.99,58.21 126.98,54.22 126.98,47.08 126.27,46.38 126.27,45.73 v1(125.68,45.14)
  TOP w0.508: R1063.1 125.82,45.01 v1(125.68,45.14)
  IN1 w0.508: v1(187.85,58.64) 187.61,58.41 176.89,58.41 v1(174.32,60.98)
  IN3 w0.381: v1(125.68,45.14) 125.11,44.57 125.11,34.01 124.97,33.87 124.97,33.14 124.03,32.2 124.03,28.2 v3(123.19,27.37)
  IN3 w0.508: v1(167.92,23.61) 167.92,24.67 167.42,25.18 167.42,25.98 v1(167.42,25.99)
  IN4 w0.254: v1(116.53,50.45) 119.75,47.23 121.75,47.23 123.84,45.14 v1(125.68,45.14)
  IN4 w0.508: v1(125.68,45.14) 127.47,43.36 127.59,43.36 130.56,40.4 145.23,40.4 v1(146.14,39.49)
  BOTTOM w0.191: 123.89,24.64 123.71,24.82 PU27.4 ; PU28.4 165.84,23.71 166.8,23.71 167.01,23.92 167.26,23.92
  BOTTOM w0.254: 131.89,17.84 139.43,17.84 140.69,19.1 v1(142.58,19.1) 146.64,19.1 147.02,18.71 147.02,17.82 148.29,16.55 PC86.1 148.06,16.31 PD5.2 ; v1(116.53,50.45) 116.14,50.45 115.84,50.75 PR457.2
  BOTTOM w0.381: 167.26,23.92 167.68,24.34 PC9318.2 ; v1(153.63,29.97) 153.29,29.63 153.29,28.82 ; R1078.1 124.77,79.59 v1(125.33,79.59)
  BOTTOM w0.508: v1(187.85,58.64) 187.85,53.75 191.4,50.2 191.4,44.68 194.07,42.02 199.33,42.02 201.89,39.45 v1(201.89,29.96) ; v1(124.04,25.43) 124.49,24.98 PC9317.2 124.31,24.64 123.89,24.64 ; PR453.2 174.93,61.6 v1(174.32,60.98) ; v1(146.14,39.49) 145.55,40.08 PR363.2 ; v1(167.92,23.61) PC9318.2 ; v1(117.41,31.33) PC9213.1 117.81,31.96 118.1,31.68 118.48,31.68 118.68,31.88 PU21.4 ; PR107.2 v1(24.61,45.97)
  vias: v1(18.73,56.38) v1(18.81,55.71) v1(19.6,55.71) v1(30.8,112.63) v1(32.38,113.54) v1(32.38,112.89) v1(202.58,29.95) v1(250.05,24.8) v1(264.25,42.69) v1(264.93,42.72) v3(12,31.13) v3(12,30.37) v3(12.75,31.15) v3(12.75,30.38) v3(13.5,31.14) v3(13.5,30.38) v3(54.95,27.14) v3(56.1,27.2) v3(58.84,29.72) v3(61.13,29.24) v3(61.86,29.85) v3(62.62,29.23) v3(121.34,13.64) v3(121.34,12.88) v3(122.1,13.64) v3(122.1,12.88) v3(122.31,23) v3(122.31,22.24) v3(122.55,16.44) v3(122.86,13.64) v3(122.86,12.88) v3(123.07,23) v3(123.07,22.24) v3(123.14,26.52) v3(123.31,16.44) v3(123.62,13.64) v3(123.62,12.88) v3(123.81,26.89) v3(123.82,23.01) v3(123.82,22.24) v3(124.38,13.64) v3(124.38,12.88) v3(125.15,13.64) v3(125.15,12.88)
