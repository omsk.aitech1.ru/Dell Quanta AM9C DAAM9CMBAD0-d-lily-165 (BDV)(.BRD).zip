# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ12: length 46.5
  IN1 w0.127: v1(46.25,59.19) 44.89,60.55 44.89,66.91 42.85,68.95 42.85,81.68 47.36,86.2 47.36,88.68 50.13,91.45 v1(50.47,91.45)
  BOTTOM w0.102: v1(50.47,91.45) 51.58,92.56 52.64,92.56 53.67,93.6 54.44,93.6 55.16,94.31 55.76,94.31 55.78,94.3 56.45,94.3 U18.B28
  BOTTOM w0.178: v1(46.25,59.19) 46.15,59.19 45.98,59.02 CN17.28
M_B_DQ13: length 45.8
  IN1 w0.127: v1(46.23,60.51) 45.32,61.42 45.32,67.14 43.28,69.18 43.28,81.51 47.79,86.02 47.79,88.32 49.6,90.13 v1(50.07,90.13)
  BOTTOM w0.108: v1(50.07,90.13) 51.05,91.1 51.05,91.55 51.66,92.16 52.53,92.16 53.75,93.39 54.53,93.39 55.25,94.11 55.68,94.11 55.81,93.98 56.17,93.98 U18.B29
  BOTTOM w0.178: v1(46.23,60.51) 44.98,59.26 CN17.24
M_B_DQ14: length 44.8
  IN1 w0.127: v1(48.72,62.41) 47.95,62.41 47.87,62.49 47.87,62.87 48,63.01 48,65.79 48.54,66.33 48.54,68.75 48.36,68.93 47.81,68.93 47.2,69.54 47.2,69.72 47.38,69.89 47.38,70.07 47.2,70.25 47.02,70.25 46.84,70.08 46.67,70.08 46.44,70.3 46.44,70.54 46.77,70.87 46.77,71.14 46.31,71.61 46.31,79.03 50.82,83.54 50.82,85.85 53.7,88.73 53.7,90.21 54.17,90.67 54.17,91.65 55.82,93.3 56,93.3 56.25,93.04 56.25,92.86 v1(55.05,91.67)
  BOTTOM w0.108: U18.A31 55.14,91.88 55.14,91.78 55.08,91.72 55.08,91.69 v1(55.05,91.67)
  BOTTOM w0.178: CN17.37 48.22,62.91 v1(48.72,62.41)
M_B_DQ15: length 45.5
  IN1 w0.127: v1(55.66,90.8) 55.89,91.03 55.89,91.27 55.74,91.42 55.53,91.42 54.09,89.98 54.09,88.45 51.25,85.61 51.25,83.36 46.74,78.85 46.74,71.86 47.82,70.78 47.82,69.54 47.94,69.41 48.24,69.41 48.37,69.54 48.37,70.94 47.24,72.08 47.24,72.28 47.42,72.46 47.57,72.46 48.97,71.06 48.97,66.09 48.3,65.41 48.3,64.13 v1(48.72,63.7)
  BOTTOM w0.108: v1(55.66,90.8) 55.99,91.13 55.99,91.46 56.73,92.2 U18.C31
  BOTTOM w0.178: v1(48.72,63.7) 49.17,64.15 49.17,64.6 49.22,64.66 CN17.41
M_B_DQ16: length 40.3
  IN1 w0.127: v1(58.23,92.48) 58.23,90.12 53.41,85.3 53.41,79.16 54.43,78.14 54.43,75.66 51.13,72.36 51.13,66.32 51.04,66.23 51.04,62.49 50.5,61.95 50.5,59.53 v1(50.01,59.04)
  BOTTOM w0.178: U18.E30 58.43,92.48 v1(58.23,92.48) ; CN17.46 50.48,58.58 v1(50.01,59.04)
M_B_DQ17: length 42
  IN1 w0.127: v1(54.06,84.71) 53.84,84.48 53.84,79.34 54.87,78.32 54.87,75.48 51.56,72.18 51.56,66.24 51.4,66.07 51.4,62.19 50.95,61.75 50.95,60.15 51.06,60.03 51.4,60.03 51.53,60.16 51.53,60.58 v1(51.93,60.99)
  BOTTOM w0.102: 56.39,87.41 56.39,88.39 58.35,90.35 58.35,91.6 U18.E31
  BOTTOM w0.108: v1(54.06,84.71) 54.8,84.71 56.39,86.3 56.39,87.41
  BOTTOM w0.178: CN17.50 51.48,58.45 51.35,58.58 51.35,60.4 v1(51.93,60.99)
M_B_DQ18: length 41
  IN1 w0.127: v1(55.24,62.4) 55.24,61.59 56.17,60.67 56.17,60.44 55.87,60.14 55.66,60.14 54.67,61.13 54.67,68.02 55.28,68.64 55.28,71.62 57.89,74.23 57.89,79.57 56.88,80.58 56.88,85.51 v1(57.15,85.78)
  BOTTOM w0.102: U18.G33 60.45,89.6 57.89,87.04 57.76,87.04
  BOTTOM w0.127: 57.76,87.04 57.15,86.44 v1(57.15,85.78)
  BOTTOM w0.178: v1(55.24,62.4) 55.14,62.4 53.73,63.82 CN17.59
M_B_DQ19: length 41.3
  IN1 w0.127: v1(55.23,63.71) 55.23,63.57 55.36,63.45 55.59,63.45 55.72,63.57 55.72,64.88 55.59,65.01 55.24,65.01 55.12,65.14 55.12,65.52 55.24,65.64 55.59,65.64 55.72,65.77 55.72,66.13 55.59,66.26 55.23,66.26 55.1,66.39 55.1,66.77 55.23,66.9 55.59,66.9 55.72,67.03 55.72,67.34 55.59,67.47 55.28,67.47 55.16,67.6 55.16,67.9 55.28,68.03 55.59,68.03 55.72,68.15 55.72,70.19 55.87,70.34 56.12,70.34 56.25,70.47 56.25,70.85 56.12,70.98 55.84,70.98 55.72,71.11 55.72,71.45 58.32,74.05 58.32,79.75 58.13,79.94 58.13,80.12 58.32,80.31 58.32,80.76 58.2,80.88 58.03,80.88 57.7,80.55 57.52,80.55 57.31,80.76 57.31,81.06 57.63,81.38 58.15,81.38 58.27,81.5 58.27,81.73 58.15,81.86 57.44,81.86 57.31,81.99 57.31,82.23 57.44,82.35 57.73,82.35 57.84,82.46 57.84,82.74 57.72,82.86 57.47,82.86 57.34,82.99 57.34,83.29 57.46,83.41 57.72,83.41 57.85,83.54 57.85,83.84 57.72,83.97 57.54,83.97 57.41,84.09 v1(57.41,84.45)
  BOTTOM w0.102: U18.G32 60.45,90.95 60.76,90.63 60.76,90.28 60.66,90.18 60.66,89.53 60.65,89.52 60.65,89.48 58.19,87.01
  BOTTOM w0.127: 58.19,87.01 58.03,86.85 58.03,84.58 57.9,84.45 v1(57.41,84.45)
  BOTTOM w0.178: v1(55.23,63.71) 55.13,63.71 54.73,64.11 CN17.63
M_B_DQ20: length 40
  IN1 w0.127: v1(50,64.19) 50.17,64.19 50.27,64.29 50.27,71.6 49.67,72.2 49.67,72.37 50.27,72.97 50.27,73.27 50.12,73.42 49.93,73.42 49.3,72.79 49.12,72.79 48.94,72.97 48.94,73.15 49.56,73.77 49.56,73.95 49.38,74.13 49.2,74.13 48.58,73.51 48.4,73.51 48.22,73.69 48.22,73.87 48.84,74.49 48.84,74.67 48.63,74.88 48.43,74.88 48.3,74.76 48.12,74.76 48.03,74.84 48.03,78.32 50.04,80.32 52.34,80.32 52.54,80.53 52.54,85.37 55.61,88.43 55.61,89.33 56.63,90.35 56.93,90.35 57.04,90.25 v1(57.04,90.04)
  BOTTOM w0.108: v1(57.04,90.04) 57.35,90.35 U18.C33
  BOTTOM w0.178: v1(50,64.19) 50.22,64.42 CN17.45
M_B_DQ21: length 40.2
  IN1 w0.127: v1(50,62.87) 50.7,63.57 50.7,73.12 50.79,73.21 51.37,73.21 51.54,73.38 51.54,73.7 51.39,73.84 50.29,73.84 48.47,75.66 48.47,78.14 50.21,79.88 52.12,79.88 52.22,79.78 52.85,79.78 52.98,79.91 52.98,85.39 56.14,88.56 v1(56.14,89.02)
  BOTTOM w0.102: U18.D33 58.05,90.83 57.76,90.54 57.76,90.08 56.7,89.02 v1(56.14,89.02)
  BOTTOM w0.178: v1(50,62.87) 51.22,64.09 CN17.49
M_B_DQ22: length 40.3
  IN1 w0.127: v1(54.48,58.76) 53.81,59.42 53.81,68.4 54.42,69.01 54.42,71.98 57.03,74.59 57.03,79.21 56.02,80.22 56.02,85.98 56.94,86.9 58.08,86.9 59.45,88.26 59.45,89.06 59.05,89.46 59.05,91.22 v1(59.94,92.11)
  BOTTOM w0.178: v1(59.94,92.11) 60.45,92.62 U18.G30 ; CN17.62 v1(54.48,58.76)
M_B_DQ23: length 40.4
  IN1 w0.127: v1(54.45,60.13) 54.24,60.33 54.24,68.22 54.85,68.83 54.85,71.8 57.46,74.41 57.46,79.39 56.45,80.4 56.45,85.95 57.07,86.57 58.37,86.57 60.24,88.44 60.24,89.13 59.8,89.57 v1(59.55,89.57)
  BOTTOM w0.102: U18.G31 60.45,91.77 60.14,91.45 60.14,90.39 60.15,90.38 60.21,90.32 60.21,89.76 60.02,89.57 v1(59.55,89.57)
  BOTTOM w0.178: v1(54.45,60.13) 53.48,59.16 CN17.58
M_B_DQ24: length 38
  IN1 w0.127: v1(57.12,63.7) 57.97,64.55 57.97,64.85 57.85,64.98 57.16,64.98 57.04,65.11 57.04,65.36 57.16,65.49 57.85,65.49 57.97,65.62 57.97,65.87 57.85,66 57.16,66 57.04,66.12 57.04,66.38 57.16,66.5 57.85,66.5 57.97,66.63 57.97,66.92 57.85,67.05 57.65,67.05 57.52,67.18 57.52,67.43 57.65,67.56 57.85,67.56 57.97,67.69 57.97,68.97 57.57,69.37 57.57,71.47 59.62,73.51 59.62,82.22 59.16,82.67 59.16,86.06 v1(60.01,86.91)
  BOTTOM w0.102: U18.J30 61.71,92.56 61.71,91.7 61.53,91.52 61.53,91.05 61.55,91.02 61.55,90.77 61.53,90.75 61.53,89.49 60.57,88.53 60.57,87.46 v1(60.01,86.91)
  BOTTOM w0.178: CN17.71 56.73,64.72 56.6,64.6 56.6,64.21 v1(57.12,63.7)
M_B_DQ25: length 38.1
  IN1 w0.127: v1(60.01,85.63) 59.6,85.22 59.6,82.85 60.05,82.4 60.05,73.33 58,71.29 58,69.55 58.41,69.15 58.41,64.37 57.9,63.86 57.9,59.56 57.81,59.47 v1(57.17,59.47)
  BOTTOM w0.102: U18.J31 62.05,91.75 61.73,91.44 61.73,91.15 61.77,91.12 61.77,90.66 61.73,90.63 61.73,89.37 60.93,88.57 60.93,86.55 v1(60.01,85.63)
  BOTTOM w0.178: v1(57.17,59.47) 56.48,58.78 CN17.70
M_B_DQ26: length 37.9
  IN1 w0.127: v1(62.59,87.71) 62.19,87.31 62.19,83.63 62.64,83.19 62.64,68.99 62.37,68.72 62.37,65.28 62.24,65.16 61.76,65.16 61.63,65.03 61.63,64.77 61.76,64.65 62.24,64.65 62.37,64.52 62.37,64.27 62.24,64.14 61.74,64.14 61.61,64.01 61.61,63.76 61.74,63.63 62.24,63.63 62.37,63.5 62.37,63.17 62.24,63.05 61.58,63.05 61.41,62.87 61.41,62.06 61.17,61.82 60.82,61.82 60.7,61.93 v1(60.7,62.27)
  BOTTOM w0.102: 62.59,88.32 63.58,89.3 63.58,90.43 U18.L33
  BOTTOM w0.108: 62.59,88.32 v1(62.59,87.71)
  BOTTOM w0.178: v1(60.7,62.27) 58.73,64.25 CN17.79
M_B_DQ27: length 37.9
  IN1 w0.127: v1(60.69,63.68) 60.99,63.68 61.11,63.79 61.11,64.67 60.93,64.85 60.72,64.85 60.59,64.98 60.59,65.55 60.72,65.68 61.79,65.68 61.91,65.8 61.91,66.06 61.79,66.19 60.67,66.19 60.54,66.31 60.54,66.57 60.67,66.69 61.79,66.69 61.91,66.82 61.91,67.07 61.79,67.2 60.74,67.2 60.61,67.33 60.61,67.67 60.74,67.8 61.71,67.8 61.86,67.95 61.86,68.82 62.21,69.17 62.21,83.01 61.83,83.39 61.83,85.62 v1(61.63,85.82)
  BOTTOM w0.102: U18.L32 63.35,91 63.35,90.37 63.38,90.35 63.38,89.39 62.16,88.18 62.16,86.35 v1(61.63,85.82)
  BOTTOM w0.178: CN17.83 59.73,64.41 60.46,63.68 v1(60.69,63.68)
M_B_DQ28: length 38.7
  IN1 w0.127: v1(58.47,85.81) 58.03,85.37 58.03,84.56 58.27,84.32 58.27,82.35 58.75,81.86 58.75,73.87 56.68,71.8 56.68,69.96 56.15,69.42 56.15,63.12 55.91,62.88 55.91,61.75 56.22,61.45 56.97,61.45 57.16,61.25 v1(57.16,60.81)
  BOTTOM w0.102: U18.H32 60.94,91.38 60.94,90.76 60.97,90.73 60.97,90.72 60.97,90.72 60.97,90.2 60.97,90.2 60.97,89.5 58.47,87.01 v1(58.47,85.81)
  BOTTOM w0.178: CN17.66 55.48,59.12 57.16,60.81 v1(57.16,60.81)
M_B_DQ29: length 38.8
  IN1 w0.127: v1(58.7,84.34) 58.7,82.52 59.18,82.04 59.18,73.69 57.11,71.62 57.11,69.34 56.99,69.21 56.71,69.21 56.58,69.09 56.58,68.83 56.71,68.71 57.37,68.71 57.49,68.58 57.49,68.33 57.37,68.2 56.71,68.2 56.58,68.07 56.58,67.82 56.71,67.69 56.96,67.69 57.09,67.56 57.09,67.31 56.96,67.18 56.71,67.18 56.58,67.06 56.58,62.98 56.36,62.76 56.36,62.02 56.46,61.91 56.99,61.91 57.12,62.04 v1(57.12,62.4)
  BOTTOM w0.102: v1(58.7,84.34) 58.89,84.53 58.89,87.14 61.25,89.5 U18.H33
  BOTTOM w0.178: CN17.67 55.73,63.8 v1(57.12,62.4)
M_B_DQ30: length 38.6
  IN1 w0.127: v1(62.62,86.33) 62.62,83.69 63.07,83.24 63.07,68.81 62.8,68.54 62.8,62.87 v1(60.72,60.79)
  BOTTOM w0.102: U18.L30 63.15,92.4 63.15,91.99 63.41,91.73 63.65,91.73 63.95,91.43 63.95,90.37 63.78,90.2 63.78,89.22 63.02,88.46 63.02,86.73
  BOTTOM w0.127: 63.02,86.73 v1(62.62,86.33)
  BOTTOM w0.178: v1(60.72,60.79) 58.97,59.04 CN17.80
M_B_DQ31: length 37.6
  IN1 w0.127: v1(60.7,59.44) 63.23,61.98 63.23,68.36 63.5,68.63 63.5,83.37 63.14,83.74 63.14,88.4 63.99,89.26 v1(63.99,92.51)
  BOTTOM w0.108: v1(63.99,92.51) 63.65,92.17 U18.L31
  BOTTOM w0.178: v1(60.7,59.44) 59.97,58.72 CN17.84
M_B_DQ32: length 37.1
  IN1 w0.127: v1(82.19,89.08) 81.6,89.67 81.6,91.17 81.73,91.29 82.72,91.29 82.85,91.17 82.85,88.47 83.17,88.15 83.17,85.5 82.26,84.6 82.26,70.88 82.43,70.71 82.43,64.12 82.54,64.01 82.89,64.01 v1(83.22,64.34)
  BOTTOM w0.102: v1(82.19,89.08) 81.62,89.65 81.62,90.03 81.65,90.07 81.65,90.08 81.77,90.2 81.77,90.75 81.57,90.95 81.57,91.78 U18.AN31
  BOTTOM w0.178: v1(83.22,64.34) 83.23,64.34 CN17.169
M_B_DQ33: length 37.8
  IN1 w0.127: v1(83.22,63.02) 83.38,62.87 83.78,62.87 83.92,63 83.92,64.64 83.71,64.85 82.97,64.85 82.86,64.96 82.86,65.3 82.99,65.43 83.8,65.43 83.88,65.51 83.88,65.84 83.78,65.94 82.99,65.94 82.86,66.06 82.86,70.89 82.69,71.06 82.69,84.1 v1(83.8,85.2)
  BOTTOM w0.102: U18.AP32 82.05,91.35 82.37,91.02 82.37,90.77 82.33,90.73 82.33,90.22 82.61,89.94 82.61,88.51 82.81,88.31 82.81,87.41
  BOTTOM w0.108: v1(83.8,85.2) 82.96,85.2 82.81,85.36 82.81,87.41
  BOTTOM w0.178: CN17.173 84.23,63.01 84.02,62.81 83.44,62.81 v1(83.22,63.02)
M_B_DQ34: length 37.7
  IN1 w0.127: v1(87.71,60.18) 87.15,60.18 86.83,60.51 86.83,69.38 86.09,70.12 86.09,71.33 85.28,72.13 85.28,82.97 86.1,83.79 v1(86.1,85.84)
  BOTTOM w0.102: U18.AT32 83.97,91.38 83.97,90.77 83.94,90.74 83.94,89.86 84.34,89.46 84.34,89.14 84.36,89.12 84.36,89.1 84.89,88.57 84.89,87.41
  BOTTOM w0.108: v1(86.1,85.84) 85.67,85.84 84.89,86.63 84.89,87.41
  BOTTOM w0.178: CN17.182 86.48,58.95 v1(87.71,60.18)
M_B_DQ35: length 37.8
  IN1 w0.127: v1(86.74,85.09) 87.15,84.68 87.15,83.62 86.15,82.61 86.15,72.49 86.28,72.36 86.6,72.36 86.73,72.49 86.73,72.78 86.86,72.91 87.11,72.91 87.24,72.78 87.24,72.49 87.36,72.36 87.66,72.36 87.79,72.23 87.79,71.8 87.67,71.68 87.14,71.68 87.01,71.55 87.01,71.3 87.14,71.17 87.67,71.17 87.79,71.04 87.79,70.79 87.67,70.66 87.28,70.66 87.15,70.53 87.15,70.28 87.28,70.15 87.67,70.15 87.79,70.03 87.79,64.45 v1(87.72,64.37)
  BOTTOM w0.102: 85.3,87.41 85.3,87.51 85.17,87.64 85.17,88.59 84.62,89.15 84.62,89.15 84.54,89.23 84.54,89.58 84.14,89.99 84.14,90.64 84.45,90.95 U18.AU32
  BOTTOM w0.108: 85.3,87.41 85.3,86.83 85.69,86.43 88.05,86.43 88.17,86.31 88.17,86.04 88.06,85.93 86.87,85.93 86.74,85.81 v1(86.74,85.09)
  BOTTOM w0.178: CN17.187 87.72,64.38 v1(87.72,64.37)
M_B_DQ36: length 37.1
  IN1 w0.127: v1(82.2,85.83) 81.4,85.03 81.4,70.52 81.57,70.35 81.57,58.18 81.73,58.02 83.17,58.02 83.31,58.15 v1(83.31,58.77)
  BOTTOM w0.102: 81.46,87.41 81.46,88.13 81.16,88.43 81.16,90.41 U18.AN33
  BOTTOM w0.108: 81.46,87.41 81.46,87.28 81.77,86.97 81.77,86.26 v1(82.2,85.83)
  BOTTOM w0.178: CN17.170 83.48,58.6 v1(83.31,58.77)
M_B_DQ37: length 36.9
  IN1 w0.127: v1(83.31,60.09) 83.1,59.89 82.26,59.89 82,60.15 82,70.53 81.83,70.7 81.83,84.87 82.73,85.77 82.73,87.68 v1(82.21,88.2)
  BOTTOM w0.102: v1(82.21,88.2) 81.42,89 81.42,90.24 81.55,90.37 81.55,90.65 81.25,90.95 U18.AN32
  BOTTOM w0.178: v1(83.31,60.09) 84.48,58.92 CN17.174
M_B_DQ38: length 37.6
  IN1 w0.127: v1(83.64,89.09) 84.06,89.09 84.73,88.43 85.52,87.64 85.52,83.81 84.85,83.15 84.85,71.95 85.66,71.15 85.66,69.94 86.4,69.2 86.4,60.21 v1(87.72,58.88)
  BOTTOM w0.102: U18.AR31 83.32,91.63 83.32,90.79 83.5,90.6 83.5,89.23 v1(83.64,89.09)
  BOTTOM w0.178: v1(87.72,58.88) 87.48,58.63 CN17.186
M_B_DQ39: length 38.1
  IN1 w0.127: v1(87.72,63.07) 87.72,60.88 87.6,60.76 87.39,60.76 87.26,60.89 87.26,69.56 86.52,70.3 86.52,71.51 85.72,72.31 85.72,82.79 v1(86.7,83.78)
  BOTTOM w0.102: 84.51,87.41 84.51,88.62 84.08,89.06 84.08,89.36 83.73,89.71 83.73,90.82 U18.AT33
  BOTTOM w0.108: v1(86.7,83.78) 85.02,85.46 85.02,85.81 84.51,86.32 84.51,87.41
  BOTTOM w0.178: CN17.183 86.72,64.07 v1(87.72,63.07)
M_B_DQ40: length 39.3
  IN1 w0.127: v2(84.86,92.47) 84.37,91.99 84.37,89.89 85.57,88.69 86.18,88.69 86.76,88.11 86.76,87.5 87.18,87.09 87.18,85.91 88.14,84.94 88.14,82.78 87.44,82.08 87.44,74.41 89.09,72.76 89.09,61.76 89.17,61.68 v1(89.55,61.68)
  BOTTOM w0.178: v2(84.86,92.47) 84.45,92.88 U18.AU30 ; CN17.191 88.72,64.64 88.58,64.5 88.58,62.64 v1(89.55,61.68)
M_B_DQ41: length 39.3
  IN1 w0.127: v1(89.55,64.31) 89.61,64.37 89.61,72.85 87.87,74.59 87.87,79.73 88,79.86 88.35,79.86 88.48,79.99 88.48,80.26 88.38,80.37 88,80.37 87.87,80.49 87.87,80.75 88,80.87 88.35,80.87 88.48,81 88.48,81.26 88.35,81.38 88,81.38 87.87,81.51 87.87,81.9 87.97,82 88.35,82 88.58,82.22 88.58,84.84 87.43,85.98 87.43,87.17 87,87.6 87,88.28 86.02,89.26 86.02,90.53 86.12,90.63 86.12,91.44 85.5,92.06 85.23,92.06 85.03,91.85 85.03,91.6 85.56,91.07 85.56,89.79 v1(85.37,89.6)
  BOTTOM w0.102: v1(85.37,89.6) 85.54,89.77 85.54,90.79 85.64,90.89 85.64,91.62 85.56,91.7 U18.AV32
  BOTTOM w0.178: v1(89.55,64.31) 89.72,64.48 CN17.195
M_B_DQ42: length 39.8
  IN1 w0.127: v1(91.47,62.92) 92.21,63.66 92.21,72.79 92.37,72.96 92.66,72.96 92.87,73.17 92.87,73.57 92.69,73.74 92.39,73.74 90.47,75.66 90.47,78.12 91.17,78.82 91.17,79.26 91.29,79.39 91.8,79.39 91.93,79.51 91.93,79.77 91.8,79.89 91.29,79.89 91.17,80.02 91.17,80.28 91.29,80.4 92.22,80.4 92.34,80.53 92.34,80.78 92.22,80.91 91.29,80.91 91.17,81.04 91.17,81.29 91.29,81.42 91.86,81.42 91.99,81.55 91.99,81.8 91.86,81.93 91.29,81.93 91.17,82.05 91.17,84.11 88.88,86.39 88.88,89.04 v1(89.22,89.38)
  BOTTOM w0.102: U18.BA33 88.67,89.38 v1(89.22,89.38)
  BOTTOM w0.178: CN17.207 92.72,64.18 v1(91.47,62.92)
M_B_DQ43: length 39.3
  IN1 w0.127: v1(91.47,64.23) 91.77,64.53 91.77,73.74 90.03,75.48 90.03,78.3 90.74,79 90.74,83.68 90,84.41 90,84.86 88.65,86.21 88.65,89.35 88.25,89.75 88.25,90.3 88.35,90.4 89.07,90.4 89.19,90.28 89.19,90.05 89.37,89.87 89.6,89.87 89.78,90.05 89.78,90.81 89.65,90.94 88.35,90.94 88.25,91.04 88.25,91.32 88.38,91.45 89.12,91.45 89.24,91.57 89.24,91.85 88.94,92.16 87.84,92.16 87.46,91.77 v1(87.46,91.17)
  BOTTOM w0.108: v1(87.46,91.17) 87.14,91.49 87.06,91.49 U18.AY32
  BOTTOM w0.178: CN17.203 91.72,64.49 v1(91.47,64.23)
M_B_DQ44: length 39.7
  IN1 w0.127: v1(89.97,59.39) 89.45,59.39 89.32,59.26 89.32,58.27 89.14,58.09 88.56,58.09 88.44,58.22 88.44,60.63 88.23,60.84 88.23,72.41 86.58,74.05 86.58,82.43 87.41,83.26 87.41,85.03 86.6,85.84 86.6,86.65 v1(86.39,86.86)
  BOTTOM w0.102: 85.58,87.41 85.58,88.48 84.82,89.23 84.82,89.24 84.75,89.31 84.75,89.72 84.45,90.02 U18.AU33
  BOTTOM w0.108: v1(86.39,86.86) 86.32,86.93 85.85,86.93 85.58,87.21 85.58,87.41
  BOTTOM w0.178: v1(89.97,59.39) 89.48,58.89 CN17.194
M_B_DQ45: length 40
  IN1 w0.127: v1(86.06,88.21) 86.52,87.75 86.52,87.41 86.87,87.06 86.87,85.89 87.71,85.05 87.71,82.96 87.01,82.26 87.01,74.23 88.66,72.58 88.66,61.07 88.96,60.76 88.96,60.15 89.1,60.01 89.43,60.01 89.55,60.14 89.55,60.64 89.62,60.71 v1(89.95,60.71)
  BOTTOM w0.102: v1(86.06,88.21) 86.06,88.29 84.95,89.4 84.95,89.8 84.7,90.06 84.7,90.32 84.77,90.39 84.77,91.78 U18.AU31
  BOTTOM w0.178: v1(89.95,60.71) 88.57,59.33 88.57,58.53 88.48,58.43 CN17.190
M_B_DQ46: length 40.8
  IN1 w0.127: v1(89.32,87.18) 89.32,86.37 91.6,84.08 91.6,82.97 96.43,78.14 96.43,75.66 92.64,71.87 92.64,63.43 92.53,63.32 92.53,59.18 v1(92.98,58.73)
  BOTTOM w0.102: 89.21,87.28 88.22,88.27 88.22,89 86.84,90.38 86.84,90.46 86.52,90.78 86.52,91.63 U18.AW31
  BOTTOM w0.108: 89.21,87.28 v1(89.32,87.18)
  BOTTOM w0.178: CN17.208 v1(92.98,58.73)
M_B_DQ47: length 39.8
  IN1 w0.127: v1(89.31,88.58) 89.85,88.05 89.85,86.46 90.8,85.51 92.05,84.26 92.05,83.13 96.87,78.32 96.87,75.48 93.07,71.69 93.07,63.15 92.98,63.06 v1(92.98,60.08)
  BOTTOM w0.102: v1(89.31,88.58) 88.95,88.58 88.3,89.23 87.13,90.4 87.13,90.61 U18.AY33
  BOTTOM w0.178: CN17.204 91.98,59.07 v1(92.98,60.08)
M_B_DQ48: length 46
  IN1 w0.127: v1(93.74,63.02) 93.54,62.82 93.54,62.08 93.74,61.88 93.74,61.47 93.41,61.14 93.41,60.69 93.51,60.58 93.84,60.58 94.27,61.02 94.27,64.65 93.97,64.95 93.97,71.37 97.73,75.13 97.73,78.67 92.91,83.49 92.91,84.49 90.79,86.62 90.79,90.72 90.91,90.85 91.27,90.85 91.4,90.72 v1(91.4,90.54)
  BOTTOM w0.102: U18.BC31 89.39,92.26 89.69,92.26 91.4,90.56 v1(91.4,90.54)
  BOTTOM w0.178: CN17.215 94.72,62.71 94.56,62.55 93.91,62.55 93.74,62.72 v1(93.74,63.02)
M_B_DQ49: length 45.3
  IN1 w0.127: v1(87.15,92.11) 87.41,92.37 87.41,94.06 87.54,94.19 87.8,94.19 87.92,94.06 87.92,92.79 88.05,92.66 88.3,92.66 88.43,92.79 88.43,94.75 88.56,94.87 88.84,94.87 88.96,94.75 88.96,92.79 90.32,91.44 90.32,86.48 91.04,85.75 92.48,84.32 92.48,83.31 97.3,78.49 97.3,75.3 93.54,71.55 93.54,64.53 v1(93.72,64.34)
  BOTTOM w0.102: v1(87.15,92.11) 87.83,92.79 87.94,92.79 U18.BB30
  BOTTOM w0.178: CN17.211 v1(93.72,64.34)
M_B_DQ50: length 46.5
  IN1 w0.127: v1(90.59,94.04) 91.64,94.04 93.48,92.2 93.48,90.82 94.49,89.81 94.49,89.03 97.25,86.26 97.25,85.26 102.05,80.46 102.05,72.24 99.26,69.46 99.26,60.41 v1(98.34,59.49)
  BOTTOM w0.102: U18.BB28 88.52,94.23 89.04,94.23 89.14,94.32 89.62,94.32 89.9,94.04 v1(90.59,94.04)
  BOTTOM w0.178: v1(98.34,59.49) 97.87,59.02 97.87,58.52 97.98,58.41 CN17.228
M_B_DQ51: length 45.9
  IN1 w0.127: v1(91.07,93.6) 91.7,93.6 93.22,92.08 93.22,90.57 94.1,89.69 94.1,88.8 96.82,86.08 96.82,85.08 101.62,80.28 101.62,73.51 101.22,73.12 101.22,72.94 101.59,72.58 101.59,72.4 101.41,72.22 101.23,72.22 100.86,72.58 100.68,72.58 100.5,72.4 100.5,72.22 100.79,71.93 100.79,71.75 100.61,71.57 100.43,71.57 100.15,71.86 99.97,71.86 99.79,71.68 99.79,71.5 100.11,71.18 100.11,71 99.93,70.82 99.75,70.82 99.43,71.15 99.25,71.15 98.83,70.73 98.83,64.25 98.77,64.19 98.44,64.19 v1(98.27,64.37)
  BOTTOM w0.102: v1(91.07,93.6) 91.07,94.17 90.25,94.99 89.83,94.99 89.73,94.89 89.11,94.89 89.09,94.91 88.82,94.91 88.78,94.88 88.32,94.88 88.13,95.07 87.27,95.07 U18.AY27
  BOTTOM w0.178: CN17.229 98.23,64.41 v1(98.27,64.37)
M_B_DQ52: length 46.3
  IN1 w0.127: v1(91.4,88.3) 91.19,88.1 91.19,86.83 91.66,86.36 93.37,84.65 93.37,83.65 98.16,78.85 98.16,74.95 94.85,71.64 94.85,71.36 95.01,71.2 95.18,71.2 95.31,71.07 95.31,70.79 95.18,70.67 94.53,70.67 94.41,70.54 94.41,70.22 94.53,70.09 95.18,70.09 95.31,69.96 95.31,69.71 95.18,69.58 94.53,69.58 94.41,69.45 94.41,69.2 94.53,69.07 95.01,69.07 95.14,68.95 95.14,68.69 95.01,68.57 94.53,68.57 94.41,68.44 94.41,65.07 94.63,64.85 94.63,61.3 94.93,60.99 94.93,60.25 94.73,60.05 94.4,60.05 94.28,60.18 v1(94.28,60.31)
  BOTTOM w0.102: v1(91.4,88.3) 90.53,89.17 90.53,89.22 88.7,91.05 88.7,91.15 U18.BB32
  BOTTOM w0.178: CN17.216 94.98,58.42 95.14,58.58 95.14,60.73 94.98,60.88 94.46,60.88 94.28,60.7 v1(94.28,60.31)
M_B_DQ53: length 46.6
  IN1 w0.127: v1(94.29,58.95) 94.29,58.24 94.15,58.1 93.65,58.1 93.51,57.95 93.51,57.56 93.68,57.38 95.24,57.38 95.37,57.51 95.37,61.17 95.03,61.5 95.03,65.97 94.84,66.17 94.84,67.78 95.74,68.68 95.74,71.91 98.59,74.77 98.59,79.03 93.8,83.82 93.8,84.83 v1(91.62,87.01)
  BOTTOM w0.102: 91.22,87.41 90.91,87.72 90.91,88.21 90.28,88.84 90.28,89.18 88.53,90.92 88.43,90.92 87.75,91.6 U18.BA31
  BOTTOM w0.108: 91.22,87.41 v1(91.62,87.01)
  BOTTOM w0.178: CN17.212 93.98,58.63 v1(94.29,58.95)
M_B_DQ54: length 46.5
  IN1 w0.127: v1(92.79,91.5) 92.79,90.44 93.71,89.52 93.71,88.58 96.39,85.9 96.39,84.9 101.18,80.11 101.18,73.69 98.4,70.91 98.4,65.35 97.75,64.71 97.75,62.03 98.26,61.52 98.64,61.52 98.82,61.7 98.82,62.31 98.67,62.46 98.39,62.46 98.29,62.57 v1(98.29,63.07)
  BOTTOM w0.102: U18.BC29 89.61,93.54 90.2,93.54 92.11,91.63 92.67,91.63 v1(92.79,91.5)
  BOTTOM w0.178: CN17.225 97.23,64.75 97.37,64.61 97.37,62.59 97.51,62.45 98.17,62.45 98.29,62.57 v1(98.29,63.07)
M_B_DQ55: length 46.3
  IN1 w0.127: v1(92.04,92.63) 92.04,91.9 92.31,91.63 92.31,90.41 93.3,89.42 93.3,88.38 93.49,88.2 95.96,85.73 95.96,84.72 100.75,79.93 100.75,73.87 97.96,71.08 97.96,65.62 97.38,65.04 97.38,62.01 97.11,61.75 97.11,61.09 97.45,60.75 98.21,60.75 v1(98.33,60.86)
  BOTTOM w0.102: v1(92.04,92.63) 92.03,92.62 91.41,92.62 90.28,93.75 89.85,93.75 89.48,94.11 89.21,94.11 88.9,93.8 U18.BB29
  BOTTOM w0.178: CN17.224 96.98,59.51 v1(98.33,60.86)
M_B_DQ56: length 53.5
  IN1 w0.127: v1(103.72,63.65) 103.25,63.65 103.16,63.73 103.16,64.72 103.29,64.85 104.1,64.85 104.18,64.78 104.18,64.15 104.28,64.04 104.56,64.04 104.66,64.14 104.66,65.16 104.48,65.33 103.49,65.33 103.37,65.46 103.37,65.69 103.49,65.82 104.59,65.82 104.66,65.89 104.66,66.43 105.18,66.94 105.18,68.37 105.93,69.12 105.93,82.08 101.57,86.44 101.57,88.83 95.86,94.54 95.49,94.54 95.31,94.37 95.31,94.14 v1(95.56,93.88)
  BOTTOM w0.102: U18.BB27 88.9,95.4 89.21,95.71 90.39,95.71 91.02,95.08 91.17,95.08
  BOTTOM w0.108: 91.17,95.08 93.39,92.86 94.54,92.86 v1(95.56,93.88)
  BOTTOM w0.178: v1(103.72,63.65) 103.64,63.65 103.23,64.06 CN17.249
M_B_DQ57: length 53.5
  IN1 w0.127: v1(100.12,64.34) 100.12,69.1 102.91,71.89 102.91,80.82 98.51,85.22 98.51,85.55 98.41,85.65 98.22,85.65 98.12,85.76 98.12,86.14 98.23,86.25 98.37,86.25 98.46,86.34 98.46,86.85 98.31,87 98.11,87 98.02,86.91 97.84,86.91 97.64,87.11 97.64,87.29 98.14,87.78 98.14,87.96 97.96,88.14 97.78,88.14 97.28,87.64 97.1,87.64 96.92,87.82 96.92,88 97.42,88.5 97.42,88.68 97.24,88.86 97.06,88.86 96.54,88.34 96.36,88.34 96.18,88.52 96.18,88.7 96.7,89.22 96.7,89.4 96.52,89.58 96.34,89.58 95.81,89.05 95.63,89.05 95.45,89.23 95.45,89.41 95.98,89.94 95.98,90.12 95.8,90.3 95.62,90.3 95.32,90 95.14,90 94.4,90.74 94.4,91.06 94.5,91.17 94.5,91.39 94.37,91.52 94.24,91.52 94.01,91.75 94.01,92.35 94.14,92.47 94.48,92.47 94.6,92.6 94.6,92.84 94.48,92.97 94.14,92.97 94.01,93.1 v1(94.01,93.3)
  BOTTOM w0.102: U18.BB26 88.47,95.88 89.09,95.88 89.12,95.91 90.48,95.91 91,95.39 91.19,95.39
  BOTTOM w0.108: 91.19,95.39 92.72,93.86 93.41,93.86 93.54,93.99 93.54,95.23 93.66,95.36 93.88,95.36 94.01,95.23 v1(94.01,93.3)
  BOTTOM w0.178: CN17.237 100.23,64.44 v1(100.12,64.34)
M_B_DQ58: length 53.2
  IN1 w0.127: v1(90.82,97.91) 90.14,97.24 89.64,97.24 89.52,97.11 89.52,96.27 89.39,96.14 89.14,96.14 89.01,96.27 89.01,97.24 88.88,97.36 88.53,97.36 88.41,97.24 88.41,95.79 88.61,95.59 89.93,95.59 91.15,94.37 91.69,94.37 93.76,92.3 93.76,90.97 94.89,89.84 94.89,89.24 97.69,86.44 97.69,85.44 102.48,80.64 102.48,72.06 99.69,69.28 99.69,63.48 v1(100.12,63.05)
  BOTTOM w0.102: U18.BB24 88.49,97.46 89.07,97.46 89.12,97.51 90.41,97.51 v1(90.82,97.91)
  BOTTOM w0.178: v1(100.12,63.05) 99.31,63.86 99.31,64.64 99.23,64.72 CN17.233
M_B_DQ59: length 53.2
  IN1 w0.127: v1(91.51,97.91) 91.51,97.39 93.98,94.92 96.1,94.92 102,89.01 102,86.62 106.37,82.25 106.37,67.33 106.19,67.16 105.07,66.03 105.07,63.67 v1(103.72,62.32)
  BOTTOM w0.102: v1(91.51,97.91) 91.08,98.33 89.81,98.33 89.56,98.08 89.12,98.08 89.08,98.12 88.82,98.12 88.73,98.03 88.37,98.03 88.14,98.26 87.36,98.26 87.02,98.6 U18.AY23
  BOTTOM w0.178: CN17.245 102.23,64.75 102.41,64.57 102.41,63.64 v1(103.72,62.32)
M_B_DQ60: length 54
  IN1 w0.127: v1(95.02,90.78) 95.02,91.18 95.14,91.29 95.44,91.29 98.98,87.76 98.98,85.37 103.34,81 103.34,71.71 100.62,68.99 100.62,62.48 100.5,62.35 99.84,62.35 99.71,62.23 99.71,61.97 99.84,61.85 100.5,61.85 100.62,61.72 100.62,61.47 100.5,61.34 99.84,61.34 99.71,61.21 99.71,60.96 99.84,60.83 100.5,60.83 100.62,60.7 100.62,60.2 100.53,60.11 v1(100.17,60.11)
  BOTTOM w0.102: 93.47,92.06 90.33,95.2 89.74,95.2 89.64,95.1 89.2,95.1 89.18,95.12 88.73,95.12 88.73,95.11 88.72,95.11 88.69,95.09 88.41,95.09 88.1,95.4 U18.BA27
  BOTTOM w0.108: v1(95.02,90.78) 94.32,90.78 93.47,91.64 93.47,92.06
  BOTTOM w0.178: v1(100.17,60.11) 99.57,60.71 99.16,60.71 98.98,60.53 CN17.232
M_B_DQ61: length 53.4
  IN1 w0.127: v1(100.17,58.81) 100.17,58.3 100.04,58.17 98.41,58.17 98.29,58.04 98.29,57.69 98.41,57.56 100.85,57.56 101.05,57.76 101.05,68.81 103.78,71.53 103.78,81.18 99.41,85.55 99.41,87.94 95.52,91.83 94.73,91.83 v1(94.5,92.05)
  BOTTOM w0.102: 93.58,92.47 93.35,92.47 90.42,95.4 U18.BC27
  BOTTOM w0.108: 93.58,92.47 93.99,92.05 v1(94.5,92.05)
  BOTTOM w0.178: CN17.236 99.98,58.62 v1(100.17,58.81)
M_B_DQ62: length 53.2
  IN1 w0.127: v1(92.97,96.95) 92.97,96.32 93.98,95.32 96.3,95.32 102.44,89.19 102.44,86.79 106.8,82.43 106.8,67.15 106.62,66.98 105.91,66.26 105.91,65.03 106.01,64.93 106.01,63.86 104.61,62.47 104.61,62.21 104.74,62.08 105.14,62.08 105.27,61.95 105.27,61.7 105.14,61.57 104.74,61.57 104.61,61.45 104.61,61.08 v1(103.7,60.16)
  BOTTOM w0.102: U18.BC25 89.45,97.1 91.91,97.1
  BOTTOM w0.108: v1(92.97,96.95) 92.06,96.95 91.91,97.1
  BOTTOM w0.178: v1(103.7,60.16) 102.48,58.94 CN17.246
M_B_DQ63: length 53.5
  IN1 w0.127: v1(94.06,95.83) 96.4,95.83 102.87,89.36 102.87,86.97 107.23,82.61 107.23,66.97 106.41,66.16 106.41,63.56 105.71,62.85 105.71,60.86 v1(103.7,58.85)
  BOTTOM w0.102: U18.BB25 88.9,97 89.2,97.3 92.71,97.3
  BOTTOM w0.108: v1(94.06,95.83) 94.06,96.52 93.23,97.36 92.77,97.36 92.71,97.3
  BOTTOM w0.178: CN17.250 103.48,58.63 v1(103.7,58.85)
M_B_DQS0: length 55.9
  IN1 w0.114: v1(52.53,95.72) 52.52,95.72 52.29,95.5 52.29,95.3 52.07,95.08 50.78,95.08 50.59,95.27 50.59,95.97 50.49,96.07 50.24,96.07 49.92,95.76 49.92,95.31 49.7,95.08 49.46,95.08 43.81,89.42 43.81,88.83 43.55,88.57 42.96,88.57 42.65,88.26 42.65,88.07 42.74,87.98 43.54,87.98 43.81,87.71 43.81,86.76 43.48,86.44 43.12,86.44 42.63,86.93 42.33,86.93 42.24,86.83 42.24,86.47 42.7,86 42.7,85.66 39.94,82.89 39.94,65.57 40.03,65.47 41.1,65.47 41.5,65.07 41.5,63.09 41.61,62.98 41.94,62.98 v1(42.23,63.27)
  BOTTOM w0.102: v1(52.53,95.72) 52.43,95.72 52.26,95.56 52.26,95.37 52.39,95.25 53.15,95.25 53.96,96.06 55.12,96.06 55.19,96.14 55.46,96.14 55.82,96.5 56.45,96.5 U18.B26
  BOTTOM w0.127: v1(42.23,63.27) 42.23,63.18 42.09,63.04 41.68,63.04 41.59,63.12 41.59,64.17 41.9,64.48 41.95,64.48 42.22,64.75 CN17.13
M_B_DQS1: length 45.6
  IN1 w0.114: v1(53.45,90.7) 53.1,91.05 52.97,91.05 52.82,90.9 52.82,88.94 50.06,86.19 50.06,83.86 45.55,79.34 45.55,70.12 47.66,68.01 47.66,66.3 47.39,66.02 47.39,63.16 47.17,62.94 47.17,61.61 47.32,61.46 47.62,61.46 47.83,61.66 48.21,61.66 48.69,61.18 48.69,60.01 48.4,59.72 48.24,59.72 v1(47.97,59.45)
  BOTTOM w0.102: v1(53.45,90.7) 53.76,91.01 53.92,91.01 53.93,91.01 53.99,91.01 54.11,91.13 54.11,91.14 54.21,91.24 54.21,91.49 54.81,92.09 55.41,92.68 56.43,92.68 U18.B30
  BOTTOM w0.127: v1(47.97,59.45) 47.73,59.7 47.42,59.7 47.34,59.61 47.34,58.59 47.48,58.45 CN17.34
M_B_DQS2: length 40.5
  IN1 w0.114: v1(51.82,62.83) 52.02,63.04 52.56,63.04 52.78,63.25 52.78,64.7 52.56,64.92 52.29,64.92 52.17,65.04 52.17,65.4 52.33,65.56 52.6,65.56 52.78,65.74 52.78,66.47 52.54,66.71 52.54,69.12 52.65,69.23 52.96,69.23 53.2,69.47 53.2,70.16 52.96,70.4 52.65,70.4 52.54,70.51 52.54,71.1 52.65,71.21 52.94,71.21 53.2,71.47 53.2,72.44 55.84,75.08 55.84,78.72 54.81,79.74 54.81,85.79 56.78,87.76 57.49,87.76 57.67,87.58 58.22,87.58 58.53,87.89 v2(58.53,88.41)
  BOTTOM w0.102: U18.F32 59.65,91.33 59.35,91.02 59.35,90.75 59.36,90.74 59.36,90.26 58.04,88.95 58.04,88.72 58.35,88.41 v2(58.53,88.41)
  BOTTOM w0.127: v1(51.82,62.83) 52.01,63.02 52.52,63.02 52.73,63.23 CN17.55
M_B_DQS3: length 38.4
  IN1 w0.114: v1(58.38,59.52) 58.65,59.8 59.02,59.8 59.81,60.59 59.81,69.08 61.45,70.73 61.45,83 61.08,83.37 61.08,87.22 61.62,87.77 62.04,87.77 63.1,88.83 63.1,89.13 62.94,89.29 v2(62.94,89.54)
  BOTTOM w0.102: U18.K32 62.49,91.34 62.49,90.77 62.56,90.71 62.56,90.29 62.47,90.2 62.47,89.81 62.75,89.54 v2(62.94,89.54)
  BOTTOM w0.127: v1(58.38,59.52) 58.16,59.74 58.01,59.74 57.84,59.57 57.84,58.59 57.97,58.45 CN17.76
M_B_DQS4: length 37.4
  IN1 w0.114: v1(85.87,63.49) 85.87,63.3 85.76,63.19 85.42,63.19 85.32,63.29 85.32,64.5 85.51,64.69 85.51,67.09 85.13,67.47 84.4,67.47 84.27,67.6 84.27,67.99 84.38,68.1 85.37,68.1 85.62,68.36 85.62,68.91 85.37,69.16 84.38,69.16 84.27,69.27 84.27,69.75 84.39,69.88 84.67,69.88 84.9,70.11 84.9,70.84 84.1,71.64 84.1,83.46 84.28,83.65 85.13,84.5 85.13,86.73 84.03,87.83 v1(84.03,87.86)
  BOTTOM w0.102: U18.AR32 83.08,91.07 83.08,90.72 83.23,90.57 83.23,88.91 83.6,88.54 83.6,88.29 v1(84.03,87.86)
  BOTTOM w0.127: CN17.179 85.73,64.79 85.56,64.62 85.56,64.44 85.38,64.27 85.38,63.33 85.46,63.25 85.64,63.25 v1(85.87,63.49)
M_B_DQS5: length 39.7
  IN1 w0.114: v1(87.61,88.68) 87.81,88.88 88.05,88.88 88.14,88.78 88.14,86.03 89.46,84.71 89.46,83.99 89.76,83.68 89.76,79.4 89.06,78.7 89.06,75.08 90.8,73.34 90.8,65.59 90.6,65.39 90.6,62.37 90.84,62.13 91.05,62.13 91.15,62.03 91.15,61.6 91.06,61.51 90.84,61.51 90.6,61.27 90.6,59.99 90.96,59.63 91.22,59.63 v1(91.43,59.43)
  BOTTOM w0.102: U18.AW32 86.05,90.94 85.75,90.64 85.75,90.37 85.85,90.28 85.85,89.46 86.48,88.83 87.15,88.83 87.22,88.91 87.39,88.91 v1(87.61,88.68)
  BOTTOM w0.127: v1(91.43,59.43) 91.25,59.61 91.11,59.61 90.98,59.48 CN17.200
M_B_DQS6: length 46
  IN1 w0.114: v1(90.26,92.27) 90.95,92.27 91.24,91.98 91.6,91.98 92.04,91.54 92.04,90.12 92.89,89.27 92.89,87.72 95.2,85.41 95.2,84.41 100,79.61 100,74.19 97.14,71.33 97.14,67.62 96.88,67.36 96.41,67.36 96.24,67.19 96.24,66.74 96.36,66.63 97.07,66.63 97.31,66.38 97.31,65.85 97.04,65.57 96.36,65.57 96.24,65.46 96.24,63.44 96.33,63.35 96.71,63.35 96.8,63.44 v1(96.8,63.7)
  BOTTOM w0.102: v1(90.26,92.27) 90.26,92.13 90.34,92.05 90.51,92.05 90.74,92.28 90.74,92.41 90.03,93.13 89.29,93.13 89.09,93.32 88.81,93.32 88.76,93.27 88.36,93.27 88,93.64 88,93.73 87.93,93.8 U18.BA29
  BOTTOM w0.127: CN17.221 96.23,64.65 96.15,64.57 96.03,64.57 95.95,64.5 95.95,63.43 96.05,63.33 96.64,63.33 96.8,63.5 v1(96.8,63.7)
M_B_DQS7: length 53.8
  IN1 w0.114: v1(91.63,96.04) 91.74,95.93 92.56,95.93 94.05,94.44 94.29,94.44 95.29,93.43 95.9,93.43 100.81,88.52 100.81,86.13 105.18,81.76 105.18,69.48 104.42,68.73 104.42,67.46 102.5,65.54 102.5,60.03 102.13,59.66 101.82,59.66 v1(101.64,59.47)
  BOTTOM w0.102: U18.BA25 87.65,97.1 87.55,97.1 87.43,96.99 87.43,96.84 87.6,96.67 88.14,96.67 88.34,96.47 88.78,96.47 88.83,96.52 89.07,96.52 89.11,96.48 89.56,96.48 89.77,96.69 91.58,96.69 92.07,96.19 92.07,96.08 91.97,95.97 91.7,95.97 v1(91.63,96.04)
  BOTTOM w0.127: CN17.242 101.48,58.3 101.2,58.57 101.2,59.5 101.27,59.57 101.54,59.57 v1(101.64,59.47)
M_B_DQS#0: length 55.8
  IN1 w0.114: v1(51.87,95.75) 51.97,95.75 52.08,95.64 52.08,95.39 51.98,95.29 50.87,95.29 50.8,95.36 50.8,96.06 50.58,96.29 50.15,96.29 49.71,95.85 49.71,95.4 49.61,95.29 49.38,95.29 43.59,89.51 43.59,88.92 43.46,88.79 42.87,88.79 42.43,88.35 42.43,87.98 42.65,87.76 43.45,87.76 43.59,87.62 43.59,86.85 43.39,86.65 43.21,86.65 42.72,87.14 42.25,87.14 42.02,86.92 42.02,86.38 42.48,85.91 42.48,85.75 39.72,82.98 39.72,65.48 39.94,65.26 41.01,65.26 41.29,64.98 41.29,63 41.52,62.76 41.97,62.76 v1(42.23,62.51)
  BOTTOM w0.102: v1(51.87,95.75) 52.06,95.56 52.06,95.29 52.3,95.04 53.23,95.04 54.05,95.86 55.2,95.86 55.27,95.93 55.54,95.93 55.81,96.2 U18.A26
  BOTTOM w0.127: CN17.11 41.73,64.63 41.36,64.26 41.36,63.03 41.59,62.81 41.93,62.81 v1(42.23,62.51)
M_B_DQS#1: length 45.6
  IN1 w0.114: v1(53.45,91.54) 53.45,91.34 53.37,91.26 52.88,91.26 52.6,90.99 52.6,89.03 49.85,86.28 49.85,83.95 45.33,79.43 45.33,70.03 47.45,67.92 47.45,66.39 47.17,66.11 47.17,63.25 46.95,63.03 46.95,61.52 47.23,61.24 47.71,61.24 47.92,61.45 48.12,61.45 48.48,61.09 48.48,60.1 48.31,59.94 48.07,59.94 47.97,60.03 v1(47.97,60.22)
  BOTTOM w0.102: U18.A30 55.84,92.89 55.33,92.89 54.01,91.57 54.01,91.33 53.9,91.22
  BOTTOM w0.108: v1(53.45,91.54) 53.45,91.32 53.55,91.22 53.9,91.22
  BOTTOM w0.127: CN17.32 46.98,58.45 47.11,58.59 47.11,59.7 47.33,59.92 47.9,59.92 47.97,60 v1(47.97,60.22)
M_B_DQS#2: length 40.7
  IN1 w0.114: v1(51.82,63.59) 51.82,63.37 51.93,63.25 52.47,63.25 52.57,63.34 52.57,64.61 52.47,64.7 52.2,64.7 51.95,64.95 51.95,65.49 52.24,65.77 52.51,65.77 52.57,65.83 52.57,66.38 52.32,66.62 52.32,69.21 52.56,69.45 52.87,69.45 52.99,69.56 52.99,70.07 52.87,70.18 52.56,70.18 52.32,70.42 52.32,71.19 52.56,71.43 52.85,71.43 52.99,71.56 52.99,72.53 55.62,75.17 55.62,78.63 54.6,79.65 54.6,85.88 56.69,87.98 57.58,87.98 57.76,87.79 57.93,87.79 58.01,87.88 v1(58.01,87.99)
  BOTTOM w0.102: U18.E32 58.85,91.46 59.08,91.69 59.23,91.69 59.42,91.5 59.42,91.39 59.14,91.11 59.14,90.66 59.15,90.65 59.15,90.34 57.84,89.03 57.84,88.64 58.13,88.34 58.13,88.11 v1(58.01,87.99)
  BOTTOM w0.127: CN17.53 52.22,64.65 52.31,64.56 52.43,64.56 52.5,64.49 52.5,63.32 52.42,63.25 51.91,63.25 51.82,63.34 v1(51.82,63.59)
M_B_DQS#3: length 38.2
  IN1 w0.114: v1(62.46,89.1) 62.82,89.1 62.89,89.04 62.89,88.92 61.95,87.98 61.53,87.98 60.86,87.31 60.86,83.28 61.24,82.91 61.24,70.82 59.59,69.17 59.59,60.68 58.93,60.01 58.51,60.01 58.38,60.15 v1(58.38,60.29)
  BOTTOM w0.102: U18.J32 62.12,91.3 62.29,91.13 62.29,90.69 62.35,90.63 62.35,90.37 62.27,90.29 62.27,89.73 62.49,89.5 62.49,89.14 v1(62.46,89.1)
  BOTTOM w0.127: CN17.74 57.48,58.45 57.61,58.59 57.61,59.67 57.92,59.97 58.06,59.97 v1(58.38,60.29)
M_B_DQS#4: length 37.3
  IN1 w0.114: v1(85.87,62.72) 85.62,62.97 85.33,62.97 85.1,63.2 85.1,64.59 85.29,64.78 85.29,67 85.04,67.25 84.31,67.25 84.05,67.51 84.05,68.08 84.29,68.32 85.28,68.32 85.41,68.45 85.41,68.82 85.28,68.94 84.29,68.94 84.05,69.18 84.05,69.84 84.3,70.1 84.58,70.1 84.68,70.2 84.68,70.75 83.88,71.55 83.88,83.55 84.07,83.74 84.7,84.38 84.91,84.59 84.91,86.64 84.36,87.19 v1(84.03,87.19)
  BOTTOM w0.102: U18.AR33 83.03,90.32 83.03,88.83 83.4,88.46 83.4,88.2 83.62,87.99 83.62,87.61 83.82,87.41
  BOTTOM w0.108: 83.82,87.41 v1(84.03,87.19)
  BOTTOM w0.127: v1(85.87,62.72) 85.57,63.02 85.36,63.02 85.15,63.23 85.15,64.36 85.33,64.54 85.33,64.67 85.23,64.78 CN17.177
M_B_DQS#5: length 39.6
  IN1 w0.114: v1(91.43,60.19) 91.43,59.93 91.35,59.85 91.05,59.85 90.82,60.08 90.82,61.18 90.93,61.29 91.15,61.29 91.36,61.51 91.36,62.12 91.14,62.35 90.93,62.35 90.82,62.46 90.82,65.3 91.02,65.5 91.02,73.43 89.28,75.17 89.28,78.61 89.98,79.31 89.98,83.77 89.67,84.08 89.67,84.8 88.36,86.12 88.36,88.87 88.14,89.1 87.47,89.1 v2(87.18,89.38)
  BOTTOM w0.102: v2(87.18,89.38) 87.18,89.16 87.07,89.05 87.06,89.03 86.56,89.03 86.05,89.54 U18.AW33
  BOTTOM w0.127: v1(91.43,60.19) 91.43,59.96 91.31,59.84 91.01,59.84 90.75,59.57 90.75,58.63 90.64,58.53 90.55,58.53 90.48,58.45 CN17.198
M_B_DQS#6: length 46.2
  IN1 w0.114: v1(90.84,91.77) 91.51,91.77 91.82,91.45 91.82,90.03 92.68,89.18 92.68,87.63 94.99,85.32 94.99,84.32 99.78,79.52 99.78,74.28 96.93,71.42 96.93,67.71 96.79,67.57 96.32,67.57 96.03,67.27 96.03,66.65 96.27,66.41 96.98,66.41 97.1,66.29 97.1,65.94 96.95,65.79 96.27,65.79 96.03,65.55 96.03,63.35 96.24,63.14 96.6,63.14 v1(96.8,62.93)
  BOTTOM w0.102: v1(90.84,91.77) 90.84,92.08 90.95,92.18 90.95,92.49 90.11,93.33 89.37,93.33 89.18,93.52 88.72,93.52 88.67,93.47 88.45,93.47 88.2,93.72 88.2,93.86 87.96,94.1 87.25,94.1 U18.AY29
  BOTTOM w0.127: CN17.219 95.72,63.33 95.96,63.1 96.64,63.1 v1(96.8,62.93)
M_B_DQS#7: length 54
  IN1 w0.114: v1(92.16,95.52) 92.24,95.6 92.25,95.6 92.36,95.71 92.47,95.71 93.96,94.22 94.2,94.22 95.2,93.22 95.81,93.22 100.6,88.43 100.6,86.04 104.96,81.67 104.96,69.57 104.21,68.82 104.21,67.55 102.29,65.63 102.29,60.12 102.04,59.87 101.75,59.87 101.64,59.98 v1(101.64,60.23)
  BOTTOM w0.102: v1(92.16,95.52) 92.16,95.88 92.27,95.99 92.27,96.28 91.66,96.89 89.69,96.89 89.48,96.68 89.19,96.68 89.15,96.73 88.74,96.73 88.69,96.67 88.42,96.67 88.2,96.9 88.2,97.1 88,97.3 87.46,97.3 87.16,97 U18.AY25
  BOTTOM w0.127: CN17.240 100.98,59.6 101.18,59.8 101.37,59.8 101.64,60.07 v1(101.64,60.23)
M_B_EVENT#: length 41.8
  TOP w0.178: v1(72.62,56.14) 72.65,56.17 R636.2
  IN1 w0.127: v1(72.62,56.14) 74.06,57.58 74.06,61.45 74.65,62.04 74.65,64.62 75.16,65.13 75.16,66.07 74.65,66.58 74.65,84.98 74.26,85.37 74.26,88.56 75,89.3 v1(75.58,89.3)
  BOTTOM w0.102: U18.AG30 76.13,92.57 76.13,91.72 75.93,91.52 75.93,91.07 76,91 76,90.77 75.94,90.72 75.94,90.25 76.08,90.11 76.08,89.8 v1(75.58,89.3)
  BOTTOM w0.178: v1(72.62,56.14) 72.48,56.28 CN17.134
M_B_PARITY: length 10.6
  TOP w0.114: R635.1 80.76,60.7 v1(80,60.7)
  BOTTOM w0.114: v1(80,60.7) 76.1,60.7 74.73,62.07 CN17.143
M_B_RAS#: length 36.8
  IN1 w0.127: v1(80.22,60.08) 79.92,60.08 78.98,61.02 78.02,61.02 77.21,61.82 77.21,86.91 77.71,87.41 v1(77.71,88.55)
  BOTTOM w0.102: v1(77.71,88.55) 77.51,88.55 77.09,88.96 77.09,89.99 77.25,90.15 U18.AH33
  BOTTOM w0.178: CN17.152 78.97,59.13 79.92,60.08 v1(80.22,60.08)
M_B_RESET#: length 37.9
  IN1 w0.127: v1(65.98,58.86) 64.19,60.65 64.19,67.93 64.5,68.24 64.5,83.34 63.89,83.96 63.89,88.36 64.56,89.03 v1(64.56,90.38)
  BOTTOM w0.178: U18.T33 66.64,90.9 66.29,91.26 65.88,91.26 65.58,90.95 65.13,90.95 v1(64.56,90.38) ; v1(65.98,58.86) 65.97,58.85 CN17.108
M_B_WE#: length 33.2
  IN1 w0.127: v1(79.07,63.05) 78.66,63.45 78.66,85.08 79.01,85.43 v1(79.01,85.84)
  BOTTOM w0.102: v1(79.01,85.84) 78.3,86.55 78.3,87.12 78.13,87.28 78.13,89.97 77.75,90.36 77.75,90.63 78.01,90.88 78.08,90.88 78.37,91.17 78.37,91.78 U18.AJ31
  BOTTOM w0.178: v1(79.07,63.05) 78.58,63.54 78.58,64.57 78.73,64.72 CN17.151
M_MA_BG0: length 53
  IN4 w0.127: v1(67,93.42) 66.77,93.42 66.66,93.31 66.66,92.87 67.14,92.4 67.14,89.99 67.54,89.58 67.54,89.39 67.37,89.22 67.12,89.22 66.84,89.51 66.6,89.51 66.46,89.37 66.46,88.84 66.99,88.31 66.99,87.33 66.5,86.84 66.5,68.08 64,65.58 64,57.94 65.85,56.08 65.85,50.29 v1(65.46,49.9)
  BOTTOM w0.178: v1(65.46,49.9) 65.94,49.9 67.73,51.69 CN16.115 ; U18.T29 67.27,93.7 v1(67,93.42)
M_MA_BG1: length 53.3
  IN4 w0.127: v1(67.02,95.83) 66.43,95.25 66.43,92.78 66.91,92.31 66.91,91.73 66.78,91.61 66.11,91.61 65.98,91.48 65.98,91.23 66.11,91.1 66.78,91.1 66.91,90.97 66.91,90.07 66.77,89.93 66.36,89.93 66.23,89.81 66.23,88.71 65.96,88.44 65.96,87.49 65.71,87.24 65.71,86.77 66.07,86.4 66.07,68.26 63.62,65.81 63.62,57.71 65.39,55.93 v1(65.39,51.18)
  BOTTOM w0.178: v1(67.02,95.83) 67.29,96.1 U18.T26 ; v1(65.39,51.18) 66.5,51.18 67.23,51.91 CN16.113
M_MB_BG0: length 36.9
  IN1 w0.127: v1(66.13,87.04) 66.13,84.43 66.74,83.83 66.74,64.59 66.87,64.46 v1(66.87,61.92)
  BOTTOM w0.102: U18.W31 70.05,91.76 69.73,91.45 69.73,91.15 69.77,91.12 69.77,90.66 69.77,90.65 69.77,90.64 69.75,90.63 69.75,89.48 69.04,88.78 68.13,88.78 66.82,87.46
  BOTTOM w0.165: 66.82,87.46 66.4,87.04 v1(66.13,87.04)
  BOTTOM w0.178: CN17.115 67.73,64.69 67.34,64.31 67.34,62.4 v1(66.87,61.92)
M_MB_BG1: length 35.6
  IN1 w0.127: v1(66.4,88.29) 65.57,87.45 65.57,84.36 66.3,83.62 66.3,67.25 65.99,66.93 65.99,63.85 v1(66.3,63.54)
  BOTTOM w0.102: U18.W30 69.63,92.48 69.63,91.63 69.53,91.52 69.53,91.07 69.57,91.03 69.57,90.74 69.56,90.74 69.56,90.73 69.54,90.71 69.54,89.57 68.96,88.98 67.09,88.98 v1(66.4,88.29)
  BOTTOM w0.178: v1(66.3,63.54) 66.56,63.54 66.92,63.89 66.92,64.33 67.23,64.64 CN17.113
M_VREF: length 9.7
  BOTTOM w0.305: U18.T32 67.65,91.47 68.08,91.04 68.08,90.67 67.27,89.86 64.88,89.86 64.3,89.28 64.3,87 TP268.1
MA_ZVDDIO: length 1.4
  TOP w0.381: R463.2 73.42,93.19 v1(73.08,93.52)
  BOTTOM w0.203: v1(73.08,93.52) 73.27,93.7 U18.AD29
MAA0_0: length 30
  TOP w0.102: 137.15,112.85 137.15,112.75 137.41,112.49 137.41,111.4 137.17,111.16 137.17,109.83 v1(137.6,109.4)
  TOP w0.14: v1(134.3,134.62) 134.3,134.24 133.7,133.64 133.33,133.64 133,133.32 133,132.95 132.24,132.19 132.24,126.12 132.34,126.02 132.34,121.52 v1(132.84,121.02) 133.64,120.22 133.64,118.83 136.73,115.74 136.73,113.26 137.15,112.85
  BOTTOM w0.14: v1(137.6,109.4) 137.8,109.4 U22.G25 ; v1(134.3,134.62) 134.7,134.22 VRAM1.H4
MAA0_1: length 30.7
  TOP w0.102: v1(137.6,108.73) 137.54,108.73 137.19,109.08 137.19,109.47 136.97,109.69 136.97,111.27 137.21,111.51 137.21,112.24 136.85,112.6
  TOP w0.14: v1(133.35,134.62) 132.62,133.89 132.62,133.11 131.75,132.24 131.75,128.1 131.68,128.03 131.68,121.3 132.97,120.01 132.97,118.55 136.43,115.09 136.43,113.02 136.85,112.6
  BOTTOM w0.14: VRAM1.H5 133.55,134.62 v1(133.35,134.62) ; v1(137.6,108.73) 137.93,108.73 U22.H25
MAA0_2: length 29.8
  TOP w0.102: v1(136.56,110.16) 136.06,110.66 136.06,112.12 135.79,112.38 135.79,113.15
  TOP w0.14: v1(129.55,133.04) 129.55,132.87 129.7,132.73 129.95,132.73 130.08,132.85 130.08,133.08 130.24,133.24 130.45,133.24 130.56,133.13 130.56,132.73 130.84,132.45 130.84,129.3 130.36,128.81 v1(130.36,122.92) 130.36,118.45 132.16,116.65 132.74,116.65 135.03,114.36 135.03,113.91 135.27,113.67 135.79,113.15
  BOTTOM w0.14: U22.E27 136.95,110.55 v1(136.56,110.16) ; VRAM1.H11 129.55,133.82 v1(129.55,133.04)
MAA0_3: length 29.4
  TOP w0.102: 135.98,113.46 136.05,113.4 136.05,112.51 136.3,112.26 136.74,112.26 137.01,111.99 137.01,111.61 136.56,111.17 v1(136.56,110.96)
  TOP w0.14: v1(131.05,133.11) 131.27,132.89 131.27,128.76 131.02,128.51 v1(131.02,120.96) 131.02,119.91 131.15,119.78 132.13,119.78 132.26,119.66 132.26,119.15 132.16,119.05 131.74,119.05 131.62,118.92 131.62,118.56 131.74,118.43 132.13,118.43 135.41,115.15 135.41,114.03 135.98,113.46
  BOTTOM w0.14: v1(136.56,110.96) 136.66,110.96 U22.D27 ; v1(131.05,133.11) 131.05,133.71 130.5,134.25 129.98,134.25 VRAM1.H10
MAA0_4: length 29
  TOP w0.102: 135.01,112.71 135.01,111.13 135.14,111 v1(135.4,111)
  TOP w0.14: v1(129.55,132.22) 128.66,131.33 127.84,131.33 127.35,130.83 127.35,128.09 v1(127.09,127.83) 126.4,127.14 126.22,126.96 126.22,124.74 128.9,122.06 128.9,118.03 131.6,115.33 132.01,115.33 132.77,114.57 132.77,114.19 133.43,113.53 134.19,113.53 135.01,112.71
  BOTTOM w0.14: v1(129.55,132.22) 129.55,132.22 VRAM1.K11 ; U22.D29 135.6,111 v1(135.4,111)
MAA0_5: length 30.2
  TOP w0.102: 128.94,127.77 129.17,128 129.17,129.35 129,129.52 129,130.03 129.17,130.2 129.17,130.81 129.37,131.02 129.84,131.02 130.01,131.18 130.01,131.81 v1(130.42,132.22) ; 135.41,112.67 135.41,112.43 135.86,111.99 135.86,110.12 v1(136.58,109.4)
  TOP w0.14: 128.94,127.77 127.79,126.63 v1(127.79,125.94) 127.79,124.39 128.25,123.93 129.24,123.93 129.57,123.6 129.57,118.3 131.88,115.99 132.47,115.99 135.03,113.43 135.41,113.04 135.41,112.67
  BOTTOM w0.102: 137.02,108.95 v1(136.58,109.4)
  BOTTOM w0.14: VRAM1.K10 129.99,132.62 130.39,132.22 v1(130.42,132.22) ; U22.H27 137.02,108.95
MAA0_6: length 30.5
  TOP w0.102: 137.44,113.4 137.9,112.94 137.9,111.3 138.05,111.15 138.05,110.24 138.31,109.98 138.31,108.99 v1(138.71,108.59)
  TOP w0.14: v1(133.55,132.22) 133.26,132.22 133.08,132.04 133.08,130.24 133.25,130.06 133.25,126.93 133.66,126.53 133.66,125.62 134.68,124.61 134.68,123.52 134.83,123.37 135.31,123.37 135.5,123.18 135.5,122.58 135.32,122.4 133.95,122.4 133.81,122.26 133.81,121.91 134,121.71 134.79,121.71 135.02,121.48 v1(135.02,120.94) 135.02,119.33 137.44,116.9 137.44,113.4
  BOTTOM w0.14: v1(133.55,132.22) VRAM1.K5 ; v1(138.71,108.59) 138.79,108.59 139.15,108.95 U22.H23
MAA0_7: length 30
  TOP w0.102: v1(134.35,132.22) 134.15,132.22 133.97,132.04 133.97,130.88 133.96,130.87 133.96,130.28 133.89,130.21 133.89,130.06 ; 138.65,112.89 138.65,112.85 138.33,112.52 138.15,112.35 138.15,111.45 138.35,111.25 138.35,110.62 v1(138.79,110.19)
  TOP w0.14: 133.89,130.06 133.89,127.27 134.32,126.84 134.52,126.84 134.69,127.01 134.94,127.01 135.32,126.63 135.32,126.42 v1(134.62,125.72) 134.62,125.72 135,125.34 135.99,125.34 136.12,125.21 136.12,124.82 135.98,124.68 135.6,124.68 135.49,124.57 135.49,124.16 135.61,124.04 135.95,124.04 136.1,123.88 136.1,121.79 135.96,121.65 135.75,121.65 135.61,121.51 135.61,121.24 135.75,121.1 135.96,121.1 136.1,120.96 136.1,120.68 135.96,120.54 135.75,120.54 135.61,120.4 135.61,120.12 135.75,119.98 135.96,119.98 136.1,119.84 136.1,118.98 138.1,116.98 138.1,115.15 138.65,114.6 138.65,112.89
  BOTTOM w0.14: VRAM1.K4 v1(134.35,132.22) ; v1(138.79,110.19) 138.89,110.19 U22.E23
MAA0_8: length 29.3
  TOP w0.102: 137.63,112.64 137.63,111.02 v1(137.61,111)
  TOP w0.14: 137.63,112.64 137.63,112.77 137.04,113.36 137.04,116.37 134.26,119.14 134.26,120.47 133,121.74 v1(133,122.52) 133,122.83 133.12,122.95 133.98,122.95 134.11,123.08 134.11,123.39 133.98,123.51 133.14,123.51 133,123.65 133,123.93 133.14,124.07 133.85,124.07 133.98,124.2 133.98,124.5 133.85,124.63 133.14,124.63 133,124.77 133,126.29 132.62,126.67 132.62,131.96 133.51,132.85 v1(133.51,132.98)
  BOTTOM w0.14: VRAM1.J5 v1(133.51,132.98) ; U22.D25 137.96,111.35 v1(137.61,111)
MAA1_0: length 30.9
  TOP w0.102: v1(144.32,110.2) 144.69,110.57 144.69,111.21 144.39,111.51 144.39,112.99 145.16,113.76 145.16,117.34 145.2,117.38 145.2,117.84
  TOP w0.14: 145.2,117.84 145.2,118.52 149.38,122.71 v1(149.38,126.56) 149.38,127.8 150.02,128.44 150.02,132.54 149.37,133.2 149.37,133.83 149.18,134.01 148.8,134.01 148.42,133.63 147.91,133.63 147.63,133.91 147.63,134.26 v1(148.01,134.64)
  BOTTOM w0.14: VRAM2.K4 147.61,134.24 v1(148.01,134.64) ; U22.E15 144,110.2 v1(144.32,110.2)
MAA1_1: length 31
  TOP w0.102: 145.58,117.78 145.44,117.64 145.44,113.54 144.6,112.7 144.6,111.59 144.89,111.29 144.89,109.08 v1(144.36,108.54)
  TOP w0.14: v1(149.12,134.49) 149.62,133.99 149.62,133.58 150.45,132.74 150.45,128.14 150.03,127.71 v1(150.03,124.93) 150.03,122.61 146.42,119 146.42,118.62 145.58,117.78
  BOTTOM w0.14: VRAM2.K5 148.87,134.24 v1(149.12,134.49) ; v1(144.36,108.54) 144.06,108.54 U22.H15
MAA1_2: length 29.3
  TOP w0.102: v1(145.3,109.4) 145.71,109.81 145.71,111.19 145.66,111.24 145.66,112.85 146,113.2
  TOP w0.14: 146,113.2 146.21,113.41 146.46,113.66 146.46,114.29 146.62,114.44 146.62,116.12 147.54,117.05 147.54,118.65 151.39,122.5 v1(151.39,124.36) 151.39,132.44 151.69,132.74 152.44,132.74 v1(152.73,133.04)
  BOTTOM w0.14: v1(152.73,133.04) 152.73,133.8 VRAM2.K11 ; U22.G13 145.1,109.4 v1(145.3,109.4)
MAA1_3: length 27.5
  TOP w0.102: 145.71,113.41 144.8,112.5 144.8,111.67 145.3,111.17 v1(145.3,111)
  TOP w0.14: 145.71,113.41 146.21,113.91 146.21,114.39 146.33,114.52 146.33,116.42 147.02,117.11 147.02,118.86 150.7,122.55 v1(150.7,126.21) 150.7,127.65 151.01,127.96 151.01,132.88 v1(151.17,133.04)
  BOTTOM w0.14: U22.D13 145.1,111 v1(145.3,111) ; v1(151.17,133.04) 151.17,133.46 151.95,134.24 VRAM2.K10
MAA1_4: length 30.1
  TOP w0.102: v1(146.59,109.46) 146.77,109.46 146.9,109.59 146.9,109.92 146.74,110.07 146.74,110.99 146.09,111.63 146.09,112.14 146.33,112.38 146.33,112.38 146.78,112.83
  TOP w0.14: v1(152.73,132.24) 153.8,131.16 154.49,131.16 154.83,130.82 154.83,127.97 154.4,127.54 154.4,124.03 148.58,118.22 148.58,116.5 148.9,116.18 148.9,115.17 148.58,114.84 148.58,114.63 146.78,112.83
  BOTTOM w0.14: v1(152.73,132.24) 153.13,132.64 VRAM2.H11 ; v1(146.59,109.46) 146.33,109.46 145.85,108.98 U22.H11
MAA1_5: length 29.8
  TOP w0.102: 153.13,130.42 153.13,130.91 152.98,131.06 152.5,131.06 152.29,131.27 152.29,131.8 v1(151.84,132.25) ; v1(145.31,108.75) 145.5,108.75 145.93,109.18 145.93,111.26 145.89,111.29 145.89,112.44 146.27,112.82 147.66,114.21 147.66,114.5
  TOP w0.14: 147.66,114.5 148.56,115.41 148.56,116.07 148.06,116.57 148.06,118.43 153.54,123.92 v1(153.54,125.56) 153.54,127.42 153.15,127.82 153.15,130.4 153.13,130.42
  BOTTOM w0.14: v1(145.31,108.75) 144.95,108.75 U22.H13 ; v1(151.84,132.25) 151.98,132.25 VRAM2.H10
MAA1_6: length 29.1
  TOP w0.102: v1(143.1,108.85) 143.79,109.54 143.79,111.17 143.95,111.32 143.95,114.95 144.12,115.12 144.12,117.52
  TOP w0.14: 144.12,117.52 143.96,117.68 143.96,118.75 147.24,122.03 v1(147.24,125.63) 147.24,128.38 147.79,128.93 148.42,128.93 148.55,129.06 148.55,129.42 148.42,129.54 148.04,129.54 147.91,129.67 147.91,130.08 148.04,130.2 149.06,130.2 149.25,130.4 149.25,131.76 v1(148.77,132.24)
  BOTTOM w0.14: U22.H17 143.01,108.95 v1(143.1,108.85) ; VRAM2.H5 v1(148.77,132.24)
MAA1_7: length 29.2
  TOP w0.102: 143.4,112.88 143.4,112.7 143.74,112.36 143.74,111.4 143.59,111.25 143.59,110.04 v1(143.05,109.5)
  TOP w0.14: v1(148.02,133.04) 148.02,132.21 147.53,131.73 147.53,131.4 147.3,131.16 146.13,131.16 145.82,130.85 145.82,127.75 145.7,127.64 145.25,127.64 145.12,127.51 145.12,127.13 145.27,126.98 145.62,126.98 145.75,126.84 145.75,126.39 145.63,126.27 145.25,126.27 145.12,126.14 v1(145.12,125.29) 145.12,120.65 143.13,118.66 143.13,115.07 143.4,114.8 143.4,112.88
  BOTTOM w0.14: U22.G17 142.8,109.5 v1(143.05,109.5) ; VRAM2.H4 147.62,132.64 v1(148.02,133.04)
MAA1_8: length 26.4
  TOP w0.102: v1(144.28,111) 144.18,111.1 144.18,114.9 144.34,115.06 144.34,117.75 144.6,118
  TOP w0.14: 144.6,118 144.6,118.66 148.71,122.77 v1(148.71,125.16) 148.71,127.86 149.62,128.78 149.62,132.31 148.94,132.99 v1(148.94,133.44)
  BOTTOM w0.14: v1(144.28,111) 144,111 U22.D15 ; v1(148.94,133.44) VRAM2.J5
MAB0_0: length 30.5
  TOP w0.11: 152.06,107.18 151.58,107.18 150.55,106.14 149.73,106.14 149.43,106.43 148.83,106.43 v2(148.4,106)
  TOP w0.14: v1(172.32,109.79) 171.51,110.6 171.51,110.61 170.83,111.29 167.88,111.29 167.25,111.93 162.09,111.93 161.31,112.7 v1(160.16,112.7) 159.68,112.23 159.68,110.49 156.62,107.43 156.11,107.43 155.86,107.18 152.06,107.18
  BOTTOM w0.14: VRAM3.H4 172.32,109.74 v1(172.32,109.79) ; U22.R5 148.75,105.65 v2(148.4,106)
