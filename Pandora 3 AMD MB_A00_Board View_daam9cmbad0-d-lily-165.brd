# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 76.65,146.03 76.65,143.67 76.62,143.61 76.62,143.56 76.62,143.28 76.62,143.23 76.65,143.17 76.65,143.14 76.81,142.98 78.59,142.98 78.73,142.84 78.73,141.43 78.83,141.33 81.65,141.33 82.6,142.27 89.11,142.27 90.51,140.88 93.15,140.88 93.6,140.43 93.6,139.39 92.04,137.84 88.7,137.84 88.68,137.85 83.1,137.85 82.4,138.56 82.39,138.59 82.4,138.61 82.04,139.27 81.68,138.6 81.69,138.57 81.67,138.54 81.57,138.43 81.57,137.81 81.16,137.41 81.16,136.47 80.94,136.24 79.57,136.24 79.44,136.37 79.44,137.46 79.14,137.76 79.14,138.11 78.82,138.43 74.59,138.43 73.98,139.04 73.98,144.25 74.74,145.01 74.74,146.16 74.99,146.41 76.26,146.41
GND on TOP (solid shape): 79.95,111.44 79.97,111.4 79.85,111.11 79.96,110.86 79.99,110.79 79.96,110.72 80.07,110.13 80.56,110.46 80.58,110.5 80.61,110.51 80.77,110.51 80.85,110.5 80.92,110.51 81.63,110.51 81.72,110.42 81.73,110.4 81.74,110.38 81.74,109.74 81.45,109.45 81.45,108.88 81.35,108.77 79.7,108.77 79.3,109.17 79.3,109.39 79.3,109.4 79.34,109.56 79.3,109.71 79.3,109.72 79.3,110.53 79.11,110.73 79.11,110.87 79.12,110.88 79.19,111.1 79.12,111.32 79.11,111.33 79.11,111.39 79.29,111.57 79.82,111.57
GND on TOP (solid shape): 35.59,63.89 35.63,63.87 35.64,63.84 35.64,58.73 36.11,58.26 36.11,58.25 36.48,57.88 36.48,52.23 35.69,51.44 35.69,47.51 36.11,47.08 36.11,35.26 36.09,35.23 36.07,35.23 35.93,35.17 35.82,35.07 35.81,35.05 35.78,35.04 34.76,35.04 34.62,35.19 34.62,35.54 34.86,35.79 34.86,36.1 34.75,36.22 34.69,36.27 34.61,36.35 34.61,36.69 34.86,36.94 34.86,37.23 34.75,37.36 34.69,37.4 34.62,37.48 34.62,37.81 34.86,38.05 34.86,38.37 34.75,38.48 34.71,38.51 34.62,38.61 34.62,38.95 34.72,39.05 34.77,39.1 34.86,39.19 34.86,39.49 34.76,39.61 34.71,39.65 34.62,39.73 34.62,40.08 34.86,40.32 34.86,40.62 34.79,40.69 34.74,40.75 34.68,40.8 34.61,40.87 34.61,41.21 34.86,41.46 34.86,41.77 34.74,41.89 34.52,42.11 34.52,60.98 34.46,61.04 34.46,61.06 34.39,61.2 34.25,61.27 34.24,61.27 34.19,61.32 34.19,63.42 34.66,63.89
GND on TOP (solid shape): outline of 126 points within 65.27,88.83 71.91,93.32
GND on TOP (solid shape): 76.7,111.69 77.08,111.69 77.09,111.68 77.15,111.65 77.22,111.64 77.52,111.64 77.57,111.65 77.61,111.66 77.64,111.66 77.66,111.65 77.87,111.45 77.9,111.36 77.84,111.29 77.64,110.91 77.95,110.61 77.97,110.6 78.01,110.55 78.01,109.8 77.96,109.74 77.95,109.74 77.66,109.37 77.96,109 77.97,108.99 78.01,108.94 78.01,108.2 77.95,108.13 76.99,108.13 76.94,108.17 76.94,108.21 76.95,108.22 76.98,108.53 76.77,108.76 76.77,108.76 76.65,108.87 75.77,108.87 75.62,109.03 75.62,109.74 75.83,109.95 75.87,109.94 76.02,109.93 76.17,109.98 76.38,109.98 76.9,109.94 76.91,110.46 76.9,110.47 76.9,110.53 76.91,110.55 76.96,111 76.52,111.13 76.48,111.12 76.36,111.23 76.36,111.52 76.56,111.71 76.62,111.71
GND on TOP (solid shape): 66.48,118.68 66.48,118.06 66.63,117.91 69.95,117.91 70,117.86 70,117.35 69.89,117.25 68.95,117.25 68.94,117.26 68.61,117.26 68.61,117.26 67.67,117.26 67.67,117.26 67.6,117.26 67.59,117.25 67.48,117.25 67.27,117.04 67.27,113.06 67.24,112.99 67.17,112.96 66.81,112.71 66.93,112.29 66.95,112.25 66.93,112.21 66.9,112.19 66.86,112.2 66.78,112.24 66.69,112.25 66.37,112.25 66.32,112.24 66.27,112.22 66.24,112.22 66.21,112.24 66.18,112.28 66.16,112.31 66.13,112.38 66.16,112.45 65.88,113.1 65.61,112.45 65.64,112.38 65.61,112.31 65.57,112.26 65.54,112.21 65.53,112.19 65.5,112.18 65.43,112.18 65.13,112.18 65.09,112.19 65.06,112.21 65.02,112.23 65,112.26 65,112.29 64.89,112.65 64.52,112.74 64.49,112.74 64.47,112.76 64.43,112.81 64.43,112.83 64.43,118.69 64.62,118.89 66.27,118.89
GND on TOP (solid shape): outline of 157 points within 135.67,133.46 145.81,141.08
GND on TOP (solid shape): 73.2,115 73.2,114.75 73.26,114.69 73.29,114.64 73.34,114.61 73.42,114.53 74.28,114.53 74.59,114.21 74.59,113.42 74.48,113.3 72.43,113.3 72.35,113.34 72.33,113.43 72.32,113.64 72.19,113.81 72.14,113.9 72.2,113.99 72.05,114.66 71.83,114.01 71.87,113.92 71.82,113.83 71.66,113.66 71.64,113.43 71.62,113.34 71.54,113.3 71.12,113.3 70.9,113.08 70.88,113.07 70.85,113.07 70.7,113.11 70.55,113.08 70.52,113.08 70.49,113.09 70.31,113.24 70.09,113.3 69.42,113.3 69.37,113.3 69.33,113.29 69.25,113.31 69.22,113.39 69.22,113.65 70.23,114.66 70.25,114.66 70.34,114.68 70.41,114.74 70.49,114.77 70.57,114.74 70.64,114.68 70.74,114.66 71.02,114.66 71.18,114.72 71.24,114.88 71.24,115.14 71.47,115.37 72.83,115.37
GND on TOP (solid shape): outline of 177 points within 173.14,96.68 178.85,106.66
GND on TOP (solid shape): outline of 203 points within 80.58,49.38 86.75,55.34
GND on TOP (solid shape): outline of 232 points within 87.3,98.92 92.87,101.81
GND on TOP (solid shape): outline of 280 points within 64.17,97.79 69.87,102.53
GND on TOP (solid shape): outline of 1145 points within 136.43,97.52 146.61,108.95
GND on TOP (solid shape): outline of 1860 points within 0.51,0.51 291.04,153.24
GND on TOP (solid shape): outline of 14052 points within 37.22,37.24 104.13,107.74
GND on BOTTOM (solid shape): 9.94,23.45 9.94,21.77 9.87,21.7 7.28,21.7 7.23,21.75 7.23,23.47 7.3,23.55 9.84,23.55
GND on BOTTOM (solid shape): 20.05,27.11 20.05,25.66 19.95,25.56 15.23,25.56 15.15,25.63 15.15,27.18 15.18,27.21 19.95,27.21
GND on BOTTOM (solid shape): 41.21,123.58 41.21,120.17 41.09,120.05 37.66,120.05 37.58,120.12 37.58,123.63 37.68,123.73 41.06,123.73
GND on BOTTOM (solid shape): 76.26,146.28 76.26,144.25 76.14,144.12 75.12,144.12 74.87,144.38 74.87,146.28 75.12,146.54 76.01,146.54
GND on BOTTOM (solid shape): 93.58,141.02 93.58,139.36 92.14,137.93 90.54,137.93 90.46,138 90.46,141.31 90.56,141.41 93.19,141.41
GND on BOTTOM (solid shape): 105.63,147.76 105.63,146.21 105.12,145.7 102.63,145.7 102.5,145.83 102.5,147.43 103.01,147.93 105.45,147.93
GND on BOTTOM (solid shape): 114.91,145.2 114.91,142.18 114.72,141.99 111.54,141.99 111.39,142.14 111.39,145.22 111.57,145.39 114.72,145.39
GND on BOTTOM (solid shape): 142.54,51.29 142.54,48.26 142.35,48.08 139.17,48.08 139.02,48.23 139.02,51.3 139.2,51.47 142.35,51.47
GND on BOTTOM (solid shape): 159.11,23.14 159.11,21.45 159.06,21.4 157.9,21.4 157.71,21.59 157.71,23.31 157.9,23.49 158.75,23.49
GND on BOTTOM (solid shape): 165.42,49.15 165.42,46.39 165.32,46.28 163.34,46.28 163.16,46.46 163.16,48.61 163.82,49.28 165.29,49.28
GND on BOTTOM (solid shape): 166.18,73.33 166.18,70.62 166.1,70.54 164.43,70.54 164.35,70.62 164.35,72.55 165.27,73.46 166.05,73.46
GND on BOTTOM (solid shape): 173.04,47.02 173.04,44.51 172.92,44.39 170.43,44.39 170.22,44.6 170.22,46.8 170.52,47.1 172.96,47.1
GND on BOTTOM (solid shape): 254.57,17.1 254.57,14.86 254.55,14.84 252.31,14.84 252.29,14.86 252.29,17.07 252.34,17.12 254.55,17.12
GND on BOTTOM (solid shape): 258.76,22.46 258.76,21.29 258.56,21.09 256.86,21.09 256.64,21.31 256.64,22.47 256.91,22.74 258.48,22.74
GND on BOTTOM (solid shape): 267.73,46.08 267.73,44.56 267.65,44.48 266.18,44.48 266.05,44.61 266.05,46.08 266.18,46.21 267.6,46.21
GND on BOTTOM (solid shape): 272.96,45.4 272.96,44.63 272.71,44.38 271.23,44.38 271.16,44.46 271.16,45.68 271.33,45.85 272.51,45.85
GND on BOTTOM (solid shape): 37.91,88.19 37.91,87.08 37.71,86.87 36.39,86.87 35.84,87.42 35.84,88.08 36.28,88.52 37.58,88.52
GND on BOTTOM (solid shape): 123.95,9.8 123.95,4.86 123.93,4.84 120.26,4.84 120.23,4.86 120.23,9.76 120.45,9.98 120.45,9.98 123.77,9.98
GND on BOTTOM (solid shape): 7.81,26.27 7.81,25.51 7.51,25.2 4.2,25.2 4.08,25.33 4.08,26.68 4.28,26.88 7.2,26.88
GND on BOTTOM (solid shape): 31.98,9.3 31.98,8.37 31.86,8.25 30.33,8.25 30.21,8.36 30.21,9.33 30.07,9.48 30.07,9.94 30.16,10.04 31.24,10.04
GND on BOTTOM (solid shape): 125.83,11.45 125.83,9.36 125.83,9.36 125.83,9 125.64,8.82 124.51,8.82 124.38,8.95 124.38,11.2 124.66,11.48 125.79,11.48
GND on BOTTOM (solid shape): 147.44,84.59 147.44,83.72 147.1,83.38 141.75,83.38 141.65,83.48 141.65,84.42 141.78,84.55 145.05,84.55 145.22,84.71 147.31,84.71
GND on BOTTOM (solid shape): 155.9,22.89 155.9,21.51 155.85,21.46 151.37,21.46 151.24,21.59 151.24,23.03 151.29,23.08 152.31,23.08 152.36,23.13 155.66,23.13
GND on BOTTOM (solid shape): 159.73,7.55 161.1,7.55 161.3,7.35 161.3,6.82 161.18,6.7 155.91,6.7 155.82,6.79 155.82,7.78 155.94,7.9 159.37,7.9
GND on BOTTOM (solid shape): 164.07,12.22 164.07,10.6 163.72,10.24 161.27,10.24 161.03,10.48 161.03,12.18 161.19,12.34 161.42,12.34 161.43,12.35 163.94,12.35
GND on BOTTOM (solid shape): 273.24,90.38 273.24,89.36 273.16,89.29 273.16,86.87 272.83,86.54 270.07,86.54 269.15,87.46 269.15,90.12 269.46,90.43 273.19,90.43
GND on BOTTOM (solid shape): 15.3,44.18 15.3,40.9 15.25,40.85 11.91,40.85 11.39,41.36 11.39,43.65 11.66,43.91 13.22,43.91 13.68,44.37 15.12,44.37
GND on BOTTOM (solid shape): 123.08,36.71 123.08,36.5 124.15,35.43 124.15,34.06 124,33.91 118.94,33.91 118.17,34.68 118.17,36.78 118.4,37.01 122.77,37.01
GND on BOTTOM (solid shape): 129.59,82.25 129.59,80.84 129.38,80.63 126.81,80.63 126.73,80.72 126.73,81.54 126.81,81.62 127.74,81.62 128.57,82.45 129.39,82.45
GND on BOTTOM (solid shape): 137.57,16.99 137.57,13.58 137.56,13.58 137.56,13.43 137.32,13.19 134.84,13.19 134.7,13.34 134.7,16.93 134.87,17.09 137.46,17.09
GND on BOTTOM (solid shape): 141.17,17.64 141.17,14.37 140.81,14 138.01,14 137.84,14.18 137.84,16.74 138.06,16.97 139.52,16.97 140.26,17.7 141.11,17.7
GND on BOTTOM (solid shape): 273.9,67.62 273.9,65.21 273.77,65.08 273.77,64.45 272.42,63.1 271.76,63.1 269.99,64.87 269.99,67.68 270.23,67.92 273.6,67.92
GND on BOTTOM (solid shape): 84.47,14.51 85.28,14.51 85.33,14.46 85.33,12.4 85.18,12.25 77.81,12.25 77.58,12.48 77.58,14.64 77.74,14.79 84.19,14.79
GND on BOTTOM (solid shape): 96.64,131.38 96.64,125.2 96.43,125 94,125 92.47,126.53 91.73,126.53 89.96,128.3 89.96,131.84 89.48,132.32 89.48,132.69 89.6,132.8 95.21,132.8
GND on BOTTOM (solid shape): 121.96,26.65 121.96,26.34 121.76,26.14 121.76,23.45 121.82,23.39 121.82,22.12 121.68,21.98 121.07,21.98 120.81,22.24 120.81,26.61 120.92,26.73 121.88,26.73
GND on BOTTOM (solid shape): 131.26,41.18 131.26,39.76 131.05,39.55 124.7,39.55 124.4,39.86 124.4,40.59 124.6,40.8 125.59,40.8 125.87,41.08 125.87,41.56 126.02,41.71 130.72,41.71
GND on BOTTOM (solid shape): 149.6,24.69 149.6,21.75 149.38,21.54 148.44,21.54 148.21,21.77 148.21,25.04 147.26,25.99 147.26,26.45 147.33,26.52 147.77,26.52
GND on BOTTOM (solid shape): 153.81,81.2 153.81,80.43 153.49,80.12 148.52,80.12 148.17,80.46 148.15,80.46 148.05,80.56 146.62,80.56 146.34,80.84 146.34,81.51 146.54,81.7 153.31,81.7
GND on BOTTOM (solid shape): 156.38,26.46 156.38,25.76 156.25,25.63 152.49,25.63 152.46,25.6 152.43,25.6 152.31,25.48 151.27,25.48 150.96,25.79 150.96,26.49 151.12,26.65 156.2,26.65
GND on BOTTOM (solid shape): 164.13,16.67 164.13,14.05 164.03,13.95 161.63,13.95 161.33,14.25 161.33,14.85 161.02,15.17 160.28,15.17 160.09,15.37 160.09,16.21 160.83,16.95 163.84,16.95
GND on BOTTOM (solid shape): 249.16,19.16 249.16,17.35 249.14,17.33 248.71,17.33 248.35,17.68 248.27,17.68 248.25,17.71 246.95,17.71 246.75,17.91 246.75,19.36 246.9,19.51 248.81,19.51
GND on BOTTOM (solid shape): 272.56,82.94 272.56,80.12 272.56,80.11 272.44,79.98 271.48,79.98 271.11,80.35 271.11,81.41 271.11,81.41 271.11,82.83 271.29,83.01 272.48,83.01
GND on BOTTOM (solid shape): 20.61,41.69 20.61,40.59 20.59,40.57 19.6,40.57 19.42,40.75 18.73,40.75 18.71,40.77 18.71,40.87 18.76,40.92 19.42,40.92 19.5,41 19.5,41.39 19.84,41.74 20.56,41.74
GND on BOTTOM (solid shape): 24.64,41.09 24.64,40.81 24.65,40.81 24.65,38.92 23.81,38.08 23.1,38.08 22.72,38.46 22.72,40.9 22.75,40.92 23.61,40.92 23.62,40.93 23.92,40.93 24.22,41.23 24.5,41.23
GND on BOTTOM (solid shape): 108.83,39.68 108.83,37.24 108.16,36.57 108.16,34.27 108.14,34.23 108.11,34.22 103.16,34.22 103.09,34.3 103.09,39.5 103.47,39.88 108.62,39.88
GND on BOTTOM (solid shape): 159.91,15.71 159.91,15.11 160.1,14.92 160.74,14.92 160.97,14.68 160.97,13.14 160.81,12.98 158.35,12.98 158.19,13.14 158.19,14.32 157.81,14.69 157.81,15.65 157.97,15.81 159.81,15.81
GND on BOTTOM (solid shape): 176.54,79.98 177.25,79.27 177.25,74.99 175.58,73.31 174.94,73.31 174.79,73.46 174.79,76.13 174.44,76.48 174.11,76.48 173.5,77.09 173.5,80.29 173.95,80.75 175.78,80.75
GND on BOTTOM (solid shape): 184.37,46.16 184.4,46.15 184.42,46.11 184.42,43.51 184.22,43.31 182.11,43.31 181.65,43.78 181.65,46.11 181.66,46.15 181.7,46.16
GND on BOTTOM (solid shape): 197.78,30.52 197.78,25 197.45,24.67 194.7,24.67 194.63,24.74 194.63,25.76 194.78,25.91 194.78,29.37 194.78,29.42 194.58,29.62 194.58,31.76 194.7,31.88 196.41,31.88
GND on BOTTOM (solid shape): 111.12,128.97 111.12,125.67 110.9,125.44 107.37,125.44 107.32,125.49 107.31,125.51 107.3,125.53 107.3,129.88 107.48,130.05 110.04,130.05
GND on BOTTOM (solid shape): 105.36,17.33 105.36,15.79 105.27,15.7 102.91,15.7 102.81,15.8 102.81,16.74 102.76,16.79 101.21,16.79 101.13,16.72 101.13,15.8 100.99,15.66 99.97,15.66 99.72,15.92 99.72,17.42 99.78,17.48 105.21,17.48
GND on BOTTOM (solid shape): 143.13,8.17 143.13,6.29 142.87,6.02 139.36,6.02 138.65,5.31 137.68,5.31 137.68,5.32 137.5,5.49 137.5,7.78 137.76,8.03 138.72,8.03 138.8,8.11 138.9,8.11 139.21,8.41 142.74,8.41 142.89,8.41
GND on BOTTOM (solid shape): 158.05,63.28 158.05,61.26 157.9,61.11 157.02,61.11 157,61.1 156.71,61.1 155.99,60.38 155.99,59.06 155.59,58.65 153.86,58.65 153.23,59.29 153.23,60.02 153.35,60.15 153.35,62.72 153.48,62.84 156.88,62.84 157.57,63.53 157.8,63.53
GND on BOTTOM (solid shape): 138.26,31.63 138.28,31.63 138.3,31.62 138.42,31.5 138.42,30.31 137.55,29.44 137.55,28.88 137.48,28.81 136.74,28.81 136.61,28.94 135.8,28.94 135.7,29.04 135.7,29.93 135.85,30.08 136.26,30.08 136.51,30.33 136.51,30.72 137.42,31.63
GND on BOTTOM (solid shape): 196.81,15.98 196.81,15.06 196.74,14.98 196.74,11.85 196.71,11.82 196.71,10.4 196.53,10.22 194.97,10.22 194.7,10.49 194.7,11.79 194.7,14.79 194.98,15.07 194.98,16.13 195.01,16.16 196.63,16.16
GND on BOTTOM (solid shape): 161.63,26.92 161.63,23 161.58,22.94 161.12,22.94 161.07,22.9 160.98,22.9 160.83,22.75 160.83,22.65 160.82,22.64 160.82,20.54 160.83,20.53 160.83,20.45 160.61,20.24 159.72,20.24 159.55,20.41 159.55,26.63 159.55,27 159.68,27.13 161.43,27.13
GND on BOTTOM (solid shape): 49.6,14.83 49.6,13.76 50.11,13.24 50.11,12.44 50.26,12.29 50.85,12.29 51.09,12.05 51.09,11.22 50.87,11 49.18,11 48.79,11.39 41.8,11.39 41.28,10.86 41.08,10.86 40.94,11.01 40.94,14.97 41.28,15.31 49.12,15.31
GND on BOTTOM (solid shape): 170.37,85.43 170.37,84.94 169.38,83.95 169.29,83.88 169.21,83.79 168.69,83.27 166.74,83.27 166.13,82.66 165.7,82.66 165.55,82.5 165.55,76.27 165.16,75.88 165.16,75.16 162.82,72.83 160.77,72.83 158.92,74.68 158.92,83.32 161.18,85.58 170.22,85.58
GND on BOTTOM (solid shape): 15.94,37.42 15.94,36.07 15.84,35.97 15.25,35.97 15.08,35.79 15.08,34.22 15,34.14 15,33.71 14.82,33.53 13.88,33.53 13.7,33.71 13.7,36.05 13.91,36.25 13.98,36.31 14.03,36.38 14.31,36.66 14.31,37.34 14.52,37.55 15.81,37.55
GND on BOTTOM (solid shape): 82.72,137.04 82.72,134.52 82.23,134.04 81.24,134.04 80.96,133.76 80.96,133.28 80.66,132.97 80.05,132.97 80.03,132.98 79.88,133.09 79.71,133.13 79.69,133.13 79.44,133.38 79.44,136.81 79.79,137.17 82.59,137.17
GND on BOTTOM (solid shape): 37.21,28.64 37.21,25.23 36.56,24.58 36.56,22.31 36.44,22.18 30.91,22.18 30.88,22.21 29.9,22.21 29.12,22.99 28.97,22.99 28.93,23 28.92,23.04 28.92,24.47 28,25.38 23.84,25.38 23.76,25.46 23.76,26.95 23.91,27.11 28.23,27.11 28.51,27.39 28.51,28.1 29.58,29.16 36.69,29.16
GND on BOTTOM (solid shape): 23.27,57.55 23.27,51.54 23.52,51.28 25.37,51.28 25.45,51.21 25.45,50.74 25.87,50.33 26.89,50.33 27.01,50.21 27.01,49.9 26.9,49.79 21.15,49.79 20.32,50.63 20.32,50.96 20.28,50.99 20.27,51.01 20.27,51.03 20.27,55.16 20.05,55.38 20.05,57.23 20.89,58.07 22.75,58.07
GND on BOTTOM (solid shape): 165.27,26.98 165.27,25.6 165.21,25.55 165.21,21.18 165.9,20.49 165.9,19.62 165.74,19.46 164.77,19.46 164.5,19.72 164.5,20.42 164.51,20.43 164.53,20.57 164.51,20.71 164.5,20.72 164.5,21.7 164.28,21.92 164.28,26.08 164.2,26.16 164.2,26.17 164.11,26.26 164.11,26.98 164.22,27.09 165.16,27.09
GND on BOTTOM (solid shape): 169.23,61.73 169.23,61.14 169.25,61.12 169.46,61.12 169.48,61.14 169.48,61.73 169.51,61.75 169.69,61.75 169.71,61.73 169.71,61.09 169.85,60.95 169.85,60.93 170.32,60.46 170.32,60.33 170.16,60.17 169.94,60.17 169.9,60.17 169.85,60.15 169.71,60.15 168.97,60.89 168.97,61.15 168.98,61.15 168.98,61.71 169.02,61.75 169.2,61.75
GND on BOTTOM (solid shape): 99.2,142.22 104.33,142.22 104.71,141.84 104.71,139.86 104.38,139.53 100.44,139.53 100.34,139.63 100.34,140.27 100.34,140.42 100.22,140.54 98.79,140.54 98.72,140.47 98.72,140.29 98.36,139.94 98.36,139.58 97.98,139.2 96.2,139.2 95.59,139.81 95.59,141.43 96.25,142.09 96.28,142.09 96.79,142.6 98.82,142.6
GND on BOTTOM (solid shape): 190.77,49.28 190.77,46.34 190.56,46.13 188.72,46.13 188.58,46.27 188.58,47.36 188.63,48.11 188.07,48.6 188.04,48.62 188.03,48.65 188.03,49.17 188.3,49.44 190.61,49.44
GND on BOTTOM (solid shape): 111.47,14.66 111.88,14.66 112.04,14.5 112.04,13.07 111.91,12.95 108.03,12.95 107.96,13.02 107.96,13.37 108.02,13.56 107.97,13.76 107.96,13.77 107.96,13.89 107.97,13.92 108.2,14.13 108.28,14.4 108.28,14.61 108.29,14.64 108.33,14.66 111.47,14.66
GND on BOTTOM (solid shape): 125.85,26.07 125.85,25.81 125.92,25.65 126.08,25.59 126.36,25.59 126.42,25.59 126.47,25.62 126.5,25.63 126.53,25.63 127.47,24.69 127.47,24.53 127.46,24.46 127.46,24.33 127.47,24.26 127.47,24.23 127.32,24.08 126.25,24.08 125.59,23.42 125.11,23.42 124.98,23.55 124.98,26.17 125.03,26.22 125.7,26.22
GND on BOTTOM (solid shape): 72.99,142.19 72.99,140.25 72.48,139.73 72.48,137.79 72.28,137.59 71.14,137.59 70.96,137.78 70.96,138.26 70.8,138.41 67.5,138.41 67.02,138.89 67.02,139.28 66.99,139.3 66.99,139.43 65.57,139.43 65.21,139.07 65.21,137.9 64.96,137.65 62.42,137.65 61.66,138.41 61.46,138.41 58.48,138.41 58.1,138.79 58.1,139.43 57.98,139.55 56.45,139.55 56.27,139.73 56.27,140.95 56.66,141.33 61.5,141.33 61.89,140.95 65.78,140.95 66.16,141.33 70.73,141.33 70.93,141.53 70.93,141.59 71,141.65 71,142.04 71.32,142.36 72.82,142.36
GND on BOTTOM (solid shape): 145.73,36.02 145.86,36 145.99,36.02 146,36.02 147.19,36.02 147.34,35.87 147.56,35.87 147.56,35.87 147.56,35.08 147.54,35.06 146.32,35.06 146.2,34.93 144.51,34.93 144.48,34.95 144.46,34.99 144.46,35.14 144.48,35.17 144.51,35.19 145.14,35.19 145.14,35.43 144.51,35.43 144.48,35.45 144.46,35.49 144.46,35.64 144.51,35.69 145.22,35.69 145.56,36.02 145.72,36.02
GND on BOTTOM (solid shape): 88.51,141 88.51,139.02 88.11,138.63 87.43,138.63 87.29,138.49 83.68,138.49 83.57,138.6 83.57,139.34 83.43,139.48 81.9,139.48 81.65,139.22 81.65,139.03 81.64,139.02 81.61,138.84 81.64,138.67 81.65,138.66 81.65,138.19 81.64,138.18 81.61,138.03 81.63,137.87 81.63,137.84 81.62,137.82 81.32,137.52 79.31,137.52 78.4,138.44 74.92,138.44 74.66,138.69 74.66,139.48 74.5,139.64 73.66,139.64 73.47,139.83 73.47,141.13 73.67,141.33 88.18,141.33
GND on BOTTOM (solid shape): 170.14,67.34 170.14,65.87 169.99,65.71 169.84,65.71 169.71,65.59 169.71,64.98 169.69,64.95 169.53,64.95 169.48,65 169.48,65.56 169.46,65.59 169.25,65.59 169.23,65.56 169.23,64.98 169.2,64.95 169.02,64.95 169,64.98 169,65.56 168.97,65.59 168.75,65.59 168.72,65.56 168.72,64.98 168.69,64.95 168.52,64.95 168.49,64.98 168.49,65.56 168.47,65.59 168.24,65.59 168.21,65.56 168.21,64.98 168.19,64.95 168.01,64.95 167.98,64.98 167.98,65.54 167.22,65.54 166.41,64.73 166.41,64.29 166.36,64.24 164.96,64.24 164.91,64.29 164.91,66.43 164.91,66.43 164.91,66.88 165.57,67.53 169.94,67.53
GND on BOTTOM (solid shape): 111.34,55.31 111.34,51.79 111.12,51.57 109.46,51.57 108.19,52.84 108.19,54.6 108.23,54.68 108.33,54.69 108.79,54.82 108.76,55.3 108.73,55.37 108.76,55.44 108.82,55.51 108.85,55.6 108.85,55.61 109.14,55.9 110.76,55.9
GND on BOTTOM (solid shape): 140.26,65.06 140.26,64.43 140.69,64 144.45,64 144.61,63.84 144.61,63.1 144.72,62.99 145.74,62.99 145.85,63.09 145.85,63.33 146.57,64.05 149.9,64.05 150.18,63.77 150.18,63.23 150.31,63.1 150.48,63.1 150.51,63.07 151.09,63.07 151.45,62.72 151.45,61.38 151.34,61.27 125.84,61.27 125.75,61.36 125.75,63.92 125.82,63.98 129.1,63.98 129.21,63.88 129.21,63.32 129.21,63.31 129.21,63.14 129.33,63.02 130.4,63.02 130.53,63.15 130.53,63.39 131.14,64 134.81,64 134.93,63.88 134.93,63.13 135.04,63.01 135.94,63.01 136,63.07 136.01,63.08 137.16,64.23 137.16,65.28 137.39,65.51 139.81,65.51
GND on BOTTOM (solid shape): 186.38,12.99 186.99,12.99 187.36,12.62 187.36,9.84 186.93,9.4 183.3,9.4 183.17,9.53 183.17,11.13 183.29,11.24 183.52,11.24 183.71,11.44 183.71,11.78 183.72,11.81 183.76,11.83 185.25,11.83 185.25,12.02 183.76,12.02 183.72,12.04 183.71,12.07 183.71,12.28 183.72,12.31 183.76,12.33 185.25,12.33 185.25,12.52 183.76,12.52 183.72,12.54 183.71,12.57 183.71,12.78 183.72,12.81 183.76,12.83 185.31,12.83 185.49,13.01 186.35,13.01
GND on BOTTOM (solid shape): 81.04,110.14 81.08,110.12 81.09,110.09 81.09,108.34 80.71,107.96 80.06,107.96 80.03,107.98 79.62,107.98 79.6,107.96 79.54,107.96 78.88,107.29 78.72,107.29 78.69,107.32 78.36,107.32 78.19,107.49 78.19,107.61 78.27,107.69 78.31,107.74 78.37,107.78 78.56,107.96 78.56,108.33 79.48,109.25 79.48,109.3 79.48,109.32 79.5,109.33 79.8,109.64 79.87,109.69 79.91,109.75 80.27,110.11 80.32,110.12 80.36,110.14
GND on BOTTOM (solid shape): 282.19,69.96 282.19,69.74 281.99,68.91 282.7,68.42 291.04,68.42 291.04,60.9 290.64,60.56 290.38,60.11 281.33,60.11 280.83,60.61 277.61,60.61 277.61,58.3 277.43,58.12 275.12,58.12 274.61,58.63 274.61,59.64 276.6,61.62 280.33,61.62 281.48,62.78 281.48,67.11 279.31,69.28 279.31,69.91 279.54,70.13 282.01,70.13
GND on BOTTOM (solid shape): 140.73,35.69 141.17,35.69 141.29,35.57 141.29,35.49 141.27,35.45 141.24,35.43 140.73,35.43 140.73,35.19 141.24,35.19 141.27,35.17 141.29,35.14 141.29,34.99 141.27,34.95 141.24,34.93 140.73,34.93 140.73,34.69 141.24,34.69 141.27,34.67 141.29,34.64 141.29,34.49 141.27,34.45 141.24,34.43 140.73,34.43 140.73,34.19 141.24,34.19 141.27,34.17 141.29,34.14 141.29,33.11 141.9,32.49 142.69,32.49 142.81,32.36 142.81,29.95 142.69,29.82 140.07,29.82 139.21,30.69 139.21,31.91 139.05,32.07 139.05,33.33 139.89,34.17 139.89,35.57 140.02,35.69 140.73,35.69
GND on BOTTOM (solid shape): 58.76,107.66 58.77,107.63 58.77,107.6 58.74,107.51 58.75,107.41 58.73,107.34 58.67,107.29 58.5,107.17 58.45,106.95 58.43,106.87 58.35,106.84 58.03,106.84 57.95,106.85 57.87,106.84 57.23,106.84 57.15,106.85 57.07,106.84 56.68,106.84 56.4,107.12 56.4,107.44 56.42,107.48 56.45,107.49 56.64,107.49 56.69,107.55 56.8,107.55 56.86,107.49 57.5,107.49 57.72,107.71 58.15,107.71 58.2,107.75 58.66,107.75
GND on BOTTOM (solid shape): 40.2,105.19 40.2,104.27 37.82,101.89 36.36,101.89 36.26,102 36.26,103.32 36.12,103.47 35.34,103.47 35.12,103.69 35.12,104.5 35.37,104.76 35.37,105.4 35.39,105.44 35.43,105.45 35.58,105.45 35.61,105.44 35.63,105.4 35.63,104.84 35.87,104.84 35.87,105.4 35.89,105.44 35.93,105.45 36.08,105.45 36.11,105.44 36.13,105.4 36.13,104.84 36.37,104.84 36.37,105.4 36.39,105.44 36.43,105.45 36.58,105.45 36.61,105.44 36.63,105.4 36.63,104.84 36.87,104.84 36.87,105.4 36.89,105.44 36.92,105.45 37.93,105.45 39.93,105.45
GND on BOTTOM (solid shape): 291.04,91.57 290.68,91.2 290.54,90.7 290.54,86.3 290.68,85.8 291.04,85.43 291.04,84.94 282.7,84.94 281.99,84.45 282.19,83.62 282.19,83.38 282.03,83.22 279.39,83.22 278.96,83.65 278.96,86.26 279.44,86.75 279.44,90.51 278.68,91.27 278.68,91.9 278.9,92.13 280.91,92.13 281.12,92.34 291.04,92.34
GND on BOTTOM (solid shape): 277.61,46.69 277.61,44.49 280.83,44.49 281.33,44.99 290.38,44.99 290.56,44.64 290.82,44.35 290.86,44.28 290.83,44.2 290.62,43.88 290.54,43.5 290.54,39.3 290.68,38.8 291.04,38.43 291.04,37.75 261.14,37.75 261.14,32 261,31.86 260.26,31.86 260.13,31.99 260.13,38.77 289.6,38.77 289.54,39.03 289.53,39.3 289.53,43.5 289.54,43.74 289.58,43.98 281.75,43.98 281.25,43.48 276.6,43.48 274.64,45.43 274.64,46.46 275.17,47 277.31,47
GND on BOTTOM (solid shape): 36.84,95.23 36.92,95.19 36.94,95.11 37.17,94.68 37.63,94.83 37.64,94.84 37.66,94.85 37.83,94.85 37.87,94.84 37.88,94.8 37.88,94.51 37.86,94.44 37.79,94.41 37.41,94.07 37.71,93.66 37.73,93.65 37.88,93.5 37.88,90.45 37.68,90.25 36.11,90.25 35.8,90.56 35.8,93.96 36.34,94.49 36.34,94.82 36.74,95.23
GND on BOTTOM (solid shape): 37.06,63.57 37.06,61.83 37.06,61.83 37.02,61.55 37.06,61.27 37.06,61.27 37.06,49.24 37.06,49.24 37.03,48.98 37.06,48.72 37.06,48.72 37.06,47.99 38.02,47.02 38.02,43.94 40.57,41.39 40.57,34.58 40.41,34.42 36.49,34.42 36.4,34.48 36.42,34.59 36.14,35.24 35.87,34.59 35.89,34.48 35.79,34.42 35.07,34.42 34.91,34.58 34.91,41.8 33.99,42.72 33.98,42.73 33.97,42.75 33.97,42.84 33.95,42.92 33.95,60.26 33.95,60.26 33.97,60.39 33.95,60.52 33.95,60.52 33.95,63.4 34.28,63.73 36.9,63.73
GND on BOTTOM (solid shape): outline of 109 points within 115.53,21.57 118.15,27.75
GND on BOTTOM (solid shape): outline of 81 points within 60.03,64.78 65.93,69.91
GND on BOTTOM (solid shape): outline of 81 points within 59.86,54.24 65.8,58.35
GND on BOTTOM (solid shape): 137.25,136.73 137.28,136.7 137.37,136.61 140.81,136.61 140.93,136.48 140.93,135.34 140.75,135.17 139.61,135.17 138.39,133.95 136.27,133.95 136.13,134.09 136.13,134.29 136.28,134.43 136.32,134.63 136.34,134.71 136.4,134.74 136.43,134.75 136.47,134.77 136.5,134.77 136.64,134.9 136.89,134.9 137.04,134.76 137.24,134.75 137.24,134.76 137.45,134.76 137.96,134.76 137.96,135.26 137.93,135.33 137.96,135.41 137.98,135.88 137.51,135.96 137.44,135.95 137.38,135.98 137.3,136.06 137.19,136.1 137.13,136.13 137.11,136.2 137.06,136.39 136.92,136.53 136.87,136.62 136.92,136.71 136.96,136.73
GND on BOTTOM (solid shape): 170.32,108 170.41,107.95 170.55,107.82 170.74,107.78 170.81,107.75 170.84,107.69 170.9,107.57 171.01,107.48 171.01,107.2 170.89,107.1 170.84,106.97 170.84,106.95 170.76,106.87 170.76,105.82 170.42,105.49 170.42,104.58 171.31,103.69 171.31,98.36 171.27,98.29 171.19,98.26 170.81,98.08 170.88,97.66 170.91,97.59 170.89,97.52 170.84,97.28 171.01,97.09 171.01,96.98 170.4,96.37 170.2,96.37 170.17,96.4 170.17,98.32 167.2,101.29 167.2,103.48 168.1,104.39 168.11,104.39 169.71,105.99 169.71,106.02 169.75,106.02 170.02,106.27 169.93,106.63 169.93,106.89 169.79,107.03 169.78,107.04 169.73,107.13 169.65,107.19 169.62,107.2 169.62,107.47 169.66,107.47 169.94,107.75 169.96,107.75 170.12,107.81 170.24,107.94
GND on BOTTOM (solid shape): 145.7,137.37 145.75,137.27 145.83,137.19 145.83,136.89 145.74,136.8 145.69,136.67 145.66,136.6 145.59,136.58 145.32,136.48 145.21,136.22 145.19,136.15 145.13,136.12 145.09,136.11 145.05,136.09 144.86,136.09 144.32,136.05 144.43,135.53 144.48,135.44 144.43,135.35 144.32,134.83 144.86,134.79 145.05,134.79 145.06,134.78 145.26,134.77 145.42,134.9 145.72,134.9 145.81,134.81 145.92,134.76 145.98,134.73 146,134.66 146.03,134.48 146.14,134.34 146.14,134.12 146.05,134.02 144.87,134.02 144.83,133.99 144.21,133.99 143.04,135.17 141.59,135.17 141.49,135.27 141.49,136.58 141.59,136.68 144.51,136.68 144.51,136.68 144.95,136.68 145.31,137.04 145.32,137.1 145.33,137.18 145.37,137.25 145.42,137.29 145.45,137.32 145.47,137.37
GND on BOTTOM (solid shape): 178.38,98.99 178.38,96.84 178.19,96.65 177.77,96.65 177.7,96.76 177.58,96.82 177.53,96.86 177.51,96.92 177.45,97.14 177.29,97.28 177.29,97.45 177.53,97.69 177.53,98.3 177.36,98.48 176.98,98.48 176.34,97.85 176.34,97.46 176.04,97.16 175.8,97.16 175.66,97.27 175.49,97.31 175.42,97.33 175.39,97.39 175.35,97.49 175.28,97.58 175.24,97.64 175.25,97.72 174.92,98.27 174.71,97.66 174.71,97.4 174.84,97.26 174.85,97.25 174.92,97.15 175.02,97.08 175.02,96.82 174.93,96.76 174.86,96.68 174.56,96.68 174.47,96.78 174.35,96.83 174.29,96.86 174.27,96.93 174.2,97.16 174,97.29 174,97.97 173.86,97.97 173.57,98.27 173.2,98.09 173.11,98.04 173.02,98.09 172.5,98.2 172.46,97.66 172.46,97.47 172.45,97.46 172.44,97.27 172.56,97.12 172.56,96.91 171.95,96.3 171.84,96.3 171.74,96.4 171.74,99.09 172.23,99.57 177.8,99.57
GND on BOTTOM (solid shape): outline of 191 points within 136.07,130.26 146.22,133.3
GND on BOTTOM (solid shape): outline of 130 points within 183.15,16.03 187.44,32.03
GND on BOTTOM (solid shape): outline of 238 points within 55.74,108.36 59.93,111.12
GND on BOTTOM (solid shape): outline of 134 points within 171.31,85.07 179.69,92.56
GND on BOTTOM (solid shape): outline of 771 points within 123.19,129.24 140.88,142.12
GND on BOTTOM (solid shape): outline of 1038 points within 141.47,129.24 159.14,141.56
GND on BOTTOM (solid shape): outline of 1649 points within 70.35,110.36 89.12,118.27
GND on BOTTOM (solid shape): outline of 1778 points within 159.3,104.65 179.52,125.71
GND on BOTTOM (solid shape): outline of 2040 points within 0.51,0.51 291.04,153.24
GND on SGND (solid shape): outline of 2897 points within 0.51,0.51 291.04,153.24
GND on IN1 (solid shape): 272.35,89.47 272.35,87.28 272.22,87.15 269.95,87.15 269.79,87.31 269.79,89.47 269.97,89.65 272.17,89.65
GND on IN1 (solid shape): 282.19,69.93 282.19,69.74 281.99,68.91 282.7,68.42 291.04,68.42 291.04,60.9 290.64,60.56 290.38,60.11 281.33,60.11 280.83,60.61 277.61,60.61 277.61,58.3 277.43,58.12 275.12,58.12 274.61,58.63 274.61,59.64 276.6,61.62 281.25,61.62 281.75,61.12 289.79,61.12 289.9,61.26 290.03,61.4 290.03,67.41 280.9,67.41 279.13,69.17 279.13,69.75 279.52,70.13 281.99,70.13
GND on IN1 (solid shape): 277.61,46.69 277.61,44.49 280.83,44.49 281.33,44.99 290.38,44.99 290.59,44.6 290.91,44.28 290.64,43.93 290.54,43.5 290.54,39.3 290.68,38.8 291.04,38.43 291.04,37.75 261.14,37.75 261.14,32 261,31.86 260.26,31.86 260.13,31.99 260.13,38.77 289.6,38.77 289.54,39.03 289.53,39.3 289.53,43.5 289.54,43.74 289.58,43.98 281.75,43.98 281.25,43.48 276.6,43.48 274.64,45.43 274.64,46.46 275.17,47 277.31,47
GND on IN1 (solid shape): 291.04,91.57 290.68,91.2 290.54,90.7 290.54,86.3 290.68,85.8 291.04,85.43 291.04,84.94 282.7,84.94 281.99,84.45 282.19,83.62 282.19,83.38 282.03,83.22 279.29,83.22 278.91,83.6 278.91,84.21 280.65,85.95 282.62,85.95 282.7,85.95 289.56,85.95 289.53,86.13 289.53,86.3 289.53,90.7 289.55,91.02 289.63,91.33 281.23,91.33 280.86,91.7 280.86,92.11 281.09,92.34 291.04,92.34
GND on IN1 (solid shape): outline of 2000 points within 0.51,0.51 291.04,153.24
GND on IN1 (solid shape): outline of 7223 points within 37.07,34.85 106.54,56.7
GND on IN1 (solid shape): outline of 17120 points within 121.37,84.99 179.67,142.12
GND on SVCC (solid shape): 157.32,141.75 160.84,133.24 169.35,129.72 179.82,129.72 179.82,107.73 179.82,106.25 179.82,96.63 179.82,95.93 179.99,91.23 180.52,86.56 180.53,86.51 181.18,82.66 181.22,82.48 157.86,82.48 155.9,84.44 155.82,84.49 155.72,84.51 149.55,84.51 146.14,87.92 146.14,91.65 146.11,91.78 146.01,91.87 146.01,96.07 146,96.12 145.97,96.16 145.5,96.63 145.5,106.25 145.49,106.3 145.46,106.35 144.53,107.28 144.49,107.31 144.44,107.32 137.25,107.32 136.89,107.69 136.84,107.72 136.79,107.73 131.12,107.73 131.03,107.82 130.9,107.85 127.35,107.85 121.68,113.52 121.68,141.2 122.7,142.22 157.32,142.22
GND on SVCC (solid shape): 48.17,98.93 48.25,98.83 48.35,98.75 48.35,98.63 48.36,98.58 48.39,98.54 48.51,98.42 48.55,98.39 48.6,98.38 57.14,98.38 58.19,97.33 58.23,97.3 58.28,97.29 62.01,97.29 62.07,97.3 62.11,97.33 62.63,97.85 63.41,97.85 64.56,96.7 64.56,96.41 63.99,95.83 63.96,95.79 63.95,95.74 63.95,93.32 63.96,93.27 63.99,93.23 64.33,92.89 64.33,91.98 64.14,91.79 64.11,91.75 64.1,91.7 64.1,89.14 63.38,88.41 63.35,88.37 63.34,88.32 63.34,83.88 63.35,83.82 63.38,83.78 63.79,83.37 63.79,83.21 63.7,83.11 63.67,82.99 63.67,68.61 63.44,68.38 63.38,68.3 63.36,68.2 63.36,55.94 63.38,55.84 63.44,55.76 64.58,54.61 64.58,43.65 64.09,43.16 37.5,43.16 37.5,48.04 39.38,48.98 37.5,49.92 37.5,60.6 39.38,61.55 37.5,62.5 37.5,86.69 44.11,93.3 44.28,93.26 44.46,93.25 44.47,93.25 45.73,94.4 44.7,95.77 45.25,96.32 45.45,96.32 45.55,96.34 45.63,96.4
GND on SVCC (solid shape): outline of 2038 points within 79.82,2.03 289.52,151.72
GND on IN2 (solid shape): 272.36,89.47 272.36,87.29 272.18,87.11 269.97,87.11 269.76,87.32 269.76,89.46 269.97,89.67 272.15,89.67
GND on IN2 (solid shape): 277.61,46.69 277.61,44.49 280.83,44.49 281.33,44.99 290.38,44.99 290.59,44.6 290.91,44.28 290.64,43.93 290.54,43.5 290.54,39.3 290.68,38.8 291.04,38.43 291.04,37.75 261.14,37.75 261.14,32 261,31.86 260.26,31.86 260.13,31.99 260.13,38.77 289.6,38.77 289.54,39.03 289.53,39.3 289.53,43.5 289.54,43.74 289.58,43.98 281.75,43.98 281.25,43.48 276.6,43.48 274.64,45.43 274.64,46.46 275.17,47 277.31,47
GND on IN2 (solid shape): 282.19,69.92 282.19,69.74 281.99,68.91 282.7,68.42 291.04,68.42 291.04,60.9 290.64,60.56 290.38,60.11 281.33,60.11 280.83,60.61 277.61,60.61 277.61,58.33 277.41,58.12 275.17,58.12 274.69,58.6 274.69,59.72 276.6,61.62 281.25,61.62 281.75,61.12 289.79,61.12 289.9,61.26 290.03,61.4 290.03,67.41 280.9,67.41 279.39,68.92 279.39,69.51 279.64,69.76 279.92,69.76 280.29,70.13 281.98,70.13
GND on IN2 (solid shape): 291.04,91.57 290.68,91.2 290.54,90.7 290.54,86.3 290.68,85.8 291.04,85.43 291.04,84.94 282.7,84.94 281.99,84.45 282.19,83.62 282.19,83.38 282.03,83.22 279.29,83.22 278.91,83.6 278.91,84.18 280.68,85.95 289.56,85.95 289.53,86.13 289.53,86.3 289.53,90.7 289.55,91.02 289.63,91.33 281.2,91.33 280.89,91.64 280.89,92.08 281.15,92.34 291.04,92.34
GND on IN2 (solid shape): outline of 2040 points within 0.51,0.51 291.04,153.24
GND on IN2 (solid shape): outline of 24486 points within 35.82,39.86 109.31,99.33
GND on IN3 (solid shape): 272.29,89.47 272.29,87.3 272.13,87.14 269.94,87.14 269.85,87.22 269.85,89.56 269.93,89.63 272.13,89.63
GND on IN3 (solid shape): 282.19,69.92 282.19,69.74 281.99,68.91 282.7,68.42 291.04,68.42 291.04,60.9 290.64,60.56 290.38,60.11 281.33,60.11 280.83,60.61 277.61,60.61 277.61,58.33 277.41,58.12 275.17,58.12 274.69,58.6 274.69,59.72 276.6,61.62 281.25,61.62 281.75,61.12 289.79,61.12 289.9,61.26 290.03,61.4 290.03,67.41 280.69,67.41 278.91,69.19 278.91,69.75 279.29,70.13 281.98,70.13
GND on IN3 (solid shape): 277.61,46.69 277.61,44.49 280.83,44.49 281.33,44.99 290.38,44.99 290.56,44.64 290.82,44.35 290.86,44.28 290.83,44.2 290.62,43.88 290.54,43.5 290.54,39.3 290.68,38.8 291.04,38.43 291.04,37.75 261.14,37.75 261.14,32 261,31.86 260.26,31.86 260.13,31.99 260.13,38.77 289.6,38.77 289.54,39.03 289.53,39.3 289.53,43.5 289.54,43.74 289.58,43.98 281.75,43.98 281.25,43.48 276.6,43.48 274.69,45.38 274.69,46.41 275.27,47 277.31,47
GND on IN3 (solid shape): 291.04,91.57 290.68,91.2 290.54,90.7 290.54,86.3 290.68,85.8 291.04,85.43 291.04,84.94 282.7,84.94 281.99,84.45 282.19,83.62 282.19,83.38 282.03,83.22 279.29,83.22 278.91,83.6 278.91,84.18 280.68,85.95 289.56,85.95 289.53,86.13 289.53,86.3 289.53,90.7 289.55,91.02 289.63,91.33 281.2,91.33 280.89,91.64 280.89,92.08 281.15,92.34 291.04,92.34
GND on IN3 (solid shape): outline of 1994 points within 0.51,0.51 291.04,153.24
GND on IN3 (solid shape): outline of 25832 points within 34.15,32.06 106.79,101.96
GND on SGND1 (solid shape): outline of 2805 points within 0.51,0.51 291.04,153.24
GND on IN4 (solid shape): 272.33,89.54 272.33,87.28 272.2,87.15 269.93,87.15 269.8,87.27 269.8,89.47 270,89.67 272.2,89.67
GND on IN4 (solid shape): 282.19,69.92 282.19,69.74 281.99,68.91 282.7,68.42 291.04,68.42 291.04,60.9 290.64,60.56 290.38,60.11 281.33,60.11 280.83,60.61 277.61,60.61 277.61,58.33 277.41,58.12 275.17,58.12 274.66,58.63 274.66,59.69 276.6,61.62 281.25,61.62 281.75,61.12 289.79,61.12 289.9,61.26 290.03,61.4 290.03,67.41 280.57,67.41 278.91,69.07 278.91,69.75 279.29,70.13 281.98,70.13
GND on IN4 (solid shape): 277.61,46.69 277.61,44.49 280.83,44.49 281.33,44.99 290.38,44.99 290.56,44.64 290.82,44.35 290.86,44.28 290.83,44.2 290.62,43.88 290.54,43.5 290.54,39.3 290.68,38.8 291.04,38.43 291.04,37.75 261.14,37.75 261.14,32 261,31.86 260.26,31.86 260.13,31.99 260.13,38.77 289.6,38.77 289.54,39.03 289.53,39.3 289.53,43.5 289.54,43.74 289.58,43.98 281.75,43.98 281.25,43.48 276.6,43.48 274.69,45.38 274.69,46.51 275.17,47 277.31,47
GND on IN4 (solid shape): 291.04,91.57 290.68,91.2 290.54,90.7 290.54,86.3 290.68,85.8 291.04,85.43 291.04,84.94 282.7,84.94 281.99,84.45 282.19,83.62 282.19,83.38 282.03,83.22 279.29,83.22 278.91,83.6 278.91,84.21 280.65,85.95 289.56,85.95 289.53,86.13 289.53,86.3 289.53,90.7 289.55,91.02 289.63,91.33 281.2,91.33 280.89,91.64 280.89,92.08 281.15,92.34 291.04,92.34
GND on IN4 (solid shape): outline of 2012 points within 0.51,0.51 291.04,153.24
GND on SGND2 (solid shape): outline of 3227 points within 0.51,0.51 291.04,153.24
VDD10 on TOP (solid shape): 276.15,84.07 276.15,82.77 275.65,82.27 275.65,81.36 275.43,81.14 274.74,81.14 274.41,81.46 274.41,82.66 274.81,83.06 275.13,83.06 275.13,84 275.38,84.25 275.98,84.25
VDD10 on BOTTOM (solid shape): 274.22,91.26 274.22,91.25 274.29,91.11 274.41,91.01 274.43,90.99 274.43,90.96 274.43,89.82 274.43,89.81 274.41,89.68 274.43,89.55 274.43,89.54 274.43,85.81 273.72,85.1 270.88,85.1 270.8,85.14 270.79,85.24 270.72,85.66 270.3,85.75 270.2,85.86 270.2,86.29 270.3,86.39 273.06,86.39 273.29,86.62 273.29,89.24 273.39,89.34 273.39,90.51 273.33,90.57 269.55,90.57 269.29,90.82 269.29,90.85 269.29,90.86 269.29,91.02 269.23,91.18 269.23,91.57 269.43,91.78 273.7,91.78
VDD10 on IN3 (solid shape): outline of 202 points within 269.14,81.04 275.37,91.98
5388BST_S on BOTTOM (solid shape): 15.71,40.34 15.71,38.08 15.63,38 14.77,38 14.62,38.16 14.62,39.15 14.11,39.65 14.11,40.16 14.39,40.44 15.61,40.44
5388PHASE on BOTTOM (solid shape): 22.47,41.61 22.47,38.41 23.32,37.56 23.32,35.08 23.29,35.01 23.22,34.98 22.91,34.82 22.84,34.39 22.76,34.35 18.89,34.35 18.63,34.6 18.63,36.3 18.91,36.58 19.95,36.58 21.15,37.77 21.15,38.77 20.98,38.93 20.98,41.65 21.03,41.7 22.38,41.7
+APU_VDD_33_S5 on TOP (solid shape): 83.17,106.32 83.17,106.3 83.42,105.99 83.8,106.1 83.89,106.14 83.97,106.09 84.09,105.98 84.25,105.93 84.29,105.92 84.3,105.88 84.3,105.15 84.42,105.03 85.31,105.03 85.58,104.91 85.86,105.03 86.27,105.03 86.28,105.03 86.28,104.45 86.18,104.35 85.92,104.38 85.71,104.22 85.63,104.18 85.55,104.22 85.3,104.36 85.02,104.27 84.95,104.25 84.88,104.28 84.61,104.4 84.35,104.29 84.27,104.26 84.2,104.29 84.13,104.36 84.05,104.39 84.03,104.47 83.99,104.68 83.85,104.84 83.79,104.87 83.73,104.89 83.49,104.86 83.31,104.69 83.23,104.64 83.15,104.67 83.06,104.76 83.06,104.79 82.99,104.95 82.83,105.02 82.8,105.02 82.18,105.02 81.79,105.41 81.78,105.42 81.73,105.51 81.64,105.58 81.64,106.15 81.84,106.35 83.14,106.35
+APU_VDD_33_S5 on BOTTOM (solid shape): 82.81,105.53 82.95,105.5 83.09,105.53 83.1,105.54 83.34,105.54 83.52,105.36 83.52,104.85 83.06,104.39 82.02,104.39 81.79,104.63 81.79,105.24 81.8,105.31 82.02,105.54 82.8,105.54
+CARD_3V on BOTTOM (solid shape): 261.1,20.73 261.1,19.84 260.76,19.49 260.01,19.49 259.4,18.89 256.81,18.89 256.64,19.07 256.64,20.39 256.65,20.41 256.65,20.76 256.82,20.93 260.9,20.93
+CARD_3V on BOTTOM (solid shape): 250.46,19.28 250.46,18.22 250.23,17.99 250.23,17.33 250.66,16.9 250.83,16.9 250.83,16.88 251.82,16.88 251.83,16.87 251.83,16.64 251.81,16.61 251.78,16.59 250.2,16.59 249.31,17.48 249.31,19.39 249.39,19.46 250.27,19.46
+CARD_3V on IN3 (solid shape): 258.03,19.75 258.03,18.27 257.14,17.38 250.56,17.38 249.59,18.34 249.59,19.26 249.8,19.46 250.61,19.46 251.5,18.57 253.99,18.57 255.6,20.18 257.59,20.18
+DC_IN on BOTTOM (solid shape): 53.25,9.19 53.25,8.11 53.79,7.57 56.58,7.57 56.86,7.29 56.86,4.59 56.81,4.54 51.95,4.54 51.85,4.63 51.85,9.63 51.93,9.71 52.73,9.71
+DC_IN_SS on BOTTOM (solid shape): 58.64,11.97 58.79,11.81 59.01,11.76 59.09,11.73 59.12,11.66 59.12,11.46 59.27,11.31 59.27,7.73 59.2,7.65 56.91,7.65 56.66,7.9 56.66,9.5 56.55,9.61 55.69,9.61 55.56,9.48 55.56,8.06 55.54,8.03 53.68,8.03 53.4,8.32 53.4,11.38 53.99,11.97
+DCIN_JACK on TOP (solid shape): 51.37,7.47 51.37,5.31 51.13,5.07 46.67,5.07 46.58,5.15 46.58,7.81 46.66,7.89 50.96,7.89
+DCIN_JACK on BOTTOM (solid shape): 51.36,7.92 51.36,4.2 51.19,4.03 41.7,4.03 41.66,4.07 41.66,7.81 41.94,8.09 51.2,8.09
+LCDVCC on TOP (solid shape): 171.55,53.69 173.1,53.69 173.37,53.42 173.37,53.22 173.31,53.01 173.37,52.81 173.37,52 172.84,51.47 172.31,51.47 171.18,52.6 170.75,52.6 170.14,53.2 170.14,54.37 170.19,54.42 170.82,54.42
+LCDVCC on BOTTOM (solid shape): 173.22,51.87 173.22,49.38 173.19,49.36 173.04,49.36 172.99,49.41 172.99,50.5 172.96,50.53 172.73,50.53 172.71,50.5 172.71,49.38 172.68,49.36 172.5,49.36 172.48,49.38 172.48,50.5 172.43,50.55 172.28,50.55 172.23,50.5 172.23,49.41 172.17,49.36 172.02,49.36 171.97,49.41 171.97,50.5 170.62,51.85 170.62,52.73 170.93,53.04 172.05,53.04
+LED_BL on TOP (solid shape): 184.75,51.27 184.75,46.89 184.62,46.77 181.34,46.77 181.27,46.84 181.27,48.34 181.52,48.6 181.52,50.63 181.67,50.78 181.7,50.79 181.72,50.79 182.08,50.91 182.16,51.28 182.16,51.31 182.18,51.33 182.21,51.36 184.66,51.36
+LED_BL on BOTTOM (solid shape): 185.71,50.45 185.71,49.26 185.74,49.23 185.94,49.23 185.99,49.28 185.99,50.45 186.02,50.47 186.17,50.47 186.22,50.42 186.22,49.28 186.25,49.26 186.45,49.26 186.47,49.28 186.47,50.42 186.53,50.47 186.7,50.47 186.73,50.45 186.73,49.28 186.75,49.26 186.96,49.26 186.98,49.28 186.98,50.45 187.01,50.47 187.29,50.47 187.34,50.42 187.34,48.48 187.33,48.46 187.32,48.44 187.22,48.35 187.14,48.25 186.98,48.09 186.98,46.69 186.86,46.56 184.32,46.56 184.24,46.64 184.24,48.98 184.42,49.15 185.36,49.15 185.46,49.26 185.46,50.45 185.48,50.47 185.69,50.47
+PWR_SRC on TOP (solid shape): 142.71,9.18 142.71,8.39 142.63,8.31 139.05,8.31 138.98,8.39 138.98,10.01 139.1,10.13 141.75,10.13
+PWR_SRC on TOP (solid shape): 19.11,32.24 19.11,30.33 18.86,30.08 16.07,30.08 15.81,30.33 15.81,32.49 16.07,32.75 17.34,32.75 17.84,33.25 18.1,33.25
+PWR_SRC on TOP (solid shape): 160.45,66.26 160.45,59.68 160.08,59.31 159.24,59.31 158.13,60.42 158.13,65.41 157.74,65.8 157.74,66.84 157.93,67.04 159.67,67.04
+PWR_SRC on TOP (solid shape): 167.86,63.96 167.86,60.35 167.38,59.87 165.84,59.87 165.01,60.7 165.01,63.99 165.09,64.06 167.75,64.06
+PWR_SRC on TOP (solid shape): 40.2,108.55 40.2,106.07 40.2,106.05 40.19,106.03 40.12,105.96 38.27,105.96 38.12,106.11 38.12,108.5 38.41,108.79 39.96,108.79
+PWR_SRC on TOP (solid shape): 41.85,112.3 41.85,111.74 41.64,111.54 39.1,111.54 39,111.64 39,111.94 39.18,112.12 41.16,112.12 41.42,112.37 41.77,112.37
+PWR_SRC on TOP (solid shape): 20.31,37.32 20.31,34.78 19.98,34.46 17.3,34.46 17.29,34.45 16.33,34.45 16.29,34.49 16.29,35.27 16.37,35.35 16.99,35.35 17.59,35.95 17.59,37.11 17.92,37.44 20.18,37.44
+PWR_SRC on TOP (solid shape): 145.23,33.6 145.23,31.22 144.9,30.89 143.37,30.89 143.19,31.07 143.19,33.28 143.67,33.76 145.07,33.76
+PWR_SRC on TOP (solid shape): 183.53,46.16 183.53,43.09 183.43,42.99 182.47,42.99 181.7,42.22 179.85,42.22 179.77,42.3 179.77,44.12 179.85,44.2 180.74,44.2 181.25,44.71 182.05,44.71 182.28,44.94 182.28,46.21 182.31,46.23 183.45,46.23
+PWR_SRC on TOP (solid shape): outline of 205 points within 127.6,55.67 150.43,59.8
+PWR_SRC on TOP (solid shape): outline of 313 points within 54.37,139.83 94.86,151.21
+PWR_SRC on BOTTOM (solid shape): 10.61,26.9 10.61,26.14 9.97,25.51 8.19,25.51 8.07,25.63 8.07,26.9 8.32,27.16 10.35,27.16
+PWR_SRC on BOTTOM (solid shape): 23.31,60.69 23.31,58.65 22.92,58.27 20.89,58.27 20.64,58.53 20.64,59.29 22.29,60.94 23.05,60.94
+PWR_SRC on BOTTOM (solid shape): 65.16,9.02 65.16,5.75 64.91,5.49 62.7,5.49 62.6,5.59 62.6,6.38 62.62,6.41 63.26,6.41 63.28,6.42 63.28,7.78 62.7,7.78 62.62,7.85 62.62,8.84 63.03,9.25 64.94,9.25
+PWR_SRC on BOTTOM (solid shape): 102.63,16.39 102.63,15.68 102.83,15.47 104.93,15.47 105.18,15.22 105.18,12.87 105.04,12.73 104.05,12.73 103.63,12.31 99.95,12.31 99.78,12.48 99.78,15.27 99.94,15.42 101.21,15.42 101.38,15.6 101.38,16.46 101.49,16.57 102.45,16.57
+PWR_SRC on BOTTOM (solid shape): 86.93,11.87 86.93,7.02 87.53,6.42 87.53,5.57 86.59,4.63 85.08,4.63 83.96,5.75 82.18,5.75 81.97,5.96 81.97,8.23 81.98,8.23 81.75,8.46 77.81,8.46 77.58,8.69 77.58,11.87 77.76,12.04 86.75,12.04
+PWR_SRC on BOTTOM (solid shape): 143.82,37.51 143.82,36.82 143.9,36.73 144.26,36.73 144.31,36.68 144.31,33.81 144.34,33.78 145.29,33.78 145.79,33.28 145.86,33.28 146.04,33.1 147.31,33.1 147.41,33 147.66,33.26 147.66,33.44 147.96,33.73 147.98,33.75 148,33.79 148.03,33.83 148.04,33.86 148.12,33.94 149.49,33.94 150.1,33.33 150.1,31.3 149.01,30.21 147.89,30.21 147.89,30.21 147.62,30.21 147.13,29.72 143.32,29.72 142.94,30.1 142.94,32.42 142.94,32.42 142.94,33.11 144.06,33.11 144.06,33.72 143.82,33.72 143.82,33.11 142.94,33.11 142.94,36.71 142.96,36.73 143.45,36.73 143.56,36.85 143.56,37.51 143.6,37.55 143.78,37.55
+PWR_SRC on BOTTOM (solid shape): 20.61,40.14 20.61,38.87 20.94,38.54 20.94,37.8 19.88,36.73 18.76,36.73 18.45,36.43 18.45,35.14 18.35,35.04 18.35,33.18 18.24,33.07 18.24,30.93 17.42,30.11 15.49,30.11 15.2,30.4 15.2,33.61 15.28,33.69 15.28,35.59 15.46,35.77 15.89,35.77 16.14,36.02 16.14,37.42 16.35,37.62 16.84,37.62 17.59,37.62 17.76,37.62 18.07,37.93 20.72,37.93 20.72,38.54 20.52,38.54 20.52,37.93 20.32,37.93 20.32,38.54 20.12,38.54 20.12,37.93 19.92,37.93 19.92,38.54 19.72,38.54 19.72,37.93 18.07,37.93 18.35,38.22 19.08,38.22 19.57,38.71 19.57,40.14 19.62,40.19 20.56,40.19
+PWR_SRC on BOTTOM (solid shape): 144.78,16.96 144.78,16.02 144.46,15.7 144.2,15.7 143.34,14.84 143.34,14.84 143.13,14.63 143.13,13.88 143.34,13.67 143.34,12.47 143.35,12.32 143.17,12.15 142.28,12.15 142.28,12.08 142.28,12.07 142.28,11.03 142.39,11.03 142.43,11.01 142.44,10.98 142.44,10.96 142.83,10.57 142.83,10.33 142.86,10.18 142.94,10.06 142.94,8.79 142.69,8.54 139.05,8.54 138.67,8.16 136.08,8.16 135.95,8.29 135.95,10.9 136.84,11.79 136.84,12.48 138.14,13.77 141.21,13.77 141.5,14.06 141.5,14.61 141.49,14.61 141.34,14.76 141.34,16.66 141.34,16.67 141.34,17.62 141.39,17.67 144.07,17.67
+PWR_SRC on BOTTOM (solid shape): 166.76,64.1 166.8,64.08 167.02,63.86 167.03,63.85 167.32,63.56 170.7,63.56 170.75,63.51 170.75,62.84 170.88,62.72 171.51,62.72 171.54,62.71 171.55,62.7 171.55,62.51 171.54,62.5 171.51,62.49 170.8,62.49 170.73,62.41 170.73,61.93 170.7,61.9 167.86,61.9 167.83,61.88 167.83,60.99 167.85,60.97 167.85,60.67 168.37,60.15 168.37,59.59 168.29,59.52 166.97,59.52 166.56,59.11 166.56,58.66 166.33,58.43 164.57,58.43 164.3,58.71 164.3,60.58 164.73,61.01 164.73,62.23 167.76,62.23 167.76,62.48 167.15,62.48 167.15,62.23 164.73,62.23 164.73,63.7 165.13,64.1
+PWR_SRC on BOTTOM (solid shape): 157.94,13.96 157.94,12.15 158.23,11.87 160.67,11.87 160.81,11.73 160.81,10.45 160.93,10.33 160.93,10.32 161.21,10.06 161.58,10.11 161.85,10.11 162.09,10.04 162.33,10.11 162.6,10.11 162.84,10.04 163.08,10.11 163.11,10.11 163.31,9.91 165.52,9.91 165.65,9.78 165.65,6.96 165.52,6.84 162.01,6.84 161.15,7.7 159.83,7.7 159.4,8.13 156.1,8.13 155.85,8.39 155.85,11.25 155.85,11.25 155.85,11.54 156.11,11.79 156.11,13.95 156.41,14.25 157.65,14.25
+PWR_SRC on BOTTOM (solid shape): 68.26,146.28 68.26,145.32 68.25,145.28 68.21,145.27 66.74,145.27 65.82,144.35 65.82,143.13 66.22,142.73 66.77,142.73 66.97,142.94 68.15,142.94 68.16,142.94 68.2,142.94 68.2,142.98 68.25,143.03 68.25,143.98 69.03,144.76 72.71,144.76 73.09,144.38 73.09,142.73 72.96,142.6 71.31,142.6 70.8,142.09 70.8,141.58 70.68,141.46 66.1,141.46 65.72,141.08 64.59,141.08 64.59,141.08 64.46,141.1 64.33,141.08 64.32,141.08 61.94,141.08 61.41,141.61 56.66,141.61 56.1,141.05 56.1,139.96 55.87,139.73 54.75,139.73 54.39,140.09 54.39,142.45 54.8,142.85 56.65,142.85 56.8,143 59.04,143 59.06,143.02 59.06,144.77 59.07,144.79 59.44,145.05 59.78,145.34 60.01,145.57 60.23,145.82 60.82,146.41 68.14,146.41
+PWR_SRC on BOTTOM (solid shape): 41.16,111.99 41.16,111.66 41.01,111.51 40.84,111.51 40.42,111.1 40.42,110.54 40.42,110.54 40.42,110.12 40.45,110.09 40.45,109.59 40.45,109.5 40.45,108.69 40.44,108.68 40.44,108.11 40.43,108.09 40.42,108.05 40.42,108.03 40.42,107.73 40.42,107.69 40.42,107.67 40.34,107.59 40.31,107.57 40.26,107.54 40.22,107.5 40.18,107.46 40.16,107.41 40.14,107.36 40.12,107.3 40.12,107.25 40.12,107.19 40.13,107.14 40.15,107.09 40.18,107.04 40.2,107.01 40.2,105.96 39.99,105.76 38.26,105.76 38.11,105.9 38.11,106.51 38.08,106.54 38.08,106.54 37.71,106.91 34.48,106.91 34.35,107.04 34.35,107.62 34.31,107.66 33.56,107.66 33.54,107.67 33.52,107.69 33.52,107.89 33.54,107.91 33.56,107.92 37.96,107.92 37.96,108.16 37.35,108.16 37.35,107.92 34.29,107.92 34.35,107.98 34.35,108.44 34.42,108.51 37.26,108.51 37.26,109.55 37.76,110.05 37.76,110.62 37.86,110.72 38.16,110.72 38.41,110.48 38.93,110.48 38.97,110.51 38.97,110.56 38.97,110.56 38.97,112.04 39.05,112.12 41.03,112.12
+PWR_SRC on BOTTOM (solid shape): outline of 163 points within 73.85,139.68 104.33,151.68
+PWR_SRC on BOTTOM (solid shape): outline of 295 points within 125.72,53.75 160.21,67.02
+PWR_SRC on IN1 (solid shape): outline of 1776 points within 1.55,1.53 24.6,63.23
+PWR_SRC on IN1 (solid shape): outline of 1949 points within 37.64,125.96 96.08,151.21
+PWR_SRC on SVCC (solid shape): outline of 11374 points within 0.51,0.51 183.33,153.24
+PWR_SRC on IN3 (solid shape): outline of 659 points within 1.52,1.55 20.75,27.77
+PWR_SRC on IN4 (solid shape): outline of 1283 points within 1.52,1.53 20.51,33.39
+PWR_SRC on IN4 (solid shape): outline of 1626 points within 44.97,125.81 96.13,151.21
+SMDDR_VTT on TOP (solid shape): 18.1,46.84 18.1,44.66 17.96,44.52 17.57,44.52 17.28,44.82 17.28,46.97 17.45,47.15 17.79,47.15
+SMDDR_VTT on TOP (solid shape): 107.38,45.8 107.38,45.8 107.78,45.39 107.98,45.39 108.24,45.39 108.6,45.75 109.2,45.75 109.29,45.66 109.29,44.09 109.35,44.03 109.35,43.19 109.01,42.85 106.67,42.85 105.58,43.95 105.58,46.59 105.86,46.87 106.31,46.87
+SMDDR_VTT on TOP (solid shape): 68.19,33.99 68.19,32.59 68.06,32.47 65.62,32.47 65.51,32.58 65.49,32.61 65.52,32.86 65.41,33.05 65.39,33.12 65.41,33.19 65.49,33.5 65.31,33.76 65.27,33.83 65.29,33.92 65.57,34.19 67.98,34.19
