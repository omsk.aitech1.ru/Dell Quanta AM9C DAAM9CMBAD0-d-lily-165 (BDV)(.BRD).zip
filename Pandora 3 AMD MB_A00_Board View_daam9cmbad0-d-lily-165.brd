# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXN1_LAN_C: length 13.1
  BOTTOM w0.114: C750.1 64.47,124.2 64.38,124.11 64.38,123.35 64.14,123.12 63.89,123.12 63.77,123 63.77,122.6 64.2,122.17 64.2,121.57 63.77,121.14 63.77,120.8 65.35,119.23 65.35,116.95 65.77,116.52 65.77,116.08 65.7,116.01 65.7,115.79 65.77,115.72 65.77,115.28 65.7,115.21 65.7,114.99 65.77,114.92 65.77,114.69 66.04,114.42 66.75,114.42 66.85,114.52 U18.R3
PCIE_TXP0_WLAN: length 148.2
  IN3 w0.114: v1(10.53,11.05) 10.76,11.27 10.99,11.27 11.28,11.56 11.28,12.31 10.76,12.83 10.76,14.94 14.18,18.36 14.94,18.36 17.24,20.66 19.11,22.53 19.11,23.5 19.42,23.8 20.66,23.8 22.39,25.53 24.54,25.53 29.8,30.79 29.8,57.7 29.13,58.37 29.13,63.33 34.41,68.6 34.41,74.68 38.83,79.11 38.83,86.83 42.59,90.58 42.59,97.24 46.96,101.61 46.96,107.56 47.64,108.24 50.44,108.24 50.98,108.78 50.98,110.75 52.9,112.67 52.9,115.87 53.49,116.47 53.49,118.89 55.99,121.39 65.06,121.39 65.43,121.76 v1(65.43,122.88)
  BOTTOM w0.114: C1100.2 65.4,122.07 65.27,122.2 65.27,122.71 v1(65.43,122.88) ; CN10.35 9.61,11.18 9.75,11.32 10.26,11.32 v1(10.53,11.05)
PCIE_TXP0_WLAN_C: length 12.9
  BOTTOM w0.114: U18.R1 66.85,116.12 66.79,116.05 66.66,116.05 66.53,116.18 66.53,116.42 67.05,116.94 67.05,117.45 66.81,117.69 66.04,117.69 65.91,117.81 65.91,118.05 66.04,118.18 67.24,118.18 67.42,118.36 67.42,118.76 67.07,119.11 66.1,119.11 65.98,119.24 65.98,119.48 66.1,119.6 66.69,119.6 66.94,119.85 66.94,120.52 66.57,120.9 66.2,120.9 65.53,120.22 65.36,120.22 65.16,120.41 65.16,121.16 65.29,121.29 C1100.1
PCIE_TXP1_LAN: length 287.4
  TOP w0.114: v1(267.22,85.32) 267.44,85.54 267.44,85.69 267.07,86.06 267.07,87.43 267.83,88.2 U2.13
  IN3 w0.114: v1(267.22,85.32) 267.53,85.02 267.53,84.85 267.7,84.68 267.7,84.35 267.52,83.94 266.95,82.65 266.95,76.41 266.43,73.08 265.84,70.5 265.82,70.39 265.82,70.39 265.72,69.94 264.6,66.31 264.42,65.89 263.51,63.71 263.51,59.09 262.68,58.27 261.58,54.59 261.47,54.21 261.47,52.93 260.92,52.38 259.68,49.83 257.6,47.75 250.49,44 230.84,38.12 218.85,38.12 204.72,43 195.69,43 192.53,46.16 192.5,46.19 190.55,50.87 190.37,51.04 190.36,51.05 187.44,53.98 179.04,76.52 175.72,79.84 171.62,82.46 161.38,82.46 158.13,83.2 155.13,83.2 148.69,85.1 148.01,85.78 148.01,86.13 145.25,88.89 145.19,88.95 144.87,89.27 139.01,91.98 135.41,91.98 134.95,92.23 134.6,92.67 134.07,94.82 133.26,95.64 130.56,95.64 129.93,96.27 129.9,96.3 124.79,108.87 124.49,109.17 123.39,110.27 122.72,110.27 122.42,110.56 122.42,111.85 119.41,114.86 114.08,117.29 106.87,124.5 101.07,124.5 97.34,125.37 93.07,126.56 91.42,126.56 90.93,127.05 73.85,127.05 68.69,126.54 64.42,126.54 64.22,126.34 64.22,126.11 v1(63.95,125.84)
  BOTTOM w0.114: v1(63.95,125.84) 64.26,125.53 64.26,125.35 C749.2
PCIE_TXP1_LAN_C: length 13.1
  BOTTOM w0.114: C749.1 64.16,123.94 64.16,123.44 64.05,123.33 63.8,123.33 63.56,123.09 63.56,122.51 63.99,122.08 63.99,121.66 63.56,121.23 63.56,120.71 65.13,119.14 65.13,116.86 65.56,116.43 65.56,116.17 65.48,116.09 65.48,115.7 65.56,115.63 65.56,115.37 65.48,115.29 65.48,114.9 65.56,114.83 65.56,114.6 65.95,114.21 66.66,114.21 66.85,114.02 U18.R4
PCIE_WAKE#: length 9.6
  BOTTOM w0.102: U18.AG2 76.45,115.87 76.57,115.99
  BOTTOM w0.114: R539.1 C761.2 80.73,119.89 80.2,119.36 77.47,119.36 76.57,118.46 76.57,116.62 76.76,116.43 76.76,116.17 76.58,115.99 76.57,115.99
PCIE_ZVSS: length 4.9
  BOTTOM w0.203: R652.1 125.76,90.53 128.58,93.35 U22.AU41
PCIERST#: length 564.4
  TOP w0.114: v1(104.6,105.38) 104.6,104.72 104.35,104.47 C758.2 C759.1 101.96,104.47 R522.2 ; v1(270.44,85.4) 270.48,85.43 U2.19 ; v1(180.73,28.08) 180.57,27.92 180.57,26.9 178.42,24.75 154.77,24.75 154.55,24.97 153.54,24.97 152.79,24.22 139.72,24.22 137.97,25.97 137.97,26.52 136.96,27.53 130.19,27.53 128.77,26.11 123.76,26.11 123.33,25.68 117.21,25.68 116.83,25.29 116.83,24.97 116.69,24.83 115.81,24.83 115.41,25.23 115.41,26.45 v1(115.32,26.54) 115.32,27.17 114.79,27.7 114.79,28.41 115.67,29.28 115.67,30.48 115.05,31.1 115.05,31.9 115.84,32.69 115.84,33.25 117.99,35.41 117.99,36.9 118.33,37.24 118.33,45.39 123.11,50.17 123.11,52.4 122.42,53.09 122.42,55.56 120.88,57.1 120.88,71.16 123.47,73.75 123.47,77.36 120.44,80.39 119.19,80.39 118.62,79.81 116.78,79.81 115.75,80.85 115.75,84.01 114.26,85.49 v1(114.26,86.62) v1(114.26,88.71) ; v1(5.45,12.79) 5.45,12.8 5.51,12.74 R1112.2 ; v1(53.33,27.18) 53.33,28.26 58.5,33.43 v1(65.11,33.43)
  IN1 w0.089: v1(114.26,88.71) 110.6,92.38 110.6,96.06 106.81,99.84 106.81,103.08 104.6,105.3 v1(104.6,105.38)
  IN4 w0.089: v1(5.45,12.79) 5.35,12.79 4.59,13.55 4.59,17.07 7.63,20.12 11.51,20.12 12.13,19.5 13.63,19.5 14.37,20.24 16.04,20.24 18.65,22.85 21.64,22.85 27.3,28.51 32.5,28.51 36.41,24.59 37.62,24.59 39.04,26.01 49.22,26.01 50.59,27.39 53.12,27.39 v1(53.33,27.18) 54.19,28.04 99.58,28.04 103.38,31.84 109.68,31.84 111.72,29.81 111.72,28.56 111.93,28.35 113.25,28.35 114.69,26.9 114.96,26.9 v1(115.32,26.54) ; v1(65.11,33.43) 62.49,36.06 38.94,36.06 37.07,37.93 37.07,46.1 35.02,48.15 35.02,58.1 34.13,58.98 34.13,60.86 33.65,61.34 33.65,65.4 36.7,68.44 36.7,85.7 35.17,87.23 35.17,89.42 36.51,90.76 36.51,94.65 36.92,95.06 v1(37.32,95.06) ; v1(180.73,28.08) 181.56,28.91 191.16,28.91 194.5,32.25 218.12,32.25 219.35,33.48 245.51,33.48 252.32,40.29 267.32,40.29 268.9,41.87 268.9,51.33 266.46,53.77 266.46,58.92 269.35,61.81 271.69,61.81 272.95,63.07 272.95,70.75 268.39,75.31 268.39,75.32 268.37,75.33 268.37,79.06 271.05,81.74 271.05,84.79 v1(270.44,85.4)
  BOTTOM w0.114: D18.1 40.96,94.01 40.8,93.85 39.14,93.85 39.05,93.93 D17.1 39.05,95.25 38.85,95.44 37.71,95.44 v1(37.32,95.06) ; U24.2 118.28,88.12 118.15,88.24 C965.1 116.7,88.71 v1(114.26,88.71)
PCLK_DEBUG: length 199
  IN4 w0.089: v1(112.39,29.72) 112.13,29.72 109.78,32.07 103.29,32.07 99.48,28.27 51.15,28.27 49.12,26.24 42.2,26.24 41.48,26.96 34.61,26.96 32.83,28.74 27.2,28.74 22.22,23.76 13.79,23.76 v1(12.24,22.2)
  BOTTOM w0.114: v1(12.24,22.2) 12.48,22.45 R1069.1 ; v1(112.39,29.72) v1(112.39,31.04) 112.39,43.69 111.05,45.04 111.05,46.98 113.56,49.5 113.56,53.15 113.24,53.47 113.24,55.48 110.41,58.31 110.41,73.28 107.21,76.48 107.21,90.58 109.83,93.2 109.83,99.87 105.52,104.18 105.52,107.61 103.87,109.26 102.88,109.26 C769.2 R590.1
PCLK_DEBUG_R: length 4.7
  BOTTOM w0.114: CN10.71 9.92,20.18 10.87,21.13 v1(10.87,21.47) 10.87,22.19 R1069.2
PEG_RXN0: length 85.3
  TOP w0.114: C948.1 120.8,94.05 120.69,93.95 120.4,93.95 119.91,93.46 119.91,93.01 119.72,92.82 116.47,92.82 v1(116.12,93.16)
  IN4 w0.102: v1(116.12,93.16) 116.12,92.99 115.94,92.8 114.58,92.8 112.51,94.87 112.51,103.2 111.28,104.42 111.28,109.19 106.42,114.06 106.42,117.46 104.67,119.2 99.03,119.2 97.44,117.61 93.43,117.61 91.5,119.54 88.87,119.54 88.19,120.21 77.05,120.21 75.4,118.56 71.53,118.56 70.28,117.31 70.28,116.02 68.62,114.36 68.62,111 67.32,109.71 67.24,109.71 v2(67.06,109.88)
  BOTTOM w0.114: v2(67.06,109.88) 67.04,109.9 U18.P9
PEG_RXN0_C: length 12.8
  TOP w0.114: v2(131.99,93.11) 131.76,92.88 131.76,92.55 131.4,92.19 128.35,92.19 127.37,93.17 124.8,93.17 124.15,93.82 123.19,93.82 122.93,94.07 121.85,94.07 C948.2
  BOTTOM w0.114: U22.AU35 132.01,93.11 v2(131.99,93.11)
PEG_RXN1: length 82.3
  TOP w0.114: C950.1 117.87,93.72 116.45,93.72 116.25,93.92 115.7,93.92 v1(115.47,93.69)
  IN4 w0.102: v1(115.47,93.69) 115.7,93.92 116.01,93.92 116.5,94.41 116.5,96.85 113.88,99.46 113.88,103.76 112.65,104.99 112.65,109.76 107.79,114.63 107.79,118.02 105.24,120.57 98.47,120.57 96.87,118.98 94,118.98 92.07,120.91 89.44,120.91 88.76,121.58 76.48,121.58 74.83,119.93 70.96,119.93 68.91,117.88 68.91,116.84 66.4,114.34 66.4,112.93 66.19,112.71 v1(65.88,112.71)
  BOTTOM w0.114: U18.N5 65.5,113.1 v1(65.88,112.71)
PEG_RXN1_C: length 15.4
  TOP w0.114: C950.2 119.04,93.76 119.09,93.81 119.55,93.81 120.75,95.01 121.76,95.01 122.34,95.59 126.47,95.59 128.86,93.2 130.81,93.2 130.94,93.07 130.94,92.92 130.8,92.78 v2(130.65,92.78)
  BOTTOM w0.114: U22.AU39 130.6,93.35 130.74,93.21 130.74,92.87 v2(130.65,92.78)
PEG_RXN2: length 85.9
  TOP w0.114: v1(114.78,94.97) 114.99,95.19 115.8,95.19 116.05,94.94 119.55,94.94 120.08,95.47 120.08,96.19 120.24,96.36 120.44,96.36 120.8,96 C952.1
  IN4 w0.102: v1(114.78,94.97) 114.99,95.18 115.22,95.18 115.51,95.47 115.51,96.86 113.2,99.18 113.2,103.48 111.97,104.71 111.97,109.47 107.1,114.34 107.1,117.74 104.96,119.89 98.75,119.89 97.16,118.29 93.72,118.29 91.79,120.22 89.15,120.22 88.48,120.9 76.76,120.9 75.11,119.24 71.24,119.24 69.6,117.6 69.6,116.38 67.65,114.44 67.65,111.01 67.21,110.57 66.54,110.57 66.22,110.24 v2(65.84,110.24)
  BOTTOM w0.102: v2(65.84,110.24) 65.71,110.24 U18.N8
PEG_RXN2_C: length 12.8
  TOP w0.114: C952.2 121.58,96.35 121.76,96.53 126.07,96.53 126.3,96.3 128.5,96.3 129.1,95.7 129.1,94.62 129.41,94.3 130.73,94.3 130.92,94.11 130.92,93.95 130.8,93.82 v2(130.63,93.82)
  BOTTOM w0.114: U22.AR38 131.15,94.35 v2(130.63,93.82)
PEG_RXN3: length 82.4
  TOP w0.114: C954.1 117.85,96.54 117.57,96.54 117.29,96.26 v1(117.29,96.26)
  IN4 w0.102: v1(64.62,112.37) 64.73,112.37 65.14,112.78 65.14,114.65 65.14,114.65 65.14,114.82 66.61,116.29 66.61,116.56 66.61,117.42 67.99,118.8 67.99,119.64 68.34,120 70.06,120 70.67,120.62 74.54,120.62 75.56,121.63 75.56,122.35 75.89,122.67 81.86,122.67 82.02,122.84 87.58,122.84 88.02,122.4 91.55,122.4 94.29,119.66 96.59,119.66 98.18,121.26 105.52,121.26 108.47,118.31 108.47,114.91 113.34,110.04 113.34,105.28 114.57,104.05 114.57,101.04 118.15,97.46 118.15,96.84 117.87,96.56 117.59,96.56 v1(117.29,96.26)
  BOTTOM w0.102: v1(64.62,112.37) 64.12,112.37 U18.L6
PEG_RXN3_C: length 15.9
  TOP w0.114: v2(131.41,94.96) 131.7,94.96 131.79,95.05 131.79,95.31 131.65,95.44 130.43,95.44 128.86,97.01 126.61,97.01 126.07,97.54 120.32,97.54 119.48,96.7 119.01,96.7 118.91,96.6 C954.2
  BOTTOM w0.114: U22.AN38 131.41,95.29 v2(131.41,94.96)
PEG_RXN4: length 85.8
  TOP w0.114: C956.1 120.67,98.88 120.58,98.97 120.09,98.97 119.59,98.47 119.16,98.47 119,98.31 v1(119,98.12)
  IN4 w0.102: v1(64.65,110.27) 64.65,110.19 64.48,110.01 64.33,110.01 64.14,110.2 64.14,115.45 65.64,116.95 65.64,118.58 67.53,120.48 69.86,120.48 70.47,121.1 71.63,121.1 73,122.47 74.63,122.47 75.32,123.16 81.66,123.16 81.82,123.32 87.78,123.32 88.22,122.89 91.75,122.89 92.44,122.2 96.53,122.2 96.99,121.74 105.72,121.74 108.96,118.51 108.96,115.11 113.82,110.24 113.82,105.48 115.05,104.25 115.05,101.24 117.9,98.39 118.91,98.39 119,98.3 v1(119,98.12)
  BOTTOM w0.114: v1(64.65,110.27) 64.61,110.32 64.05,110.32 63.95,110.22 63.95,110 U18.L9
PEG_RXN4_C: length 13.1
  TOP w0.114: C956.2 121.45,98.84 121.58,98.96 123.02,98.96 123.13,98.85 123.13,98.62 123.38,98.37 124.06,98.37 124.31,98.62 124.31,98.85 124.43,98.96 125.66,98.96 126.88,97.74 129.13,97.74 130.33,96.54 130.89,96.54 131.03,96.4 131.03,96.2 130.93,96.1 v2(130.7,96.1)
  BOTTOM w0.114: U22.AL38 130.7,96.2 v2(130.7,96.1)
PEG_RXN5: length 83.6
  TOP w0.114: v1(115.99,107.06) 115.7,106.77 115.26,106.77 115.02,106.53 115.02,102.23 117.17,100.08 117.89,100.08 118,99.97 C957.1
  IN4 w0.102: v1(115.99,107.06) 115.74,106.81 115.66,106.81 115.4,107.07 115.4,110.9 110.53,115.76 110.53,119.16 106.38,123.31 97.64,123.31 97.19,123.77 93.09,123.77 92.4,124.46 88.87,124.46 88.44,124.9 81.17,124.9 81,124.73 75.04,124.73 74.71,125.06 72.2,125.06 69.2,122.05 66.21,122.05 62.56,118.41 62.56,113.68 v1(62.32,113.44)
  BOTTOM w0.114: U18.K5 62.51,113.44 62.33,113.44 v1(62.32,113.44)
PEG_RXN5_C: length 16
  TOP w0.114: C957.2 118.78,100 118.86,100.08 122.39,100.08 122.62,99.85 125.78,99.85 127.18,98.46 129.54,98.46 130.41,97.59 131.72,97.59 131.84,97.46 131.84,97.19 131.73,97.08 v2(131.5,97.08)
  BOTTOM w0.114: U22.AJ38 131.5,97.4 v2(131.5,97.08)
PEG_RXN6: length 84.7
  TOP w0.114: C960.1 120.8,101.57 120.71,101.66 119.11,101.66 119,101.54 v1(119,101.35)
  IN4 w0.102: v1(119,101.35) 119,101.54 118.85,101.68 116.9,101.68 115.74,102.84 115.74,104.53 114.51,105.76 114.51,110.53 109.64,115.39 109.64,118.79 106.01,122.43 97.27,122.43 96.82,122.88 92.72,122.88 92.03,123.57 88.5,123.57 88.07,124.01 81.54,124.01 81.37,123.84 75.03,123.84 74.35,123.16 72.49,123.16 71.12,121.78 70.19,121.78 69.57,121.17 66.68,121.17 63.45,117.93 63.45,111.16 63.23,110.94 63.23,110.71 v1(63.45,110.49)
  BOTTOM w0.102: U18.K8 62.85,110.35 62.95,110.24 63.28,110.24 63.45,110.4 v1(63.45,110.49)
PEG_RXN6_C: length 12.7
  TOP w0.114: v2(130.7,98.3) 130.89,98.49 130.89,98.6 130.78,98.71 130.29,98.71 129.82,99.18 127.46,99.18 125.28,101.36 124.05,101.36 123.45,100.75 122.78,100.75 121.93,101.61 121.7,101.61 121.58,101.48 C960.2
  BOTTOM w0.114: U22.AG38 131.15,98.58 130.87,98.3 v2(130.7,98.3)
PEG_RXN7: length 86.9
  TOP w0.114: C962.1 117.42,102.69 117.29,102.82 116.19,102.82 115.8,103.22 115.8,104.23 116.11,104.55 116.39,104.55 116.61,104.76 v1(116.61,104.95)
  IN4 w0.102: v1(62.26,112.1) 61.92,112.1 61.83,112.19 61.83,113.63 62.08,113.88 62.08,118.61 66.21,122.73 66.21,125.71 66.52,126.03 77.24,126.03 77.79,125.48 92.07,125.48 93.29,124.25 97.39,124.25 97.84,123.8 106.58,123.8 111.01,119.36 111.01,115.96 115.88,111.1 115.88,108.44 116.89,107.43 116.89,105.53 117.31,105.11 117.31,104.87 117.01,104.57 116.76,104.57 116.61,104.73 v1(116.61,104.95)
  BOTTOM w0.114: U18.J6 61.85,112.1 v1(62.26,112.1)
PEG_RXN7_C: length 16.3
  TOP w0.114: C962.2 118.2,102.65 118.25,102.7 121.94,102.7 122.56,102.07 125.89,102.07 128.07,99.89 131.52,99.89 131.69,99.72 131.69,99.5 131.59,99.4 v2(131.45,99.4)
  BOTTOM w0.114: v2(131.45,99.4) 131.45,99.65 U22.AE38
PEG_RXP0: length 85.3
  TOP w0.114: C947.1 120.8,93.59 120.66,93.73 120.49,93.73 120.13,93.37 120.13,92.92 119.81,92.6 116.32,92.6 v1(116.12,92.4)
  IN4 w0.102: v1(67.17,109.22) 67.17,109.26 68.82,110.92 68.82,114.27 70.48,115.93 70.48,117.23 71.61,118.35 75.48,118.35 77.13,120.01 88.11,120.01 88.78,119.33 91.42,119.33 93.35,117.4 97.53,117.4 99.12,119 104.59,119 106.21,117.37 106.21,113.97 111.08,109.11 111.08,104.34 112.31,103.11 112.31,94.79 114.43,92.66 114.49,92.6 115.92,92.6 v1(116.12,92.4)
  BOTTOM w0.114: v1(67.17,109.22) 66.87,109.22 U18.P10
PEG_RXP0_C: length 12.8
  TOP w0.114: C947.2 121.58,93.68 121.76,93.86 122.84,93.86 123.1,93.61 124.06,93.61 124.71,92.95 127.28,92.95 128.26,91.97 131.49,91.97 132.01,92.49 v2(132.19,92.49)
  BOTTOM w0.114: U22.AV35 132.65,92.71 132.43,92.49 v2(132.19,92.49)
PEG_RXP1: length 82.3
  TOP w0.114: v1(115.47,94.45) 115.47,94.27 115.61,94.14 116.34,94.14 116.54,93.93 118.12,93.93 118.26,94.07 C949.1
  IN4 w0.102: v1(115.47,94.45) 115.47,94.22 115.57,94.13 115.92,94.13 116.29,94.49 116.29,96.76 113.68,99.38 113.68,103.68 112.45,104.91 112.45,109.67 107.58,114.54 107.58,117.94 105.16,120.37 98.55,120.37 96.96,118.78 93.92,118.78 91.99,120.71 89.35,120.71 88.68,121.38 76.56,121.38 74.91,119.73 71.04,119.73 69.11,117.8 69.11,116.76 66.61,114.25 66.61,112.76 v1(65.88,112.04)
  BOTTOM w0.114: U18.N6 65.62,112.3 v1(65.88,112.04)
PEG_RXP1_C: length 15.4
  TOP w0.114: C949.2 119.04,94.11 119.13,94.02 119.46,94.02 120.66,95.22 121.67,95.22 122.25,95.8 126.56,95.8 128.95,93.41 130.9,93.41 131.15,93.16 131.15,92.93 131.21,92.87 v2(131.35,92.73)
  BOTTOM w0.114: v2(131.35,92.73) 131.15,92.93 U22.AU38
PEG_RXP2: length 85.9
  TOP w0.114: C951.1 120.8,96.76 120.62,96.58 120.15,96.58 119.86,96.28 119.86,95.56 119.46,95.15 116.14,95.15 115.89,95.41 114.85,95.41 114.78,95.48 v1(114.78,95.74)
  IN4 w0.102: v1(65.9,109.6) 66.67,110.36 67.3,110.36 67.86,110.92 67.86,114.35 69.8,116.3 69.8,117.51 71.33,119.04 75.2,119.04 76.85,120.69 88.39,120.69 89.07,120.02 91.7,120.02 93.63,118.09 97.24,118.09 98.83,119.68 104.87,119.68 106.9,117.66 106.9,114.26 111.76,109.39 111.76,104.62 112.99,103.4 112.99,99.09 115.3,96.78 115.3,95.56 115.13,95.39 114.94,95.39 114.78,95.55 v1(114.78,95.74)
  BOTTOM w0.114: v1(65.9,109.6) 65.55,109.6 U18.N9
PEG_RXP2_C: length 12.7
  TOP w0.114: v2(131.4,93.85) 131.25,93.85 131.14,93.95 131.14,94.2 130.82,94.52 129.5,94.52 129.31,94.71 129.31,95.79 128.59,96.51 126.39,96.51 126.16,96.74 121.85,96.74 C951.2
  BOTTOM w0.114: U22.AR37 131.4,93.9 v2(131.4,93.85)
PEG_RXP3: length 82.4
  TOP w0.114: v1(117.29,97.02) 117.56,96.75 117.97,96.75 118.13,96.91 C953.1
  IN4 w0.102: v1(117.29,97.02) 117.55,96.76 117.78,96.76 117.94,96.92 117.94,97.38 114.36,100.96 114.36,103.96 113.14,105.19 113.14,109.96 108.27,114.83 108.27,118.22 105.44,121.05 98.26,121.05 96.67,119.46 94.2,119.46 91.46,122.2 87.93,122.2 87.5,122.64 82.11,122.64 81.94,122.47 75.97,122.47 75.76,122.26 75.76,121.55 74.63,120.41 70.76,120.41 70.14,119.79 68.43,119.79 68.19,119.56 68.19,118.71 66.81,117.34 66.81,116.65 66.82,116.65 66.82,116.21 65.34,114.74 65.34,112.44 v1(64.62,111.72)
  BOTTOM w0.114: U18.L7 64.4,111.5 v1(64.62,111.72)
PEG_RXP3_C: length 15.9
  TOP w0.114: C953.2 118.91,97.03 119.03,96.92 119.39,96.92 120.23,97.76 126.16,97.76 126.7,97.22 128.95,97.22 130.52,95.66 131.74,95.66 132,95.4 132,95.17 v2(132.21,94.96)
  BOTTOM w0.114: U22.AN37 132.21,95.29 v2(132.21,94.96)
PEG_RXP4: length 85.8
  TOP w0.114: C955.1 120.3,99.19 120,99.19 119.5,98.69 119.19,98.69 v1(119,98.88)
  IN4 w0.102: v1(64.65,109.58) 64.65,109.58 64.42,109.81 64.24,109.81 63.93,110.12 63.93,115.53 65.43,117.03 65.43,118.67 67.45,120.68 69.77,120.68 70.39,121.3 71.54,121.3 72.92,122.68 74.55,122.68 75.23,123.36 81.57,123.36 81.74,123.52 87.87,123.52 88.3,123.09 91.83,123.09 92.52,122.4 96.62,122.4 97.07,121.94 105.81,121.94 109.16,118.59 109.16,115.19 114.03,110.33 114.03,105.56 115.25,104.33 115.25,101.33 117.98,98.6 118.72,98.6 v1(119,98.88)
  BOTTOM w0.102: 64.05,108.98 v1(64.65,109.58)
  BOTTOM w0.114: U18.L10 64.05,108.98
PEG_RXP4_C: length 13.1
  TOP w0.114: v2(131.5,96.1) 131.24,96.36 131.24,96.49 130.98,96.76 130.42,96.76 129.22,97.96 126.97,97.96 125.75,99.18 124.34,99.18 124.1,98.94 124.1,98.71 123.97,98.58 123.47,98.58 123.35,98.71 123.35,98.94 123.11,99.18 121.83,99.18 C955.2
  BOTTOM w0.114: U22.AL37 131.5,96.2 v2(131.5,96.1)
PEG_RXP5: length 83.6
  TOP w0.114: v1(115.99,106.27) 115.7,106.56 115.35,106.56 115.24,106.44 115.24,102.32 117.26,100.3 117.91,100.3 118,100.39 C958.1
  IN4 w0.102: v1(62.32,112.76) 62.76,113.2 62.76,118.32 66.29,121.85 69.29,121.85 72.29,124.85 74.63,124.85 74.95,124.53 81.09,124.53 81.25,124.69 88.35,124.69 88.79,124.26 92.32,124.26 93.01,123.57 97.1,123.57 97.56,123.11 106.29,123.11 110.33,119.08 110.33,115.68 115.19,110.81 115.19,106.99 115.57,106.61 115.89,106.61 115.99,106.51 v1(115.99,106.27)
  BOTTOM w0.114: U18.K6 62.85,112.37 62.47,112.76 v1(62.32,112.76)
PEG_RXP5_C: length 16
  TOP w0.114: C958.2 119.18,100.3 122.48,100.3 122.71,100.07 125.87,100.07 127.26,98.67 129.63,98.67 130.5,97.8 131.81,97.8 132.06,97.55 132.06,97.33 v2(132.3,97.08)
  BOTTOM w0.114: U22.AJ37 132.3,97.4 v2(132.3,97.08)
PEG_RXP6: length 84.7
  TOP w0.114: v1(119,102.11) 119.24,101.87 120.57,101.87 C959.1
  IN4 w0.102: v1(63.45,109.83) 62.98,110.29 62.98,110.98 63.25,111.24 63.25,118.02 66.6,121.37 69.49,121.37 70.11,121.99 71.03,121.99 72.41,123.36 74.26,123.36 74.95,124.05 81.29,124.05 81.45,124.21 88.15,124.21 88.59,123.78 92.12,123.78 92.81,123.09 96.9,123.09 97.36,122.63 106.09,122.63 109.84,118.88 109.84,115.48 114.71,110.61 114.71,105.85 115.94,104.62 115.94,102.93 116.98,101.88 118.77,101.88 v1(119,102.11)
  BOTTOM w0.102: U18.K9 62.99,110.04 63.24,110.04 v1(63.45,109.83)
PEG_RXP6_C: length 12.7
  TOP w0.114: C959.2 121.85,101.82 122.02,101.82 122.87,100.97 123.36,100.97 123.96,101.57 125.37,101.57 127.55,99.4 129.91,99.4 130.38,98.93 130.87,98.93 131.22,98.58 v2(131.5,98.3)
  BOTTOM w0.114: U22.AG37 131.5,98.4 v2(131.5,98.3)
PEG_RXP7: length 86.9
  TOP w0.114: C961.1 117.19,103.04 116.28,103.04 116.02,103.31 116.02,104.14 116.2,104.33 116.43,104.33 v1(116.61,104.16)
  IN4 w0.102: v1(62.26,111.42) 62.26,111.47 61.63,112.11 61.63,113.72 61.88,113.97 61.88,118.69 66,122.82 66,125.79 66.44,126.23 77.33,126.23 77.87,125.68 92.15,125.68 93.38,124.46 97.47,124.46 97.93,124 106.66,124 111.22,119.45 111.22,116.05 116.08,111.18 116.08,108.52 117.09,107.51 117.09,105.62 117.51,105.19 117.51,104.79 117.09,104.37 116.82,104.37 v1(116.61,104.16)
  BOTTOM w0.114: v1(62.26,111.42) 61.73,111.42 U18.J7
PEG_RXP7_C: length 16.3
  TOP w0.114: C961.2 118.55,102.91 122.03,102.91 122.65,102.28 125.98,102.28 128.16,100.11 131.61,100.11 131.92,99.8 131.92,99.68 v2(132.2,99.4)
  BOTTOM w0.114: U22.AE37 132.2,99.7 v2(132.2,99.4)
PEG_TXN0: length 95.7
  IN1 w0.102: v1(125.97,92.43) 126.21,92.19 126.51,92.19 126.75,92.43 126.75,95.62 119.81,102.56 116.62,102.56 115.06,104.12 115.06,108.04 111.03,112.08 111.03,118.48 106.42,123.09 97.75,123.09 96.89,123.95 92.82,123.95 91.04,125.74 78.46,125.74 77.37,126.83 66.36,126.83 65.65,126.11 65.65,125.38 65.19,124.92 62.8,124.92 62.27,125.46 62.27,125.59 v1(62.02,125.83)
  BOTTOM w0.114: C9.1 62.24,125.25 62.24,125.61 v1(62.02,125.83) ; v1(125.97,92.43) 126.22,92.18 126.43,92.18 128.25,94 128.92,94 129.3,94.21 129.48,94.21 U22.AT40
PEG_TXN0_C: length 12.8
  BOTTOM w0.114: C9.2 62.28,124.2 62.45,124.03 62.45,123.64 62.85,123.24 62.85,123.13 62.73,123.02 62.13,123.02 61.87,122.77 61.87,122.35 62.13,122.09 62.92,122.09 63.05,121.97 63.05,121.72 62.92,121.6 62.61,121.6 62.35,121.34 62.35,120.91 64.51,118.75 64.51,116.28 64.76,116.03 64.76,115.74 64.62,115.6 64.52,115.6 64.45,115.67 U18.M1
PEG_TXN1: length 94.3
  IN1 w0.102: v1(123.84,92.31) 123.58,92.05 122.87,92.05 122.09,92.84 122.09,94.16 118.92,97.32 118.44,97.8 118.44,98.11 113.21,103.34 113.21,107.28 109.17,111.31 109.17,117.71 105.65,121.24 97.7,121.24 96.51,120.05 94.1,120.05 91.31,122.84 71.18,122.84 69.71,121.37 62.1,121.37 60.96,122.5 60.96,123.45 v1(61.16,123.65)
  BOTTOM w0.114: C11.1 61.01,123.15 61.01,123.5 v1(61.16,123.65) ; v1(123.84,92.32) 124.12,92.03 124.27,92.03 125.56,93.32 126.57,93.32 127.8,94.56 128.68,94.56 128.94,94.76 129.16,94.76 U22.AR40
PEG_TXN1_C: length 12.9
  BOTTOM w0.114: U18.L2 63.65,115.53 63.86,115.74 63.92,115.8 64.17,116.05 64.17,116.64 63.95,116.87 63.66,116.87 63.55,116.99 63.55,117.26 63.66,117.37 63.98,117.37 64.21,117.61 64.21,118.4 63.98,118.63 63.66,118.63 63.44,118.41 63.21,118.18 63.03,118.18 62.86,118.35 62.86,118.53 63.05,118.72 63.27,118.94 63.27,119.29 62.71,119.85 62.32,119.85 62.08,119.62 61.9,119.62 61.6,119.92 61.6,120.1 61.89,120.38 61.89,120.74 61.55,121.08 61.19,121.08 60.91,120.81 60.73,120.81 60.56,120.98 60.56,121.16 61.08,121.68 61.08,121.82 C11.2
PEG_TXN2: length 96.8
  IN1 w0.102: v1(125.7,94.66) 125.45,94.42 124.93,94.42 124.8,94.54 124.8,95.93 120.36,100.37 118.12,100.37 114.58,103.92 114.58,107.84 110.54,111.88 110.54,118.28 106.21,122.61 97.55,122.61 96.69,123.47 92.62,123.47 91.75,124.34 88.91,124.34 88.22,125.02 78.49,125.02 77.17,126.34 66.56,126.34 66.13,125.91 66.13,125.01 65.35,124.23 62.81,124.23 61.59,125.46 59.56,125.46 57.83,123.73 57.72,123.73 v1(57.5,123.95)
  BOTTOM w0.114: v1(57.5,123.95) 57.62,123.83 57.81,123.83 C13.1 ; v1(125.7,94.66) 125.87,94.5 126.89,94.5 127.49,95.1 128.5,95.1 128.61,95.22 129.17,95.22 129.28,95.32 129.48,95.32 U22.AP40
PEG_TXN2_C: length 12.9
  BOTTOM w0.114: U18.L3 63.72,114.63 63.72,114.51 63.61,114.4 63.45,114.4 63.33,114.53 63.33,114.82 63.43,114.93 63.43,115.26 63.34,115.36 63.34,115.64 63.42,115.73 63.42,116.08 63.07,116.43 63.07,116.86 62.22,117.71 62.22,118.24 59.31,121.16 59.31,121.9 59.81,122.41 59.81,123.35 59.35,123.82 59.06,123.82 58.9,123.97 C13.2
PEG_TXN3: length 104.3
  IN1 w0.102: v1(121.91,91.34) 121.68,91.11 121.45,91.11 121.3,91.27 121.3,93.97 117.72,97.56 117.72,97.87 112.52,103.06 112.52,106.99 108.49,111.03 108.49,117.43 105.36,120.55 97.98,120.55 96.79,119.36 93.82,119.36 91.05,122.13 89.06,122.13 88.68,121.74 83.47,121.74 83.15,121.43 70.74,121.43 70,120.68 61.78,120.68 60.64,121.83 55.48,121.83 54.32,122.99 53.74,122.99 v1(53.5,123.23)
  BOTTOM w0.114: C15.1 54,123.06 53.68,123.06 v1(53.5,123.23) ; v1(121.91,91.34) 122.12,91.13 122.3,91.13 122.48,91.31 122.48,92.83 123.3,93.65 123.58,93.65 125.52,95.59 127.62,95.59 128.29,96.26 129.11,96.26 129.28,96.42 129.48,96.42 U22.AM40
PEG_TXN3_C: length 13.1
  BOTTOM w0.114: C15.2 55.32,123.13 56.08,123.13 56.25,122.96 56.25,122.5 56.53,122.22 57.15,122.22 57.48,122.54 58.3,122.54 58.59,122.25 58.59,120.86 61.66,117.79 61.66,117.52 62.59,116.6 62.59,116.07 62.4,115.88 62.4,115.85 U18.J2
PEG_TXN4: length 105.4
  IN1 w0.102: v1(49.73,122.59) 49.95,122.81 50.89,122.81 51.97,123.89 54.77,123.89 56.16,122.51 57.87,122.51 59.77,124.41 61.37,124.41 63.93,121.85 69.51,121.85 72.51,124.85 74.22,124.85 75.75,123.32 91.51,123.32 92.25,122.58 96.21,122.58 97.07,121.72 105.85,121.72 109.65,117.91 109.65,111.51 113.69,107.48 113.69,103.54 117.75,99.48 119.11,99.48 122.44,96.16 123.1,96.16 123.44,95.82 123.44,95.31 v1(123.2,95.08)
  BOTTOM w0.114: v1(49.73,122.59) 49.88,122.75 50.18,122.75 C17.1 ; v1(123.2,95.08) 123.41,95.29 123.41,95.52 123.67,95.78 124.7,95.78 125.22,96.3 127.46,96.3 127.87,96.71 128.66,96.71 128.86,96.89 128.97,96.97 129.11,96.97 129.11,96.98 U22.AL40
PEG_TXN4_C: length 17.1
  BOTTOM w0.102: 59.77,118.6 59.78,118.6 60.91,117.47 60.91,116.96 61.35,116.53 61.35,116.23 61.58,116 61.58,115.76 61.54,115.72 61.54,115.29 61.83,115 62.24,115 62.39,114.85 62.39,114.46 62.22,114.28 62.11,114.28 62.05,114.35 U18.J3
  BOTTOM w0.114: 59.77,118.6 59.35,118.6 56.68,121.28 53.15,121.28 51.46,122.97 51.37,122.97 51.3,122.9 C17.2
PEG_TXN5: length 108.2
  IN1 w0.102: v1(120.54,91.42) 120.28,91.17 120.08,91.17 120,91.24 120,92.83 116.8,96.03 116.8,97.22 111.84,102.18 111.84,106.71 107.8,110.74 107.8,117.14 105.08,119.87 98.27,119.87 97.08,118.67 93.53,118.67 91.46,120.74 89.32,120.74 89.01,121.06 83.78,121.06 83.46,120.74 71.03,120.74 70.28,120 61.5,120 60.61,120.88 50.1,120.88 v1(49.87,121.11)
  BOTTOM w0.114: v1(120.54,91.42) 120.78,91.18 120.98,91.18 121.08,91.28 121.08,94.73 122.84,96.49 124.4,96.49 124.93,97.01 127.14,97.01 127.57,97.44 129.19,97.44 129.3,97.52 129.5,97.52 U22.AK40 ; C19.1 50.21,120.99 50,120.99 v1(49.87,121.11)
PEG_TXN5_C: length 13.7
  BOTTOM w0.102: 58.96,118.29 58.97,118.28 59.65,118.28 60.65,117.28 60.65,116.81 61.02,116.44 61.02,116.13 60.92,116.03 60.92,115.79 60.96,115.75 60.96,115.52 61.04,115.44 61.14,115.44 61.25,115.55 U18.H1
  BOTTOM w0.114: 58.96,118.29 56.58,120.67 52.31,120.67 51.99,121 51.55,121 C19.2
PEG_TXN6: length 109.4
  IN1 w0.102: v1(49.86,118.32) 50.08,118.54 51.38,118.54 52.6,119.76 60.47,119.76 61.13,119.11 63.27,119.11 63.62,118.76 66.84,118.76 67.05,118.55 70.09,118.55 71.4,119.85 83.83,119.85 84.15,120.17 88.64,120.17 88.95,119.85 91.09,119.85 93.16,117.78 97.44,117.78 98.64,118.98 104.71,118.98 106.91,116.78 106.91,110.37 110.95,106.34 110.95,101.81 115.91,96.85 115.91,95.65 116.58,94.98 119.09,92.47 119.09,91.22 118.95,91.09 118.73,91.09 v1(118.48,91.34)
  BOTTOM w0.114: U22.AJ40 129.14,98.07 126.97,98.07 126.63,97.72 124.63,97.72 124.12,97.21 122.56,97.21 119.08,93.73 119.08,91.26 118.94,91.11 118.71,91.11 v1(118.48,91.34) ; v1(49.86,118.32) 50.07,118.53 50.35,118.53 50.48,118.4 C21.1
PEG_TXN6_C: length 13.7
  BOTTOM w0.102: U18.G2 59.93,116.02 59.93,117.14 59.53,117.54 58.45,117.54 57.32,118.67 57.31,118.67 57.29,118.69
  BOTTOM w0.114: C21.2 51.78,118.62 52.13,118.62 52.84,119.33 53.25,119.33 53.37,119.22 53.37,118.61 53.61,118.37 54.05,118.37 54.29,118.61 54.29,119.22 54.77,119.7 56.29,119.7 57.29,118.69
PEG_TXN7: length 108.4
  IN1 w0.102: v1(49.85,116.32) 50.07,116.54 52.61,116.54 54.49,118.42 62.99,118.42 63.34,118.07 66.55,118.07 66.76,117.86 70.37,117.86 71.68,119.17 84.12,119.17 84.43,119.48 88.35,119.48 88.67,119.17 90.81,119.17 92.88,117.1 97.73,117.1 98.83,118.2 104.52,118.2 106.22,116.49 106.22,110.09 110.26,106.05 110.26,101.53 115.22,96.57 115.22,95.34 117.82,92.74 117.82,91.95 117.69,91.82 117.51,91.82 v1(117.28,92.06)
  BOTTOM w0.114: U22.AH40 129.5,98.61 129.3,98.61 129.17,98.52 128.95,98.52 128.65,98.81 126.74,98.81 126.37,98.44 124.34,98.44 123.85,97.95 122.19,97.95 118.69,94.45 118.43,94.19 117.82,93.58 117.82,91.9 117.7,91.78 117.55,91.78 v1(117.28,92.06) ; v1(49.85,116.32) 50.06,116.53 50.33,116.53 50.47,116.39 C23.1
PEG_TXN7_C: length 13.5
  BOTTOM w0.102: 58.76,116.81 58.97,116.6 58.98,116.6 59.15,116.42 59.15,116.17 59.12,116.14 59.12,115.71 59.43,115.4 59.82,115.4 60.23,114.99 60.62,114.99 60.77,114.84 60.77,114.51 60.62,114.36 60.52,114.36 60.45,114.42 U18.G3
  BOTTOM w0.114: C23.2 51.1,116.33 51.1,116.53 51.19,116.62 54.08,116.62 55.5,118.04 56.87,118.04 58.1,116.81 58.76,116.81
PEG_TXP0: length 95.7
  IN1 w0.102: v1(125.97,91.67) 125.97,91.93 126.03,91.99 126.59,91.99 126.95,92.35 126.95,95.71 119.9,102.76 116.71,102.76 115.27,104.2 115.27,108.13 111.23,112.17 111.23,118.57 106.5,123.3 97.84,123.3 96.98,124.16 92.9,124.16 91.12,125.94 78.55,125.94 77.45,127.03 66.28,127.03 65.44,126.2 65.44,125.46 65.11,125.13 62.89,125.13 62.47,125.54 62.47,125.76 62.54,125.83 v1(62.67,125.83)
  BOTTOM w0.114: v1(62.67,125.83) 62.46,125.62 62.46,125.26 62.74,124.98 C8.1 ; U22.AT41 129.18,93.9 128.97,93.78 128.34,93.78 126.52,91.97 126.27,91.97 v1(125.97,91.67)
PEG_TXP0_C: length 12.8
  BOTTOM w0.114: C8.2 62.66,123.93 62.66,123.73 63.06,123.33 63.06,123.04 62.82,122.8 62.22,122.8 62.09,122.68 62.09,122.44 62.22,122.31 63.01,122.31 63.26,122.05 63.26,121.63 63.01,121.38 62.7,121.38 62.57,121.25 62.57,121 64.73,118.84 64.73,116.37 64.97,116.12 64.97,115.65 64.72,115.4 64.45,115.13 U18.M2
PEG_TXP1: length 94.3
  IN1 w0.102: v1(60.52,123.65) 60.57,123.65 60.76,123.46 60.76,122.42 62.01,121.17 69.79,121.17 71.26,122.64 91.22,122.64 94.02,119.84 96.59,119.84 97.78,121.04 105.56,121.04 108.97,117.63 108.97,111.23 113.01,107.19 113.01,103.26 118.24,98.03 118.24,97.72 118.78,97.18 121.88,94.07 121.88,92.76 122.79,91.85 123.61,91.85 123.84,91.62 v1(123.84,91.55)
  BOTTOM w0.114: v1(123.84,91.55) 124.1,91.81 124.36,91.81 125.65,93.11 126.66,93.11 127.89,94.35 128.95,94.35 U22.AR41 ; v1(60.52,123.65) 60.8,123.37 60.8,122.92 60.72,122.84 C10.1
PEG_TXP1_C: length 12.9
  BOTTOM w0.114: C10.2 60.61,122.06 60.86,121.82 60.86,121.77 60.34,121.25 60.34,120.9 60.65,120.59 61,120.59 61.28,120.87 61.46,120.87 61.67,120.65 61.67,120.47 61.39,120.19 61.39,119.83 61.81,119.4 62.17,119.4 62.41,119.64 62.62,119.64 63.05,119.2 63.05,119.03 62.64,118.62 62.64,118.26 62.94,117.96 63.3,117.96 63.59,118.25 63.75,118.42 63.89,118.42 64,118.31 64,117.7 63.89,117.59 63.57,117.59 63.33,117.34 63.33,116.9 63.57,116.66 63.86,116.66 63.96,116.55 63.96,116.14 63.88,116.06 63.72,116.06 63.65,116.12 U18.L1
PEG_TXP2: length 96.8
  IN1 w0.102: v1(125.7,93.87) 125.7,94.13 125.62,94.21 124.85,94.21 124.6,94.46 124.6,95.85 120.28,100.17 118.04,100.17 114.38,103.83 114.38,107.76 110.34,111.8 110.34,118.2 106.13,122.41 97.47,122.41 96.61,123.27 92.53,123.27 91.67,124.13 88.82,124.13 88.14,124.82 78.4,124.82 77.08,126.14 66.65,126.14 66.33,125.83 66.33,124.92 65.44,124.03 62.73,124.03 61.5,125.25 59.65,125.25 57.92,123.53 57.62,123.53 57.5,123.4 v1(57.5,123.3)
  BOTTOM w0.114: U22.AP41 128.7,95 128.59,94.89 127.58,94.89 126.98,94.28 126.01,94.28 125.7,93.97 v1(125.7,93.87) ; C12.1 58.12,123.53 58.04,123.61 57.78,123.61 57.5,123.34 v1(57.5,123.3)
PEG_TXP2_C: length 12.9
  BOTTOM w0.114: U18.L4 63.11,114.44 63.11,114.91 63.22,115.02 63.22,115.17 63.12,115.27 63.12,115.73 63.2,115.82 63.2,115.99 62.85,116.34 62.85,116.77 62,117.62 62,118.15 59.09,121.07 59.09,121.99 59.59,122.5 59.59,123.26 59.26,123.6 58.97,123.6 58.9,123.53 C12.2
PEG_TXP3: length 104.3
  IN1 w0.102: v1(121.91,90.58) 121.91,90.81 121.8,90.91 121.37,90.91 121.1,91.18 121.1,93.89 117.51,97.47 117.51,97.78 112.32,102.98 112.32,106.91 108.28,110.94 108.28,117.34 105.28,120.35 98.07,120.35 96.87,119.16 93.73,119.16 90.96,121.93 89.15,121.93 88.76,121.54 83.55,121.54 83.24,121.23 70.83,121.23 70.08,120.48 61.7,120.48 60.55,121.62 55.4,121.62 54.24,122.79 53.55,122.79 53.5,122.74 v1(53.5,122.58)
  BOTTOM w0.114: C14.1 54.31,122.75 54.21,122.84 53.71,122.84 53.5,122.64 v1(53.5,122.58) ; U22.AM41 129.34,96.04 128.38,96.04 127.71,95.38 125.61,95.38 123.67,93.44 123.39,93.44 122.7,92.74 122.7,91.22 122.39,90.91 121.98,90.91 121.91,90.84 v1(121.91,90.58)
PEG_TXP3_C: length 13.1
  BOTTOM w0.114: U18.J1 62.05,116.02 62.09,115.98 62.19,115.98 62.31,116.1 62.37,116.16 62.37,116.51 61.45,117.43 61.45,117.7 58.38,120.77 58.38,122.16 58.21,122.33 57.57,122.33 57.24,122 56.44,122 56.03,122.41 56.03,122.87 55.99,122.92 55.13,122.92 54.95,122.74 54.95,122.49 C14.2
PEG_TXP4: length 105.4
  IN1 w0.102: v1(124,95.08) 123.71,95.08 123.64,95.15 123.64,95.9 123.18,96.36 122.52,96.36 119.2,99.69 117.84,99.69 113.89,103.63 113.89,107.56 109.86,111.6 109.86,118 105.93,121.93 97.16,121.93 96.3,122.78 92.33,122.78 91.59,123.52 75.83,123.52 74.3,125.06 72.42,125.06 69.42,122.05 64.02,122.05 61.46,124.61 59.69,124.61 57.79,122.71 56.24,122.71 54.86,124.1 51.89,124.1 50.81,123.02 49.87,123.02 49.73,123.17 v1(49.73,123.24)
  BOTTOM w0.114: v1(124,95.08) 123.74,95.08 123.63,95.19 123.63,95.43 123.76,95.56 124.79,95.56 125.31,96.09 127.55,96.09 127.96,96.49 128.89,96.49 U22.AL41 ; v1(49.73,123.24) 49.73,123.22 49.98,122.97 50.46,122.97 50.52,123.03 C16.1
PEG_TXP4_C: length 17.1
  BOTTOM w0.102: 59.85,118.82 61.12,117.55 61.12,117.04 61.55,116.61 61.55,116.32 61.79,116.08 61.79,115.68 61.75,115.64 61.75,115.37 61.92,115.21 62.33,115.21 62.6,114.94 62.6,114.37 62.12,113.9 U18.J4
  BOTTOM w0.114: C16.2 53.24,121.49 56.76,121.49 59.44,118.82 59.85,118.82
PEG_TXP5: length 108.2
  IN1 w0.102: v1(120.54,90.66) 120.54,90.89 120.46,90.96 119.99,90.96 119.8,91.16 119.8,92.74 116.59,95.95 116.59,97.14 111.63,102.1 111.63,106.62 107.6,110.66 107.6,117.06 104.99,119.66 98.35,119.66 97.16,118.47 93.45,118.47 91.38,120.54 89.24,120.54 88.92,120.86 83.86,120.86 83.55,120.54 71.11,120.54 70.37,119.79 61.41,119.79 60.53,120.68 49.99,120.68 49.87,120.57 v1(49.87,120.46)
  BOTTOM w0.114: C18.1 50.5,120.66 50.39,120.77 50.15,120.77 49.87,120.49 v1(49.87,120.46) ; v1(120.54,90.66) 120.54,90.86 120.64,90.96 121.07,90.96 121.3,91.19 121.3,94.64 122.93,96.27 124.49,96.27 125.02,96.8 127.23,96.8 127.66,97.22 129.38,97.22 U22.AK41
PEG_TXP5_C: length 13.7
  BOTTOM w0.102: 58.85,118.1 58.85,118.09 58.86,118.08 59.57,118.08 60.45,117.2 60.45,116.73 60.82,116.36 60.82,116.22 60.72,116.12 60.72,115.7 60.75,115.67 60.75,115.44 60.96,115.23 61.12,115.23 U18.H2
  BOTTOM w0.114: 58.85,118.1 56.49,120.46 52.22,120.46 51.9,120.78 51.4,120.78 51.28,120.66 C18.2
PEG_TXP6: length 109.4
  IN1 w0.102: v1(49.86,118.96) 50.08,118.74 51.3,118.74 52.52,119.97 60.56,119.97 61.21,119.31 63.36,119.31 63.71,118.96 66.92,118.96 67.13,118.75 70,118.75 71.31,120.06 83.75,120.06 84.06,120.37 88.72,120.37 89.04,120.06 91.18,120.06 93.25,117.99 97.36,117.99 98.55,119.18 104.79,119.18 107.11,116.86 107.11,110.46 111.15,106.42 111.15,101.9 116.11,96.94 116.11,95.73 116.72,95.12 119.29,92.55 119.29,91.14 119.04,90.89 118.78,90.89 v1(118.48,90.58)
  BOTTOM w0.114: U22.AJ41 128.95,97.85 127.06,97.85 126.72,97.51 124.72,97.51 124.21,96.99 122.65,96.99 119.29,93.64 119.29,91.17 119.02,90.9 118.8,90.9 v1(118.48,90.58) ; C20.1 50.48,118.82 50.4,118.74 50.08,118.74 v1(49.86,118.96)
PEG_TXP6_C: length 13.7
  BOTTOM w0.102: U18.G1 60.45,116.08 60.41,116.04 60.21,116.04 60.14,116.12 60.14,117.22 59.61,117.74 58.54,117.74 57.46,118.82 57.46,118.83 57.37,118.92
  BOTTOM w0.114: 57.37,118.92 57.29,119 56.38,119.91 54.68,119.91 54.08,119.31 54.08,118.7 53.96,118.59 53.7,118.59 53.58,118.7 53.58,119.31 53.34,119.55 52.75,119.55 52.04,118.84 51.55,118.84 C20.2
PEG_TXP7: length 108.4
  IN1 w0.102: v1(117.28,91.3) 117.6,91.62 117.77,91.62 118.02,91.87 118.02,92.83 115.42,95.42 115.42,96.65 110.47,101.61 110.47,106.14 106.43,110.17 106.43,116.58 104.6,118.4 98.74,118.4 97.64,117.3 92.96,117.3 90.89,119.37 88.75,119.37 88.44,119.69 84.35,119.69 84.03,119.37 71.6,119.37 70.29,118.06 66.85,118.06 66.63,118.28 63.42,118.28 63.07,118.63 54.4,118.63 52.53,116.75 50.07,116.75 v1(49.85,116.97)
  BOTTOM w0.114: v1(117.28,91.3) 117.55,91.57 117.79,91.57 118.03,91.81 118.03,93.49 122.28,97.73 123.94,97.73 124.43,98.22 126.45,98.22 126.83,98.6 128.56,98.6 128.86,98.3 U22.AH41 ; v1(49.85,116.97) 49.85,116.85 49.95,116.75 50.32,116.75 50.47,116.9 C22.1
PEG_TXP7_C: length 13.5
  BOTTOM w0.102: 58.97,116.89 58.97,116.89 59.05,116.81 59.06,116.81 59.36,116.51 59.36,116.09 59.32,116.06 59.32,115.79 59.51,115.61 59.9,115.61 60.31,115.2 60.7,115.2 60.97,114.93 60.97,114.42 U18.G4
  BOTTOM w0.114: C22.2 51.55,116.83 53.99,116.83 55.41,118.26 56.96,118.26 58.19,117.03 58.85,117.03 58.91,116.97 58.97,116.9 58.97,116.89
PEGX_RST#: length 13.5
  IN1 w0.089: v1(123.81,89.08) 123.81,88.07 121.6,85.85 v1(121.6,84.17)
  BOTTOM w0.114: R1015.2 122.56,83.66 v1(122.04,83.66) 121.85,83.66 121.6,83.92 v1(121.6,84.17) ; U24.4 122.6,88.77 R1067.1 123.2,88.89 123.39,88.69 R658.1 R648.2 124.52,88.38 v1(123.81,89.08)
PEGX_RST#_R: length 6.6
  BOTTOM w0.114: R648.1 127.6,90.55 127.6,91.6 128.8,92.8 U22.AV41
PHASE_1: length 25.8
  IN2 w0.889: v3(108.4,141.39) 107.42,141.39 102.76,136.72 97.12,136.72 95.74,138.11 93.68,138.11 92.3,136.72 v3(87.65,136.72)
  BOTTOM w0.203: 109.81,142.52 109.94,142.66 PU16.23
  BOTTOM w0.381: 108.92,141.9 109.54,142.52 109.81,142.52
  vias: v1(108.4,142.09)
PHASE_2: length 40.9
  TOP w0.508: PC9115.1 78.8,136.86 v3(78.63,137.03)
  IN2 w0.889: v3(108.33,145.58) 107.33,146.59 102.96,146.59 101.98,147.56 82.38,147.56 80.63,145.82 80.63,144.15 78.55,142.07 78.55,137.11 v3(78.63,137.03)
  BOTTOM w0.203: PU16.28 109.92,144.66
  vias: v1(109.03,145.19)
PHASE_CI: length 26.8
  TOP w0.508: PC9243.1 154.12,66.4 v3(153.99,66.53)
  IN2 w0.762: v3(148.54,54.5) 150.99,54.5 154.29,57.8 155.64,57.8 156.63,58.79 156.63,62.74 153.99,65.38 v3(153.99,66.53)
  BOTTOM w0.203: PU24.33 143.82,50.76 144.06,51.01 144.63,51.01 145.38,51.76
  BOTTOM w0.762: 145.38,51.76 v1(147.07,53.45) 147.41,53.79 PC9241.2 v3(148.54,54.5)
PHASE_GFX1: length 30.4
  TOP w0.508: v3(57.85,136.63) 57.59,136.89 PC9165.1
  IN2 w0.889: v3(57.85,136.63) 56.82,137.66 52.99,137.66 42,126.67 39.51,126.67 39.13,127.06 v3(37.22,127.06)
  BOTTOM w0.203: 38.02,125.87 38.02,125.33 38.4,124.96 PU17.23
  BOTTOM w0.508: v3(37.22,127.06) 37.86,127.06 38.21,126.71 PC9161.2 38.21,126.06 38.02,125.87
PHASE_GFX2: length 40
  TOP w0.508: v3(70.27,137.11) 70.28,137.13 PC9150.1
  IN2 w0.889: v3(43.45,125.65) 43.45,126.66 53.41,136.63 56.2,136.63 57.34,135.49 60.66,135.49 62.05,134.09 66.18,134.09 69.2,137.11 v3(70.27,137.11)
  BOTTOM w0.203: v1(41.63,125.85) 41.48,125.7 41.16,125.7 40.4,124.93 PU17.28
  BOTTOM w0.508: v1(41.63,125.85) 42.46,126.68 PC9149.2 43.45,126.08 v3(43.45,125.65)
PHASE_GPU1: length 27
  TOP w0.508: PC9276.1 129.34,66.39 v3(128.46,65.51)
  IN2 w0.889: v3(128.46,65.51) 125.74,65.51 125.16,64.93 125.16,58.37 127.51,56.03 135.4,56.03 v3(137.67,53.76)
  BOTTOM w0.203: 139.41,53.19 139.78,52.82 PU24.23
  vias: v1(126.25,65.82)
PHASE_GPU2: length 17.5
  TOP w0.508: PC9260.1 142.06,65.77 v3(142.05,65.77)
  IN2 w0.889: v3(142.05,65.77) 142.05,65.35 140.58,63.88 140.58,60.28 143.09,57.76 143.09,55.95 142.3,55.16 v3(142.3,55.15)
  BOTTOM w0.203: PU24.28 141.78,52.81 142.47,53.5
  BOTTOM w0.508: 142.47,53.5 143.15,54.18 PC9259.2
  BOTTOM w0.762: v3(142.3,55.15) 142.95,54.5 PC9259.2
  vias: v1(147.89,65.89)
PHASE_NB: length 29.5
  TOP w0.762: v3(98.97,137.98) 97.14,137.98 95.09,140.04 95.09,142.15 95.87,142.93 95.87,145.14 v1(96.53,145.8) 101.56,150.83 109.98,150.83 v3(111.31,149.5)
  BOTTOM w0.203: PU16.33 112.1,146.71 111.97,146.85 111.97,147.14
PLLCHARZ_H: length 1.5
  TOP w0.114: TP179.1 144.65,94.49 v2(144.25,94.1)
  BOTTOM w0.114: U22.AU15 143.91,93.75 v2(144.25,94.1)
PLLCHARZ_L: length 12
  TOP w0.114: TP178.1 146.67,85.1 146.67,87.8 144.25,90.23 v2(144.25,93.5)
  BOTTOM w0.102: U22.AV15 143.69,92.95 v2(144.25,93.5)
POWER_ SW_IN0#: length 39.8
  TOP w0.114: J2.4 v1(246.8,26.09) 246.83,26.06 EC163.2
  IN1 w0.089: v1(223.1,16.64) 223.18,16.56 223.18,14.89 223.79,14.28 229.83,14.28 230.95,15.4 235.62,15.4 236.57,16.34 236.57,18.78 238.34,20.55 240.47,20.55 246.01,26.09 v1(246.8,26.09)
  BOTTOM w0.114: v1(223.1,16.64) 223.2,16.74 223.2,17.41 R435.2 C714.1 226.18,19.33 226.18,19.83 226.33,19.97 D15.3
POWER_LED: length 36.3
  TOP w0.114: Q12.2 246.57,23.88 246.9,23.55 246.9,22.82 247.42,22.31 R1002.1 247.42,20.42 v1(247.31,20.32) ; U34.24 222.12,15.01 v1(222.56,14.57)
  IN1 w0.089: v1(222.56,14.57) 223.17,14.57 223.69,14.05 229.93,14.05 231.05,15.17 235.72,15.17 236.8,16.25 236.8,18.69 238.43,20.32 240.57,20.32 241.45,21.2 246.43,21.2 v1(247.31,20.32)
POWERLED: length 4.6
  TOP w0.114: R1110.2 248.09,24.76 247.94,24.62 Q12.3 249.11,23.22 EC162.2 249.17,23.96 v1(248.87,24.26)
PS_ID: length 185.7
  TOP w0.114: v1(224.48,22.84) 224.48,24.74 224.37,24.85 U34.123
  IN4 w0.089: v1(61.46,17.5) 64.14,20.17 108.11,20.17 109.31,18.97 113.26,18.97 113.41,19.12 123.81,19.12 124.36,18.58 140.21,18.58 140.81,19.17 154.76,19.17 155.27,19.69 173.81,19.69 179.94,13.55 191.09,13.55 196.43,18.89 196.43,20.18 198.08,21.83 203.14,21.83 205.3,19.66 210.12,19.66 211.92,21.46 217.27,21.46 219.16,19.57 219.78,19.57 223.05,22.84 v1(224.48,22.84)
  BOTTOM w0.114: v1(61.46,17.5) v1(61.46,16.55) PD1.3 58.92,14.64 58.6,14.32 PR202.2 PR203.2
PTP_DISABLE#: length 112.7
  TOP w0.114: v1(199.84,37.25) 199.84,36.43 200.47,35.79 239.3,35.79 242.99,32.1 242.99,28.89 244.88,27 244.88,19.67 242.39,17.18 238.15,17.18 237.98,17.01 U34.78 ; v1(166.02,41.24) 166.02,41.24 166.12,41.14 166.12,36.19 R170.1 166.71,35.6 166.71,34.35 166.5,34.13 CN4.3
  BOTTOM w0.114: v1(166.02,41.24) 168.12,41.24 168.75,41.87 177.2,41.87 178.11,40.96 196.13,40.96 v1(199.84,37.25)
PX_EN: length 8.7
  BOTTOM w0.114: U22.AC41 127.26,101.05 126.68,101.63 125.29,101.63 124.8,102.11 123.2,102.11 TP279.1 122.06,101.76 121.72,102.1 R651.1
RASA0B: length 29.5
  TOP w0.14: v1(135.96,134.6) 135.96,133.94 136.4,133.5 138.39,133.5 139.11,132.78 139.11,128.05 140.52,126.64 140.52,125.1 140.39,124.97 139.77,124.97 139.64,124.84 139.64,119.47 140.52,118.6 140.52,114.59 140.78,114.33 140.78,113.65 140.33,113.2 140.33,111.43 v1(139.89,110.99)
  BOTTOM w0.14: v1(135.96,134.6) 135.97,134.6 VRAM1.G3 ; U22.D21 139.99,110.99 v1(139.89,110.99)
RASA1B: length 32.3
  TOP w0.14: v1(142,111.25) 141.44,111.25 141.04,111.64 141.04,114.58 140.97,114.64 140.97,119.55 141.82,120.4 v1(141.82,126.14) 142,126.33 142,134.4 142.13,134.52 142.33,134.52 142.45,134.4 142.45,133.84 142.58,133.71 142.96,133.71 143.09,133.84 143.09,134.4 143.21,134.52 143.6,134.52 143.72,134.4 143.72,133.84 143.85,133.71 144.84,133.71 145.01,133.88 145.61,133.88 v1(146.36,134.63)
  BOTTOM w0.14: VRAM2.L3 v1(146.36,134.63) ; U22.D19 141.55,111.25 v1(142,111.25)
RASB0B: length 31.4
  TOP w0.14: v1(172.31,108.13) 171.76,107.58 171.76,106.98 171.38,106.6 171.38,106.26 171.89,105.76 171.89,103.39 170.39,101.89 155.91,101.89 155.48,101.46 154.72,101.46 154.59,101.33 151.97,101.33 151.72,101.59 151.41,101.59 150.02,102.99 149.58,102.99 149.2,103.37 v2(149.2,103.8)
  BOTTOM w0.14: v2(149.2,103.8) 149.55,103.45 U22.W4 ; VRAM3.G3 v1(172.31,108.13)
RASB1B: length 31.6
  TOP w0.14: v1(172.31,96.1) 171.56,96.85 171.56,98.19 171.37,98.38 171.37,99.36 171.5,99.48 172.26,99.48 172.39,99.61 v1(172.39,100.24) 172.39,101.01 171.94,101.45 156.32,101.45 155.9,101.03 151.79,101.03 151.62,101.21 151.16,101.21 150.12,102.24 149.77,102.24 v2(149.2,101.67)
  BOTTOM w0.14: U22.AA4 149.55,102.02 v2(149.2,101.67) ; v1(172.31,96.1) 172.66,95.75 VRAM4.L3
RCIN#: length 4.8
  TOP w0.114: U34.4 219.91,23.01 219.82,23.09 218.44,23.09 218.24,22.89 v1(217.12,22.89) D30.1
REG_OUT:
  vias: v1(273.7,82.58)
REM_DIODE1_N: length 40.6
  TOP w0.381: C225.2 70.01,102.58 70.73,103.29 Q4.1 70.73,103.96 v1(71.4,104.63)
  IN1 w0.381: v1(71.4,104.63) 70.84,104.07 69.84,104.07 69.17,104.74 64.52,104.74 63.82,105.44 63.82,106.72 61.64,108.9 60.89,108.9 60.16,109.63 59.74,109.63 59.21,109.1 57.11,109.1 55.63,110.58 53.7,110.58 49.74,114.55 45.47,114.55 v1(43.98,116.05)
  BOTTOM w0.381: U9.3 43.82,113.26 43.89,113.32 C574.2 43.89,115.96 v1(43.98,116.05)
REM_DIODE1_P: length 41.5
  TOP w0.381: v1(70.85,105.59) 70.7,105.75 Q4.3 70.07,104.95 69.41,104.29 Q4.2 69.41,103.14 69.05,102.79 C225.1
  IN1 w0.381: v1(43.2,116.09) 43.73,116.63 44.22,116.63 45.78,115.07 49.95,115.07 53.92,111.1 55.84,111.1 57.33,109.62 58.99,109.62 59.53,110.15 60.37,110.15 61.11,109.42 61.85,109.42 63.52,107.75 64.81,107.75 66.1,106.46 68.03,106.46 69.05,105.44 70.7,105.44 v1(70.85,105.59)
  BOTTOM w0.381: v1(43.2,116.09) 43.11,116 C574.1 43.11,113.23 43.17,113.16 U9.2
ROMCSB: length 2.6
  BOTTOM w0.114: R1083.2 139.32,86.15 139.32,85.55 139.52,85.35 U208.1
ROMSCK: length 6.1
  BOTTOM w0.114: U208.6 134.33,82.81 134.98,83.46 134.98,85.86 R1084.2
ROMSI: length 7.5
  BOTTOM w0.114: U208.5 134.46,81.54 135.86,82.94 R1085.2
ROMSO: length 4.3
  BOTTOM w0.114: U208.2 139.09,84.08 138.15,85.02 R1086.2
RREF: length 3
  BOTTOM w0.305: U28.1 250.81,14.73 250.53,14.46
  BOTTOM w0.381: R821.1 249.52,13.44 v1(249.75,13.67) 250.53,14.46
RSMRST#: length 241.3
  TOP w0.114: v1(202.95,8.43) 202.5,7.98 201.46,7.98 200.72,8.72 195.47,8.72 189.45,14.74 185.2,14.74 180.39,19.55 159.61,19.55 158.29,20.88 136.69,20.88 135.05,22.51 135.05,23.31 134.72,23.64 131.46,23.64 130.36,22.53 127.81,22.53 125.57,20.3 115.77,20.3 112.48,23.59 112.48,24.65 v1(112.28,24.85) ; v1(108.4,25.94) 108.47,26.01 108.47,28.93 108.98,29.44 108.98,33.48 113.1,37.6 113.1,38.93 113.42,39.25 113.42,58.2 112.67,58.95 112.67,67.5 110.67,69.5 110.67,70.2 104.65,76.22 104.65,92.93 107.49,95.78 107.49,106.73 107.98,107.21 107.98,109.57 105.63,111.91 v1(105.53,111.91) 104.73,111.91 104.54,111.71 D19.1 ; v1(235.26,15.84) 235.48,16.06 235.48,17.64 235.65,17.81 U34.80
  IN1 w0.089: v1(108.4,25.94) 111.19,25.94 v1(112.28,24.85)
  BOTTOM w0.114: v1(202.95,8.43) 210.95,8.43 214.24,11.72 224.99,11.72 225.79,10.92 231.28,10.92 234.03,13.67 234.03,14.04 235.26,15.28 v1(235.26,15.84)
RSMRST#_R: length 33.7
  TOP w0.114: v1(91.37,110.39) 91.47,110.49 99.56,110.49 R523.2 C760.2 100.07,112.21 100.12,112.21 100.62,111.71 D19.2
  IN1 w0.089: v2(75.5,113.44) 76.11,112.83 76.11,109.78 76.11,109.78 76.11,109.41 76.11,109.41 76.11,109.38 76.41,109.08 76.9,109.08 77.74,108.23 82.8,108.23 83.12,107.9 85.21,107.9 85.67,108.37 88.89,108.37 90.9,110.39 v1(91.37,110.39)
  BOTTOM w0.102: v2(75.5,113.44) 75.05,113.9 U18.AE4
RTC_CLK: length 9.2
  TOP w0.114: R596.2 72.82,116.32 73.51,115.63 74.38,115.63 75.89,114.12 75.89,113.18 R606.2 76.11,112.88 75.68,112.44 75.68,111.91 76.1,111.49 76.1,111.1 76.4,110.8 v2(76.67,110.8)
  BOTTOM w0.127: v2(76.67,110.8) 76.46,110.8 76.05,111.22 U18.AG7
RTL8111G_REST: length 4.1
  TOP w0.114: R58.1 276.38,90.09 274.5,90.09 273.8,89.4 U2.31
RUN_ON: length 388.7
  TOP w0.114: v1(37.83,23.11) v1(37.83,16.21) 37.83,15.06 32.15,9.38 28,9.38 27.7,9.07 26.79,9.07 26.02,8.3 CN5.33 ; v1(115.91,24.01) 115.91,23.73 116.1,23.54 118.88,23.54 119.96,24.62 124.97,24.62 125.61,23.98 127.39,23.98 v1(127.84,24.43) 128.28,23.98 129.76,23.98 130.86,25.09 136.61,25.09 v1(138.41,23.29) 138.7,23 159.4,23 159.67,22.73 166.29,22.73 166.88,22.13 170.37,22.13 v1(171.06,22.83) 171.5,22.39 179.79,22.39 185.38,16.79 189.73,16.79 195.43,11.09 v1(198.28,11.09) ; Q6.2 174.52,48.41 175.85,49.74 178.1,49.74 181.79,53.43 185.87,53.43 189.27,50.02 189.27,39.51 188.63,38.87 188.63,36.81 190.51,34.94 190.51,29.16 190.24,28.88 190.24,20.51 199.39,11.36 v1(200.6,11.36) ; U34.119 225.97,26.74 223.7,29 223.7,29.88 v1(222.54,31.04)
  IN1 w0.089: v1(37.83,23.11) 37.76,23.04 36.97,23.04 31.7,28.31 31.7,30.74 28.84,33.6 28.84,39.32 25.96,42.2 25.96,49.92 26.38,50.33 26.38,65.9 28.39,67.91 28.39,73.26 v1(29.15,74.02)
  IN4 w0.089: v1(37.83,23.11) 38.25,23.52 46.29,23.52 46.77,24 49.46,24 50.35,24.9 51.75,24.9 52.72,25.87 57.23,25.87 57.68,26.32 80.45,26.32 81.53,26.32 81.54,26.32 81.9,26.32 81.9,26.32 99.53,26.32 103.87,30.66 109.19,30.66 110.43,29.43 110.43,27.02 111.82,25.63 112.86,25.63 114.03,24.46 115.46,24.46 v1(115.91,24.01)
  BOTTOM w0.114: PR502.2 171.06,23.71 v1(171.06,22.83) ; PR504.2 28.59,76.65 28.59,74.58 v1(29.15,74.02) ; PR506.2 136.09,30.9 137.01,31.82 138.4,31.82 138.66,31.56 138.66,29.85 R1055.1 138.44,28.76 138.44,24.97 138.41,24.94 v1(138.41,23.29) ; PR501.2 127.68,23.86 127.68,24.21 127.84,24.36 v1(127.84,24.43) ; v1(198.28,11.09) 200.32,11.09 200.6,11.36 v1(200.6,11.36) 200.87,11.36 203.65,14.14 203.65,20.08 212.64,29.07 216.21,29.07 218.63,31.49 222.1,31.49 v1(222.54,31.04) 223.6,29.98 R1048.2
S3_RESUME: length 9.1
  TOP w0.114: R551.2 71.49,115.64 72.82,115.64 73.51,114.95 R530.1 74.26,114.95 74.78,114.44 74.78,111.58 75.19,111.16 v2(75.55,111.16)
  BOTTOM w0.127: U18.AG8 76.02,110.7 v2(75.55,111.16)
SATA_CALRN: length 7.3
  BOTTOM w0.241: R581.1 89.09,121.89 89.09,119.15 86.24,116.3 U18.AW1
SATA_CALRP: length 6.7
  BOTTOM w0.241: U18.AW2 86.05,115.63 90.23,119.81 R576.1
SATA_DEVSLP0: length 197.5
  TOP w0.114: R580.1 90.48,106.97 90.48,107.75 90.22,108.01 88.09,108.01 v2(87.59,107.5)
  IN1 w0.089: v2(83.31,103.97) 83.84,104.5 87.06,104.5 87.92,105.36 87.92,107.17 v2(87.59,107.5)
  IN4 w0.089: v2(83.31,103.97) 83.96,103.33 97.25,103.33 97.52,103.06 ; 100.78,100.96 103.98,100.96 105.32,99.62 105.32,86.02 108.46,82.88 108.46,67.76 109.62,66.6 109.62,49.48 108.82,48.68 108.82,41.48 118.57,31.73 120.27,31.73 124.69,27.3 124.69,26.33 126.08,24.94 128.67,24.94 129.88,23.73 146.86,23.73 148.11,24.99 152.21,24.99 152.98,25.77 156.01,25.77 156.23,25.55 172.56,25.55 173.84,24.27 182.72,24.27 184.95,26.5 192.06,26.5 v1(192.92,27.37)
  IN4 w0.102: 97.52,103.06 99.62,100.96 100.78,100.96
  BOTTOM w0.114: v1(192.92,27.37) v1(192.92,22.62) 193.13,22.41 R886.1 ; U18.AT17 83.75,103.53 v2(83.31,103.97)
SATA_DEVSLP0_R: length 3.5
  BOTTOM w0.114: R886.2 193.13,20.33 192.85,20.05 v1(192.72,20.05) 192.34,20.05 192.09,20.3 192.09,20.55 191.72,20.92 CON1.38
SATA_DEVSLP1: length 5.2
  TOP w0.114: v2(84.26,106.29) 84.71,105.84 86.65,105.84 87.38,106.58 87.9,106.58 R582.1
  BOTTOM w0.102: U18.AT12 83.75,106.8 v2(84.26,106.29)
