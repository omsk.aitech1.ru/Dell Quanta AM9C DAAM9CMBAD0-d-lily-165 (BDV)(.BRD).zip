# Allegro board Pandora 3 AMD MB_A00_Board View_daam9cmbad0-d-lily-165.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
APU_SPI_HOLD#: length 60.8
  TOP w0.114: v1(122.64,146.57) 122.68,146.54 R614.2
  IN4 w0.089: v1(122.64,146.57) 122.65,146.57 123.47,145.75 123.47,144.27 123.2,144 123.2,140.99 122.01,139.8 122.01,134.87 119.56,132.43 117.77,132.43 114.97,129.63 114.97,124.8 113.14,122.96 v1(113.14,122.56)
  BOTTOM w0.114: U18.BA7 88.24,111.89 89.29,111.89 90.32,112.92 91.11,112.92 95.38,117.19 95.86,117.19 98.32,119.65 110.54,119.65 113.14,122.24 v1(113.14,122.56)
APU_SPI_SI: length 74.8
  TOP w0.114: R612.1 v1(139.38,147.05)
  IN4 w0.089: v1(113.7,121.53) 115.76,123.58 115.76,129.29 118.11,131.64 119.89,131.64 122.8,134.55 122.8,138.79 127.43,143.42 134.32,143.42 137.95,147.05 v1(139.38,147.05)
  BOTTOM w0.102: U18.BA9 88.26,110.31 88.52,110.31 88.8,110.03 89.1,110.03 89.18,110.12 89.47,110.12 89.47,110.11 90.24,110.11 90.6,110.47 90.6,110.58 91.12,111.1
  BOTTOM w0.114: 91.12,111.1 93.62,111.1 95.87,113.36 107.24,113.36 113.48,119.6 113.48,121.3 v1(113.7,121.53)
APU_SPI_SO: length 64.2
  TOP w0.114: R611.1 121.37,148.47 121.37,146.89 121.36,146.87 v1(121.36,146.32)
  IN4 w0.089: v1(112.43,123.63) 114.03,125.24 114.03,130.02 117.38,133.37 119.17,133.37 121.07,135.26 121.07,140.19 121.98,141.1 121.98,143.69 121.43,144.25 121.43,145.47 121.36,145.53 v1(121.36,146.32)
  BOTTOM w0.114: U18.AY7 87.1,111.4 87.84,112.14 87.84,112.33 88.12,112.61 89.4,112.61 94.97,118.18 95.45,118.18 97.91,120.64 110.13,120.64 111.93,122.44 111.93,123.14 v1(112.43,123.63)
APU_SPI_WP: length 76.2
  TOP w0.114: R613.2 138.76,147.92 138.4,147.57 137.47,147.57 v1(137.44,147.54)
  IN4 w0.089: v1(113.04,121.28) 113.04,121.77 115.37,124.1 115.37,129.45 117.95,132.03 119.72,132.03 122.4,134.71 122.4,138.95 127.26,143.81 133.71,143.81 v1(137.44,147.54)
  BOTTOM w0.102: 90.4,111.74 89.56,110.89 89.14,110.89 89.1,110.93 88.06,110.93 87.85,110.73 87.85,110.62 87.44,110.22 87.44,109.86 87.05,109.47 86.99,109.47 86.5,108.98 86.5,108.55 U18.AW11
  BOTTOM w0.114: v1(113.04,121.28) 113.04,120.4 106.83,114.2 96.02,114.2 93.56,111.74 90.4,111.74
APU_SVC: length 107.8
  TOP w0.254: v1(113.3,128.9) 113.3,125.52 110.88,123.09 109.1,123.09 v1(108.71,122.71) 106.18,122.71 105.8,123.09 91.52,123.09 90.85,123.76 88.78,123.76 88.42,124.12 83.49,124.12 83.17,124.44 75.21,124.44 72.74,121.97 70.31,121.97 68.5,120.16 56.25,120.16 53.93,117.85 53.93,109.38 51.98,107.43 51.44,107.43 v1(49.88,105.87)
  BOTTOM w0.254: PR265.1 120.27,146.36 122.68,143.95 122.68,134 120.46,131.78 117.36,131.78 116.52,130.94 115.35,130.94 v1(113.3,128.9) ; v1(49.88,105.87) 50,105.75 R484.2
APU_SVD: length 121.6
  TOP w0.254: R486.2 46.33,96.09 48.13,97.89 48.13,103.69 47.69,104.13 47.04,104.13 46.79,104.39 46.79,107.53 47.74,108.49 50.13,108.49 50.55,108.06 51.72,108.06 53.3,109.64 53.3,118.27 55.83,120.8 68.08,120.8 72.35,125.07 82.82,125.07 82.82,125.07 83.43,125.07 83.75,124.76 88.68,124.76 89.04,124.4 91.11,124.4 91.48,124.03 91.78,123.73 106.06,123.73 106.45,123.34 v1(106.97,123.34) 108.45,123.34 108.83,123.72 110.61,123.72 112.67,125.78 112.67,129.19 v1(113.27,129.79)
  BOTTOM w0.254: PR267.1 120.36,145.37 122.05,143.68 122.05,134.27 120.2,132.42 117.09,132.42 116.37,131.69 115.18,131.69 v1(113.27,129.79)
APU_SVT: length 110.7
  TOP w0.254: v1(113.19,130.63) 112.03,129.47 112.03,126.04 110.36,124.36 ; v1(110.35,124.36) 110.36,124.36 ; 110.36,124.36 92.04,124.36 91.37,125.03 90.61,125.03 90.23,125.41 84.15,125.41 83.85,125.71 83.61,125.71 77.13,125.71 76.75,126.09 66.61,126.09 66.41,125.88 66.41,121.98 65.86,121.43 55.57,121.43 52.66,118.53 52.66,109.91 v1(51.95,109.19)
  BOTTOM w0.114: 55.5,105.79 55.94,105.35 56.8,105.35 U18.C15
  BOTTOM w0.254: PR269.1 120.45,144.38 121.41,143.42 121.41,134.53 119.93,133.05 116.83,133.05 116.11,132.33 114.89,132.33 v1(113.19,130.63) ; 55.5,105.79 54.55,105.79 52.51,107.83 52.51,108.25 52.06,108.7 51.55,108.7 R480.1 51.45,109.19 v1(51.95,109.19)
APU_TCK: length 114.3
  TOP w0.114: v1(40.14,29.73) 40.64,30.23 47.92,30.23 49.08,29.07 R509.1 48.53,28.68 48.02,29.19 CN13.2
  IN1 w0.089: v1(40.14,29.73) 40.14,30.16 37.09,33.21 34.96,33.21 32.89,35.28 32.89,41 31.67,42.22 31.67,62.74 35.77,66.84 35.77,75.72 34.66,76.83 34.66,80.59 33.36,81.88 33.36,86.84 35.9,89.38 36.97,89.38 38.41,90.82 38.41,91.68 40.3,93.57 40.3,94.78 43.84,98.32 45.36,98.32 48.41,101.37 48.41,104.18 49.48,105.26 50.16,105.26 51.45,106.55 58.05,106.55 v1(58.34,106.27)
  BOTTOM w0.102: v1(58.34,106.27) 58.01,106.6 U18.D13
APU_TDI: length 111.3
  TOP w0.114: v1(50.48,26.17) 50.51,26.14 C755.1 R512.1 50.4,25.71 50.29,25.71 R511.1
  IN1 w0.089: v1(60.86,105.15) 60.26,104.56 56.73,104.56 56.5,104.78 53.81,104.78 49.79,100.77 49.42,100.77 45.83,97.18 44.31,97.18 41.44,94.31 41.44,93.09 40.27,91.93 40.27,90.36 36.93,87.01 36.93,66.38 32.81,62.27 32.81,42.69 34.03,41.47 34.03,35.76 35.44,34.36 37.56,34.36 44.27,27.65 48.62,27.65 49.49,26.77 49.88,26.77 v1(50.48,26.17)
  BOTTOM w0.114: U18.H15 60.86,104.89 v1(60.86,105.15)
APU_TDO: length 112.7
  TOP w0.114: CN13.8 v1(48.1,25.38)
  IN1 w0.089: v1(48.1,25.38) 45.89,25.38 37.37,33.9 35.25,33.9 33.58,35.57 33.58,41.28 32.36,42.51 32.36,62.46 36.47,66.57 36.47,75.99 35.34,77.11 35.34,80.87 34.05,82.17 34.05,86.55 36.18,88.68 37.24,88.68 39.1,90.54 39.1,91.4 40.98,93.28 40.98,94.5 44.12,97.64 45.64,97.64 49.16,101.15 49.16,102.48 49.66,102.98 49.95,102.98 52.21,105.24 56.84,105.24 57.06,105.01 58.98,105.01 59.74,105.77 60.4,105.77 v1(60.95,106.32)
  BOTTOM w0.114: U18.H14 61.15,106.12 v1(60.95,106.32)
APU_TEST0: length 7
  TOP w0.114: v2(77.92,112.39) 77.22,113.09 77.22,114.97 v1(76.82,115.37) 76.82,116.4 R569.2 76.27,116.96 R568.1
  BOTTOM w0.127: v2(77.92,112.39) 77.65,112.39 77.56,112.3 U18.AH6
APU_TEST1: length 5.7
  TOP w0.114: R571.1 78.56,114.64 R572.2 78.46,114.3 78.46,111.95 TP126.1 78.28,111.66 v2(78.84,111.1)
  BOTTOM w0.102: U18.AK8 78.45,110.71 v2(78.84,111.1)
APU_TEST2: length 11.8
  BOTTOM w0.102: U18.AE3 75.18,115.03 75.18,117.24 75.66,117.73 75.66,118.97
  BOTTOM w0.114: 75.66,118.97 75.66,118.99 77.2,120.54 R574.2 77.48,120.54 77.71,120.77 77.71,121.7 77.88,121.87 77.88,122.45 77.43,122.9 v1(77.43,123.25) 77.99,123.25 78.48,123.73 R573.1
APU_TEST11: length 10
  BOTTOM w0.114: U18.B11 56.26,108.29 55.91,108.29 55.36,108.84 55.06,108.84 51.61,112.29 48.65,112.29 R488.1
APU_TEST14: length 7.7
  BOTTOM w0.114: U18.B10 56.26,109.49 55.42,109.49 53.14,111.78 53.14,112.24 51.6,113.77 R483.1
APU_TEST15: length 14.5
  BOTTOM w0.114: TP117.1 46.49,112.05 51.51,112.05 54.22,109.33 54.22,108.25 54.32,108.16 55.13,108.16 55.47,107.82 55.61,107.82 55.72,107.94 56.18,107.94 56.22,107.89 56.47,107.89 56.53,107.95 56.97,107.95 57.02,107.89 57.34,107.89 57.65,108.2 U18.D11
APU_TEST16: length 9.8
  BOTTOM w0.114: R485.1 48.77,113.19 51.51,113.19 52.92,111.78 52.92,111.65 55.3,109.28 55.67,109.28 U18.A10
APU_TEST17: length 7.8
  BOTTOM w0.114: U18.C11 56.84,108.51 56,108.51 55.45,109.06 55.21,109.06 54.71,109.56 54.68,109.56 51.49,112.76 R487.1
APU_TEST18: length 124.7
  TOP w0.114: v1(48.65,19.06) 48.65,18.43 v1(48.56,18.34) 47.98,17.76 CN13.20
  IN1 w0.089: v1(48.65,19.06) 48.65,19.57 41.02,27.21 40.01,27.21 36.54,30.68 35.6,30.68 31.56,34.73 31.56,40.45 29.98,42.03 29.98,56.91 29.55,57.33 29.55,62.88 33.88,67.21 33.88,75.44 33.32,76 33.32,80.03 32.03,81.33 32.03,87.39 35.35,90.71 36.41,90.71 37.08,91.37 37.08,92.24 38.46,93.62 38.46,99.88 41.18,102.6 41.47,102.6 42.92,104.05 42.92,106.56 46.17,109.81 47.37,109.81 v1(47.57,110.01)
  BOTTOM w0.114: U18.A14 55.67,106.07 54.72,106.07 53.14,107.66 53.14,108.59 52.03,109.7 51.68,109.7 51.56,109.57 48.63,109.57 R489.1 v1(47.57,110.01)
APU_TEST19: length 124.4
  TOP w0.114: v1(47.99,19.21) 47.82,19.03 CN13.18
  IN1 w0.089: v1(46.96,110.25) 46.28,110.25 42.69,106.66 42.69,104.14 41.37,102.82 41.09,102.82 38.23,99.97 38.23,93.71 36.85,92.33 36.85,91.47 36.32,90.94 35.26,90.94 31.8,87.48 31.8,81.23 33.1,79.94 33.1,75.87 33.65,75.31 33.65,67.31 29.33,62.98 29.33,57.24 29.75,56.82 29.75,41.93 31.33,40.35 31.33,34.64 35.51,30.46 36.44,30.46 39.92,26.98 40.92,26.98 48.02,19.88 48.02,19.23 v1(47.99,19.21)
  BOTTOM w0.114: U18.B14 56.39,105.8 55.9,106.29 54.81,106.29 53.35,107.75 53.35,108.72 51.83,110.24 51.48,110.24 R490.1 50.82,110.45 47.16,110.45 v1(46.96,110.25)
APU_TEST28_H: length 12.1
  BOTTOM w0.114: TP118.1 46.26,110.69 51.73,110.69 53.57,108.86 53.57,107.84 54.81,106.6 U18.A13
APU_TEST28_L: length 12
  BOTTOM w0.114: U18.B13 55.99,106.6 55.68,106.91 54.8,106.91 53.78,107.93 53.78,108.98 51.83,110.93 47.23,110.93 TP119.1
APU_TEST31: length 1.6
  TOP w0.114: v1(65.87,95.58) 65.71,95.58 TP120.1
  BOTTOM w0.102: U18.P26 66.38,96.1 v1(65.87,95.58)
APU_TEST37: length 9.8
  BOTTOM w0.114: U18.A17 53.16,103.4 52.24,104.32 49.38,104.32 R499.1 48.56,104.32 47.09,104.32 R498.1
APU_TEST410: length 2.5
  TOP w0.114: TP113.1 79.72,97.15 v1(79.44,97.43)
  BOTTOM w0.114: v1(79.44,97.43) 78.87,98 U18.AK24
APU_TEST411: length 2.1
  TOP w0.114: v1(80.18,97.12) 80.18,97.68 TP114.1
  BOTTOM w0.114: U18.AL24 80.18,97.47 v1(80.18,97.12)
APU_THERMDA: length 1.3
  TOP w0.254: TP115.1 66.15,97.24 v1(66.36,97.45)
  BOTTOM w0.25: v1(66.36,97.45) 66.46,97.55 66.46,97.99 U18.P24
APU_THERMDC: length 1.6
  TOP w0.254: v1(65.07,97.42) 64.09,97.42 TP116.1
  BOTTOM w0.25: v1(65.07,97.42) 65.25,97.61 U18.N24
APU_TMS: length 108.9
  TOP w0.114: v1(48.43,27.21) 48.87,27.21 R510.1 48.57,27.92 CN13.4
  IN1 w0.089: v1(48.43,27.21) 44.39,27.21 37.47,34.13 35.34,34.13 33.81,35.66 33.81,41.38 32.58,42.6 32.58,62.36 36.7,66.48 36.7,87.28 39.33,89.91 39.33,91.3 41.21,93.19 41.21,94.4 44.22,97.41 45.74,97.41 49.33,101 49.7,101 53.72,105.01 56.6,105.01 56.83,104.78 59.67,104.78 v1(60.03,105.15)
  BOTTOM w0.114: v1(60.03,105.15) 60.35,104.83 U18.G15
APU_TRST#: length 112.8
  TOP w0.114: v1(39.84,28.46) 39.56,28.18 v1(39.56,26.9) 39.56,26.7 39,26.13 R508.1 38.42,25.58 38.41,25.57 C754.1 R513.2
  IN1 w0.089: v1(39.84,28.46) 39.71,28.6 39.71,30.27 37,32.98 34.87,32.98 32.66,35.19 32.66,40.9 31.44,42.13 31.44,62.84 35.53,66.93 35.53,75.63 34.43,76.73 34.43,80.49 33.14,81.79 33.14,86.93 35.81,89.61 36.87,89.61 38.18,90.92 38.18,91.78 40.07,93.66 40.07,94.88 45.65,100.46 46.68,100.46 48.18,101.96 48.18,104.83 51.25,107.9 55.24,107.9 56.36,106.78 61.11,106.78 v1(61.63,106.27)
  BOTTOM w0.114: v1(61.63,106.27) 61.95,105.95 U18.J14
APU_U30: length 1.4
  TOP w0.114: TP153.1 68.62,93.76 v1(68.31,93.45)
  BOTTOM w0.102: U18.U30 68.45,93.32 v1(68.31,93.45)
APU_U31: length 1.5
  TOP w0.114: TP154.1 68.96,92.05 v1(69.12,92.21)
  BOTTOM w0.102: U18.U31 68.56,92.21 v1(69.12,92.21)
APU_VDD_RUN_FB_H: length 99.7
  TOP w0.114: v1(112.12,130.89) 112.12,130.36 111.47,129.71 v1(111.47,127.39) 111.47,126.28 110.12,124.93 92.28,124.93 91.61,125.6 90.84,125.6 90.46,125.98 84.38,125.98 84.09,126.27 83.84,126.27 77.36,126.27 76.98,126.66 66.38,126.66 65.84,126.12 65.84,125.28 65.33,124.77 59.88,124.77 58.78,123.67 58.78,122.46 58.32,122 54.92,122 51.54,118.63 51.54,115.17 50.55,114.17 49.38,114.17 49.01,113.8 49.01,112.87 48.74,112.6 v1(47.29,112.6)
  IN1 w0.089: v1(59.92,107.63) 59.72,107.63 59.31,108.04 56.18,108.04 55.53,108.68 54.91,109.3 52.67,109.3 52.03,109.94 50.97,109.94 50.47,110.45 49.44,110.45 v1(47.29,112.6)
  BOTTOM w0.114: PR297.1 115.14,133.33 115.13,133.33 115.13,133.08 115.01,132.96 114.2,132.96 v1(112.12,130.89) ; v1(59.92,107.63) 59.92,107.43 U18.G12
APU_VDD_RUN_FB_L: length 83.9
  TOP w0.114: v1(111.5,131.05) 111.68,130.86 111.68,130.27 110.99,129.57 v1(110.99,128.66) 110.99,126.13 110.02,125.17 92.38,125.17 91.71,125.84 90.94,125.84 90.56,126.22 84.48,126.22 84.19,126.52 83.94,126.52 77.46,126.52 77.08,126.9 66.28,126.9 65.6,126.22 65.6,125.39 65.22,125.01 59.78,125.01 58.54,123.77 58.54,122.56 58.22,122.24 54.82,122.24 51.3,118.73 51.3,115.27 50.45,114.41 49.28,114.41 48.77,113.9 48.77,113.45 48.31,112.99 47.51,112.99 47.41,113.09 v1(46.86,113.09)
  BOTTOM w0.114: PR300.1 112.6,133.44 112.6,132.16 v1(111.5,131.05) ; R505.1 45.93,113.58 46.42,113.09 v1(46.86,113.09)
APU_VDDGFX_RUN_FB_H: length 39.2
  IN1 w0.089: v1(61.81,110.17) 61.81,110.26 61.2,110.87 57.91,110.87 57.07,111.71 54.52,111.71 52.59,113.64 52.59,115.42 52.33,115.68 47.66,115.68 44.06,119.28 37.22,119.28 36.18,120.32 36.18,122.55 v1(35.32,123.41)
  BOTTOM w0.102: v1(61.81,110.17) 61.5,109.86 61.5,108.55 U18.H11
  BOTTOM w0.114: v1(35.32,123.41) 34.69,122.79 v1(33.97,122.79) 33.93,122.84 33.06,122.84 PR342.1
APU_VDDGFX_RUN_FB_L: length 19.2
  IN1 w0.089: v1(44.73,117.61) 44.73,118.29 43.96,119.05 37.13,119.05 35.95,120.22 35.95,122.13 v1(35.31,122.76)
  BOTTOM w0.114: PR346.1 33.21,121.87 33.66,122.32 34.87,122.32 v1(35.31,122.76) ; R503.1 45.19,115.6 v1(45.19,117.14) v1(44.73,117.61)
APU_VDDNB_RUN_FB_H: length 120.9
  TOP w0.114: v1(47.58,113.51) 48.03,113.51 49.18,114.65 50.35,114.65 51.06,115.37 51.06,118.83 54.72,122.48 58.12,122.48 58.3,122.66 58.3,123.87 59.68,125.25 65.12,125.25 65.36,125.49 65.36,126.32 66.18,127.14 77.18,127.14 77.56,126.76 82.12,126.76 84.29,126.76 84.58,126.46 90.66,126.46 91.04,126.08 91.81,126.08 92.48,125.41 109.92,125.41 110.55,126.04 110.55,129.75 v1(110.76,129.96) v1(111.25,130.45) ; PR247.1 118.39,149.99 v1(118.25,150.13)
  IN1 w0.089: v1(61.42,107.51) 60.87,108.07 59.6,108.07 59.4,108.27 56.27,108.27 55.34,109.2 55.01,109.53 52.76,109.53 52.12,110.17 51.07,110.17 50.56,110.68 49.53,110.68 47.98,112.23 47.98,112.69 47.58,113.09 v1(47.58,113.51)
  IN4 w0.089: v1(111.25,130.45) 112.39,130.45 113.69,131.75 115.21,131.75 117.19,133.73 117.19,137.7 117.95,138.47 117.95,145.24 119.4,146.68 119.4,148.75 118.25,149.89 v1(118.25,150.13)
  BOTTOM w0.114: v1(61.42,107.51) 61.94,107 U18.J12
APU_VDDP_RUN_FB_H: length 86.4
  TOP w0.114: v1(28.83,94.17) 29.03,94.37 29.03,96.76 v1(29.27,97.01) 29.5,97.23 29.5,108.65 v1(33.33,112.48)
  IN1 w0.089: v1(33.33,112.48) 34.05,112.48 34.69,111.85 35.45,111.85 36.18,111.12 37.27,111.12 40.33,114.17 47.93,114.17 48.86,113.24 48.86,112.99 49.53,112.32 50.69,112.32 52.8,110.21 55.47,110.21 56.96,108.72 59.59,108.72 59.79,108.52 61.4,108.52 63.36,106.56 63.36,105.25 64.33,104.28 68.98,104.28 69.65,103.61 71.03,103.61 71.42,104.01 78.61,104.01 78.86,103.76 82.64,103.76 83.24,103.16 85.91,103.16 86.45,102.61 v2(86.45,101.71)
  BOTTOM w0.102: v2(86.45,101.71) 86.65,101.91 86.65,102.3 U18.AY18
  BOTTOM w0.114: v1(28.83,94.17) 28.83,95.47 PR493.2
APU_VDDP_RUN_FB_L: length 15.4
  TOP w0.114: v1(41.62,110.64) 41.25,110.26 v1(40.93,110.26) 40.6,110.26 PR492.1
  IN2 w0.127: v1(41.62,110.64) 42.57,111.59 43.86,111.59 48.41,116.14 v1(49.06,116.14)
  BOTTOM w0.114: v1(49.06,116.14) 48.94,116.26 47.02,116.26 46.22,116.26 45.93,115.96 R1066.1
AUD_SPK_L+: length 82.4
  IN3 w1.016: 30,119.88 29.49,119.37 29.49,95.8 30,95.29 30,91.61 28.33,89.95 28.33,84.59 26.87,83.12 26.87,80.39 25.76,79.28 25.76,76.05 23.99,74.28 23.99,71.11 21.26,68.38 21.26,65.18 11.52,55.44 11.52,45.54
  vias: v1(12.69,45.43) v1(12.69,44.77) v1(13.27,44.25) v1(29.09,121.97) v1(29.09,121.31)
AUD_SPK_L-: length 79.8
  IN3 w1.016: 31.39,121.01 31.39,118.55 30.89,118.05 30.89,96.38 31.39,95.87 31.39,91.03 29.73,89.37 29.73,84.01 28.27,82.54 28.27,79.81 27.16,78.7 27.16,75.47 25.39,73.7 25.39,70.53 22.65,67.8 22.65,64.6 12.92,54.86 12.92,49.24
  vias: v1(12.68,47.77) v1(12.68,47.11) v1(15.38,44.89) v1(30.21,121.94) v1(30.21,121.28)
AUD_SPK_R+: length 96.8
  IN4 w1.016: 15.39,37.17 15.4,37.18 15.4,56.8 19.59,60.99 19.59,62.69 22.49,65.59 22.49,67.5 24.17,69.18 24.17,70.74 25.13,71.7 25.13,73.11 26.79,74.77 26.79,77.58 27.46,78.25 27.46,79.26 28.18,79.98 28.18,82.09 28.84,82.75 28.84,84.55 29.71,85.41 29.71,89.25 31.39,90.93 31.39,96.05 30.88,96.55 30.88,118.63 32.68,120.43 32.68,126.39
  vias: v1(13.71,36.58) v1(13.91,37.19) v1(14.34,36.71) v1(31.19,126.94) v1(31.15,126.24)
AUD_SPK_R-: length 91.4
  IN4 w1.016: 31.23,123.6 31.23,120.96 29.48,119.21 29.48,95.98 29.99,95.47 29.99,91.51 28.31,89.83 28.31,85.99 27.45,85.13 27.45,83.33 26.78,82.67 26.78,80.93 26.06,80.21 26.06,78.82 25.39,78.15 25.39,75.34 23.73,73.68 23.73,72.28 22.77,71.32 22.77,69.76 21.09,68.07 21.09,66.17 18.2,63.27 18.2,61.57 13.99,57.37 13.99,39.81
  vias: v1(13.71,38) v1(13.94,38.61) v1(14.36,38.11) v1(31.15,125.56) v1(31.15,124.9)
AUX_ZVSS: length 4.7
  BOTTOM w0.254: R921.1 145.47,88.9 145.47,91.03 U22.BA12
BAT_LED_AMBER: length 39
  TOP w0.114: U34.32 219.77,11.81 219.48,11.52 219.48,10.15 218.81,9.48 208.75,9.48 205.83,12.4 201.56,12.4 201.21,12.76 v1(199.72,12.76) ; Q13.5 198.64,24.26 v1(199.52,25.14)
  BOTTOM w0.114: v1(199.52,25.14) 199.05,24.66 199.05,19.77 199.72,19.09 v1(199.72,18.32) v1(199.72,12.76)
BAT_LED_AMBER#: length 2.9
  TOP w0.254: R1108.1 200.34,23.34 EC164.2 199.49,22.21 199.29,22.02 Q13.3
BAT_LED_W#: length 2.6
  TOP w0.254: R1109.1 197.93,25.51 198.02,25.42 EC166.2 197.99,24.85 Q13.6
BAT_LED_WHITE: length 29.7
  TOP w0.114: U34.2 219.87,23.81 219.18,24.5 219.18,25.16 218.66,25.68 R967.1 218.16,25.99 217.98,26.16 214.74,26.16 212.13,23.55 v1(209.56,23.55) 206.07,23.55 200.73,18.22 199.25,18.22 199.03,18.44 Q16.3 199.03,20.52 198.64,20.91 Q13.2
BEEP: length 4
  TOP w0.114: CN5.25 22.68,12.3 22.87,12.11 24.89,12.11 v1(24.96,12.17) 25.01,12.22 25.01,12.23 R1053.1
BEEP_R: length 208.7
  TOP w0.114: R1053.2 27.14,12.93 v1(27.36,12.72) 27.58,12.49 v1(28.08,12.49) ; U34.34 222.77,9.35 222.42,9 222,9 v1(221.72,8.71)
  IN4 w0.089: v1(28.08,12.49) 29.38,11.19 32.02,11.19 34.82,13.99 50.2,13.99 52.36,16.15 76.16,16.15 77.08,17.07 98.7,17.07 99.06,17.43 107.92,17.43 108.46,16.89 109.94,16.89 110.12,16.7 110.4,16.7 111.77,15.33 118.52,15.33 118.7,15.51 123.4,15.51 124.41,16.52 141.06,16.52 141.66,17.12 155.61,17.12 156.1,17.61 172.96,17.61 179.97,10.6 184.77,10.6 189.27,6.09 217.8,6.09 220.83,9.13 221.3,9.13 v1(221.72,8.71)
BID1: length 5.9
  TOP w0.114: U34.71 237.14,14.21 237.63,13.73 238.24,13.73 R971.2 239.16,13.9 240.22,13.9 240.49,14.16 v1(240.85,14.16) R970.1
BIOS_CS#_B: length 7.5
  TOP w0.114: TP294.1 139.84,145.51 138.49,145.51 R609.2 R600.2 136.71,144.89 136.07,145.52 U20.1
BIOS_HOLD#_B: length 6.2
  TOP w0.114: TP299.1 122.78,145.52 R601.1 123.5,145.61 124.28,146.39 R614.1 124.53,146.79 U20.7
BIOS_RD#_B: length 6.5
  TOP w0.114: TP296.1 139.55,146.47 138.55,146.47 R612.2 137.78,147.05 137.53,146.79 U20.2
BIOS_SPI_CLK_B: length 5.3
  TOP w0.114: U20.6 125.8,148.06 125.29,147.55 R610.2 123.79,147.06 122.98,147.06 TP295.1
BIOS_WP_B: length 5.9
  TOP w0.114: U20.3 R613.1 R599.1 137.98,149.66 TP298.1
BIOS_WR#_B: length 7.6
  TOP w0.114: U20.5 126.56,149.33 125.29,150.6 R611.2 124.28,150.86 124.08,151.06 123.16,151.06 121.48,149.37 TP297.1
BLON_PWM: length 15.8
  TOP w0.114: R717.2 117.43,104.75 v1(118.08,104.1) 118.77,103.41 125.72,103.41 128.52,100.61 v2(130.74,100.61)
  BOTTOM w0.127: v2(130.74,100.61) 130.74,100.64 U22.AC38
BOARD_ID0: length 7.2
  BOTTOM w0.114: TP246.1 94.3,119.45 U18.BC3
BOARD_ID1: length 9.2
  BOTTOM w0.114: U18.BA3 87.91,114.76 88.11,114.76 88.26,114.91 89.36,114.91 92.39,117.94 TP245.1
BOARD_ID2: length 7.4
  BOTTOM w0.114: U18.BC5 93.53,117.18 93.53,117.45 TP124.1
BOARD_ID3: length 10.7
  BOTTOM w0.114: U18.BA5 88.19,113.44 89.09,113.44 90.79,115.14 90.79,115.33 94.81,119.35 95.32,119.35 TP125.1
BOOT_1: length 3.6
  BOTTOM w0.508: PR290.1 v1(109.76,140.49) 110.59,141.31
BOOT_2: length 3.3
  BOTTOM w0.508: PR271.1 108.55,147.8 v1(109.56,146.79) 110.24,146.11 110.29,146.11
BOOT_CI: length 4.4
  BOTTOM w0.203: 144.76,52.39 144.44,52.07 144.04,52.07 143.53,51.56 PU24.31
  BOTTOM w0.762: PR392.1 145.99,53.62 v1(145.45,53.09) 144.76,52.39
BOOT_GFX1: length 2.9
  BOTTOM w0.203: 37.1,124.74 37.5,124.74 37.6,124.65 PU17.21
  BOTTOM w0.508: PR330.1 36.67,126.32 v1(36.67,125.61) 36.67,125.17 37.1,124.74
BOOT_GFX2: length 5.2
  BOTTOM w0.203: 41.69,124.87 41.29,124.87 41.2,124.78 PU17.30
  BOTTOM w0.508: PR308.1 v1(44.26,125.25) 43.67,124.67 41.89,124.67 41.69,124.87
BOOT_GPU1: length 4.2
  BOTTOM w0.203: PU24.21 138.98,52.45 138.82,52.61 138.15,52.61 137.98,52.78 v1(137.37,52.78)
  BOTTOM w0.762: PR429.1 136.34,53.81 v1(137.37,52.78)
BOOT_GPU2: length 4.2
  BOTTOM w0.203: v1(144.11,53.09) 143.92,52.9 143.92,52.47 143.37,51.92 142.66,51.92 142.58,52 PU24.30
  BOTTOM w0.762: PR408.1 144.56,53.55 v1(144.11,53.09)
BOOT_NB: length 4.5
  BOTTOM w0.203: PU16.31 111.3,146.48 111.16,146.61
  BOTTOM w0.254: 111.16,146.61 110.63,146.61 110.2,147.04
  BOTTOM w0.508: 110.2,147.04 v1(109.02,148.22) PR252.1
BP_0: length 14.7
  TOP w0.114: v2(131.53,102.82) 129.02,102.82 123.99,107.85 TP278.1 122.2,107.85 121.18,108.88 120.78,108.88 R643.1
  BOTTOM w0.127: U22.AA38 131.53,102.53 v2(131.53,102.82)
BP_1: length 15.8
  TOP w0.114: v2(132.33,102.84) 131.91,103.26 129.62,103.26 123.76,109.12 TP277.1 122.01,109.12 121.37,109.76 120.52,109.76 R644.1
  BOTTOM w0.127: v2(132.33,102.84) 132.33,102.53 U22.AA37
BT_RADIO_DIS#: length 265.9
  TOP w0.114: v1(233.77,24.44) 233.97,24.64 U34.99
  IN4 w0.089: v1(233.77,24.44) 234.18,24.03 234.83,24.03 235.9,22.96 235.9,19.62 235.54,19.26 234.88,19.26 234.36,18.74 234.36,14.7 233.01,13.34 226.37,13.34 222.49,9.46 220.84,9.46 217.7,6.32 189.36,6.32 184.86,10.83 180.08,10.83 173.07,17.84 156.01,17.84 155.52,17.34 141.56,17.34 140.97,16.75 124.32,16.75 123.3,15.74 118.61,15.74 118.43,15.56 111.87,15.56 110.5,16.93 110.22,16.93 110.03,17.12 108.56,17.12 108.03,17.66 98.96,17.66 98.6,17.3 76.99,17.3 76.06,16.37 52.27,16.37 50.11,14.22 32.5,14.22 31.21,12.93 27.9,12.93 27.57,12.6 26.26,12.6 24,10.33 22.81,10.33 22.19,10.96 22.19,14.73 20.64,16.28 18.78,16.28 18.51,16.55 12.39,16.55 10.36,14.52 7.81,14.52 7.14,13.85 5.82,13.85 v1(5.42,13.44)
  BOTTOM w0.114: v1(5.42,13.44) 4.54,14.32 4.54,14.63 3.24,15.93 CN10.54
CAP_LED: length 264.4
  TOP w0.114: v1(97.14,22.56) 97.27,22.56 99.02,20.81 v1(100.36,20.81) 105.42,20.81 108.34,17.9 110.29,17.9 110.95,17.23 113.81,17.23 114.08,17.51 114.08,18.18 114.47,18.56 126.33,18.56 128.6,20.82 130.77,20.82 132.19,19.4 157.61,19.4 158.93,18.08 179.74,18.08 184.6,13.23 188.74,13.23 195.27,6.69 203.11,6.69 205.74,9.32 205.74,10.02 v1(205.38,10.38) ; v1(226.96,23.68) 226.96,24.8 226.77,24.99 U34.117
  IN1 w0.089: v1(25.54,58.96) 24.59,58.01 24.59,47.82 25.51,46.9 25.51,42.01 28.38,39.13 28.38,33.41 31.24,30.55 31.24,27.32 37.05,21.52 37.05,20.82 39.73,18.14 41.59,18.14 42.84,16.89 49.15,16.89 50.17,17.91 52.32,17.91 56.29,21.88 96.61,21.88 97.14,22.41 v1(97.14,22.56)
  BOTTOM w0.114: v1(205.38,10.38) 210.7,10.38 212.88,12.56 212.88,19.31 216.65,23.09 218.88,23.09 219.67,23.88 226.76,23.88 v1(226.96,23.68) ; Q21.2 R352.1 26.22,59.64 v1(25.54,58.96)
CAP_LED_L: length 4.6
  TOP w0.254: CN2.4 v1(31,59.33)
  BOTTOM w0.254: R350.2 29.9,61.58 30.54,60.94 v1(30.54,60.43) 30.54,59.79 v1(31,59.33)
CASA0B: length 29.3
  TOP w0.102: v1(138.79,110.99) 138.79,111.19 138.37,111.6 138.37,112.12 139.05,112.8 139.05,112.89
  TOP w0.14: 139.05,112.89 139.05,114.83 138.69,115.19 138.69,117.64 136.78,119.55 136.78,123.14 136.92,123.28 137.75,123.28 137.88,123.41 137.88,123.71 137.75,123.84 136.92,123.84 136.78,123.98 136.78,124.26 136.92,124.4 137.77,124.4 137.9,124.53 137.9,124.83 137.77,124.96 136.92,124.96 136.78,125.1 136.78,125.83 136.43,126.18 v1(136.43,127.53) 136.43,129.68 136.17,129.93 135.21,129.93 134.65,130.49 134.65,130.83 135.1,131.28 v1(135.1,132.22)
  BOTTOM w0.14: v1(135.1,132.22) 135.51,131.82 VRAM1.L3 ; U22.D23 138.89,110.99 v1(138.79,110.99)
CASA1B: length 27.5
  TOP w0.102: v1(147.2,132.24) 147.2,131.58 147.06,131.45 145.98,131.45 ; 142.98,113.39 142.98,112.62 143.53,112.07 143.53,111.51 v1(143.02,111)
  TOP w0.14: 142.98,113.39 142.98,114.57 142.61,114.94 142.61,118.88 143.77,120.04 143.77,126.57 v1(143.85,126.65) 144.1,126.9 144.1,127.28 143.77,127.61 143.77,128.05 144.03,128.3 144.03,128.68 143.77,128.93 143.77,129.24 144.1,129.57 144.1,129.95 143.77,130.28 143.77,130.89 143.88,131 144.17,131 144.41,130.76 145.3,130.76 145.98,131.45
  BOTTOM w0.14: U22.D17 142.9,111 v1(143.02,111) ; v1(147.2,132.24) 147.17,132.24 VRAM2.G3
CASB0B: length 30.2
  TOP w0.11: 150.86,104.42 149.82,104.42 149.34,104.9 v2(149.2,104.9)
  TOP w0.14: v1(169.91,108.97) 169.47,108.97 168.79,108.3 168.79,107.91 168.54,107.66 168.13,107.66 167.83,107.97 167.44,107.97 167.14,107.66 164.83,107.66 164.65,107.84 164.14,107.84 163.51,107.2 163.51,106.44 163.76,106.19 164.12,106.19 164.24,106.06 164.24,104.63 164.37,104.5 164.88,104.5 165.01,104.37 165.01,103.93 164.88,103.8 153.5,103.8 153.32,103.62 151.92,103.62 151.79,103.75 151.79,104.26 151.63,104.42 150.86,104.42
  BOTTOM w0.14: VRAM3.L3 169.52,108.58 v1(169.91,108.97) ; U22.U4 149.2,104.7 v2(149.2,104.9)
CASB1B: length 30.7
  TOP w0.102: v2(149.2,100.57) 149.38,100.57 149.79,100.17 150.65,100.17 150.72,100.24 150.94,100.24 ; v1(169.91,95.35) 168.96,95.35 168.83,95.47 168.83,96.23 167.63,97.43 167.63,98.13 167.63,98.14
  TOP w0.14: 150.94,100.24 151.24,100.24 152,99.48 v1(161.41,99.48) 162.36,99.48 162.61,99.23 162.61,98.21 162.74,98.09 163.24,98.09 163.37,98.21 163.37,99.23 163.5,99.36 164.01,99.36 164.13,99.23 164.13,98.47 164.26,98.34 164.64,98.34 164.77,98.47 164.77,99.23 164.89,99.36 166.42,99.36 166.55,99.23 166.55,98.9 166.67,98.77 167.05,98.77 167.18,98.9 167.18,99.23 167.31,99.36 167.64,99.36 167.82,99.18 167.82,98.59 167.63,98.41 167.63,98.14
  BOTTOM w0.14: v2(149.2,100.57) 149.55,100.92 U22.AC4 ; VRAM4.G3 169.51,95.75 v1(169.91,95.35)
CHGR_ACDET: length 4.6
  BOTTOM w0.114: v1(65.74,8.35) PR228.2
  BOTTOM w0.178: 69.01,9.19 69.14,9.31 PU15.6
  BOTTOM w0.254: 69.01,9.19 68.59,8.77 PC246.1 PR229.1 PR228.2
CHGR_ACDRV: length 11.3
  TOP w0.508: v1(61.56,10.15) 62.36,10.95 v1(62.75,10.95) 65.44,10.95 67.4,8.98 v1(70.05,8.98)
  BOTTOM w0.178: PU15.4 69.94,9.09 v1(70.05,8.98)
  BOTTOM w0.508: PR217.2 v1(61.56,10.15)
CHGR_ACN: length 17.5
  IN1 w0.152: v1(71.83,5.53) v1(70.44,5.53)
  BOTTOM w0.152: PU15.1 71.14,9.45 71.95,8.64 PC241.2 71.95,7.06 v1(72.07,6.94) 72.39,6.62 PC250.1 72,5.97 71.83,5.81 v1(71.83,5.53) ; PR232.2P 62.5,7.09 62.4,6.99 62.4,5.18 62.68,4.9 69.81,4.9 v1(70.44,5.53)
CHGR_ACOK: length 1.5
  BOTTOM w0.178: PU15.5 69.54,8.8
  BOTTOM w0.254: PR230.2 69.61,8.73 69.54,8.8
CHGR_ACP: length 16.5
  BOTTOM w0.152: PR232.1P 61.96,7.09 62.12,6.94 62.12,5.06 62.56,4.62 70.18,4.62 v1(70.45,4.89) 71.07,5.51 PC251.1 71.07,7.01 71.17,7.1 PC241.1 71.17,8.96 70.74,9.39 PU15.2
CHGR_BATDRV: length 1.9
  BOTTOM w0.178: PU15.18 69.94,14.95
  BOTTOM w0.508: 69.94,14.95 PR187.1
CHGR_BATDRV_P: length 31.6
  TOP w0.508: v1(70.09,17.51) 70.85,18.27 93.16,18.27 95.59,15.83 96.53,15.83 v1(96.96,15.4) v1(97.85,14.52)
  BOTTOM w0.33: PQ33.4 v1(97.85,14.52)
  BOTTOM w0.508: v1(70.09,17.51) 70.09,17.47 PR187.2
CHGR_BATSRC: length 2.7
  BOTTOM w0.178: 68.57,15.09 68.78,14.88 69.07,14.88 69.54,14.41 PU15.17
  BOTTOM w0.508: PR190.1 68.12,15.53 68.57,15.09
CHGR_BST: length 2.7
  BOTTOM w0.203: v1(73.09,11.77) 72.87,11.77 72.8,11.84 PU15.25
  BOTTOM w0.508: v1(73.09,11.77) 73.37,11.77 74.21,10.92 PR483.1
CHGR_CMSRC: length 10.8
  TOP w0.508: v1(70.64,8.58) 70.25,8.19 67.29,8.19 65.18,10.31 v1(64.71,10.31) 63.25,10.31 v1(63.08,10.15)
  BOTTOM w0.178: PU15.3 70.34,9.38 70.64,9.08 v1(70.64,8.58)
  BOTTOM w0.508: PR218.2 v1(63.08,10.15)
CHGR_HIDRV: length 22.2
  TOP w0.762: v3(87.59,7.9) 86.6,7.9 86.46,7.76 73.19,7.76 72.39,8.56 72.39,10.41 v3(73.06,11.08)
  BOTTOM w0.178: PU15.26 72.7,11.44 v3(73.06,11.08)
  BOTTOM w0.33: 88.39,8.68 88.39,9.14 88.24,9.29 PQ37.4
  BOTTOM w0.508: v3(87.59,7.9) TP102.1 88.39,7.92 88.39,8.68
CHGR_IDCHG: length 2.2
  BOTTOM w0.114: PU15.8 67.3,10.64 66.74,11.21 TP101.1
CHGR_LODRV: length 14.2
  TOP w0.889: v3(82.71,15.25) 82.36,14.89 78.14,14.89 76.67,13.41 73.47,13.41 v3(72.9,12.84)
  BOTTOM w0.178: PU15.23 72.7,12.64 v3(72.9,12.84)
  BOTTOM w0.33: TP98.1 84.24,15.25 84.49,15 PQ32.4
  BOTTOM w0.508: TP98.1 v3(82.71,15.25)
CHGR_PHASE: length 20.6
  TOP w0.762: v3(88.98,10.05) v1(87.14,10.05) 85.74,10.05 84.69,8.99 v3(74.12,8.99)
  BOTTOM w0.178: PU15.27 72.37,11.04 73.13,10.28
  BOTTOM w0.508: PC242.1 89.46,9.05 89.73,9.31 89.73,9.97 ; 73.13,10.28 73.73,9.67 PC236.2 73.97,9.14 v3(74.12,8.99)
CHGR_PROCHOT#: length 1.9
  BOTTOM w0.114: PU15.10 67.34,11.44 67.31,11.47 67.31,11.47 66.59,12.2 66.59,12.2 66.42,12.37 PR215.2
CHGR_REGN: length 14.8
  IN1 w0.254: v1(74.83,11.65) 70.82,7.65 70.02,7.65 67.95,5.58 v1(66.57,5.58)
  BOTTOM w0.178: PU15.24 72.4,12.24 72.43,12.27 72.68,12.27
  BOTTOM w0.254: 72.68,12.27 72.68,12.27 73.56,12.27 73.56,12.27 PC226.1 74.83,11.66 v1(74.83,11.65) ; PR237.1 v1(66.57,5.58)
CHGR_SRN: length 1.9
  BOTTOM w0.152: PU15.19 70.34,14.65 70.85,15.17 PR188.2
CHGR_SRP: length 2.7
  BOTTOM w0.152: PR189.2 71.69,14.87 71.05,14.87 70.74,14.56 PU15.20
CHGR_TB_STAT: length 4.2
  BOTTOM w0.178: PU15.16 69.14,14.27 68.83,14.57 68.49,14.57
  BOTTOM w0.254: PR191.2 66.23,15.88 66.84,15.27 ; 66.84,15.27 67.54,14.57 68.49,14.57 ; 66.84,15.27 v1(66.84,15.27)
CHGR_VCC: length 4.7
  BOTTOM w0.508: 72.01,10.07 72.25,10.07 v1(72.81,9.5) 73.14,9.18 PC245.1 73.69,8.45 73.87,8.27 PR234.2
CKEA0: length 30.3
  TOP w0.102: v1(135.95,133.02) 136.38,132.59 136.38,131.89 136.51,131.75 ; 139.9,112.78 139.9,112.6 139.48,112.17 139.48,109.8 v1(139.89,109.39)
  TOP w0.14: 139.9,112.78 139.9,118.42 139.02,119.3 139.02,120.15 138.88,120.28 138.1,120.28 137.97,120.42 137.97,120.7 138.1,120.84 138.88,120.84 139.02,120.98 139.02,125.59 139.16,125.73 139.73,125.73 139.86,125.86 139.86,126.16 139.73,126.29 139.16,126.29 139.02,126.43 139.02,127.29 138.45,127.86 138.45,130.38 138.06,130.77 137.5,130.77 136.51,131.75
  BOTTOM w0.14: VRAM1.J3 v1(135.95,133.02) ; U22.G21 139.99,109.39 v1(139.89,109.39)
CKEA1: length 30
  TOP w0.102: 141.76,112.51 141.85,112.43 142.1,112.43 142.41,112.12 142.41,110.88 v1(142,110.47)
  TOP w0.14: v1(146.35,133.04) 146.34,133.04 145.88,133.51 145.37,133.51 145.12,133.25 144.1,133.25 143.98,133.13 143.98,132.49 143.85,132.36 143.34,132.36 143.21,132.49 143.21,132.77 143.03,132.95 142.78,132.95 142.59,132.76 142.59,127.68 v1(142.45,127.54) 142.45,120.4 141.43,119.38 141.43,114.88 141.51,114.8 141.51,112.76 141.76,112.51
  BOTTOM w0.14: VRAM2.J3 146.74,133.44 146.34,133.04 v1(146.35,133.04) ; v1(142,110.47) 141.92,110.55 U22.E19
CKEB0: length 31.7
  TOP w0.102: v2(148.4,103.8) 148.83,104.22 149.36,104.22 149.62,103.97 149.62,103.51
  TOP w0.14: 149.62,103.51 149.76,103.37 150.4,103.37 152.1,101.66 154.03,101.66 154.21,101.84 155.11,101.84 155.6,102.34 169.22,102.34 v1(169.81,102.92) 170.71,102.92 171.43,103.65 171.43,105.55 170.87,106.11 170.87,106.72 171.25,107.1 171.25,107.6 v1(170.72,108.13)
  BOTTOM w0.14: U22.W5 148.75,103.45 v2(148.4,103.8) ; VRAM3.J3 171.12,108.53 v1(170.72,108.13)
CKEB1: length 30.5
  TOP w0.102: 151.07,100.83 150.78,100.83 150.42,101.18 147.56,101.18 147.44,101.3 147.44,101.55 147.57,101.67 v2(147.6,101.67)
  TOP w0.14: 151.07,100.83 151.57,100.83 151.67,100.72 153.42,100.72 153.57,100.57 156.28,100.57 156.6,100.89 169.58,100.89 169.84,100.64 169.84,99.9 169.11,99.18 169.11,98.68 169.32,98.47 169.32,97.29 169.42,97.2 170.1,97.2 170.26,97.03 170.26,96.42 170.58,96.1 v1(170.71,96.1)
  BOTTOM w0.14: U22.AA7 147.95,102.02 v2(147.6,101.67) ; v1(170.71,96.1) 171.06,95.75 VRAM4.J3
CLK_PCI_EC: length 222.1
  TOP w0.114: v1(222,19.11) 221.9,19.11 221.6,19.41 U34.13
  IN1 w0.089: v1(117.08,33.86) 114.96,35.98 114.96,47.55 114.24,48.27 114.24,68.77 114.85,69.38 114.85,76.59 117.91,79.65 117.91,85.72 110.83,92.8 110.83,96.15 107.04,99.93 107.04,103.18 105.04,105.18 105.04,105.6 v1(104.6,106.05)
  IN3 w0.127: v1(114.52,17.89) 114.52,20.22 117.72,23.42 117.72,27.24 117.23,27.73 117.23,28.54 115.89,29.88 115.89,30.46 117.08,31.65 v1(117.08,33.86)
  IN4 w0.089: v1(114.52,17.89) 114.78,18.14 123.5,18.14 123.98,17.66 140.59,17.66 141.19,18.26 155.14,18.26 155.65,18.78 173.43,18.78 179.57,12.64 191.47,12.64 197.35,18.51 197.35,19.8 198.46,20.92 201.36,20.92 203.52,18.75 210.59,18.75 212.39,20.55 216.89,20.55 218.86,18.58 221.48,18.58 v1(222,19.11)
  BOTTOM w0.114: R589.1 101.32,107.42 102.26,107.42 C768.2 v1(103.64,106.05) v1(104.6,106.05)
CLK_PCIE_LANN: length 287.9
  TOP w0.114: U2.16 268.36,87 268.32,87.04 268.15,87.04 268.09,86.97 268.09,86.87 268.25,86.71 268.6,86.71 268.81,86.51 268.81,86.35 v1(269.13,86.03)
  IN3 w0.114: v1(269.13,86.03) 269.13,85.7 269.3,85.52 269.3,84.93 267.93,82.36 267.93,73.89 267.5,72.95 267.35,72.47 267.35,70.43 266.16,67.4 266.16,67.27 266.15,67.26 265.33,65.51 264.47,63.4 264.47,58.71 263.67,57.92 262.4,53.72 262.4,51.23 258.08,46.91 250.86,42.92 250.83,42.91 231.15,37.2 218.2,37.2 204.38,42.07 195.31,42.07 191.6,45.78 189.64,50.47 186.43,53.67 178.14,74.83 173.26,79.71 167.38,79.71 163.77,81.51 160.86,81.51 157.68,82.27 154.6,82.27 148.24,84.18 147.44,84.98 146.92,84.98 146.46,85.43 146.46,86.16 144.36,88.27 142.15,88.27 136.62,86.44 124.69,86.44 123.01,85.84 120.6,85.84 114.09,92.35 114.09,111.89 110.54,115.44 110.54,118.63 106.22,122.94 100.1,122.94 96.73,123.81 96.73,123.81 96.67,123.83 92.54,124.95 90.64,124.95 90.1,125.49 78.86,125.49 76.8,124.94 75.79,124.94 75.58,125.16 75.58,125.38 v2(75.38,125.58)
  BOTTOM w0.114: v2(75.38,125.58) 75.57,125.39 75.57,125.19 75.41,125.03 75.24,125.03 74.97,124.76 74.97,124.38 74.9,124.31 R812.2
CLK_PCIE_LANN_R: length 12.3
  BOTTOM w0.114: R812.1 74.86,123.53 74.97,123.42 74.97,123.23 74.88,123.14 73.5,122.77 72.55,121.83 72.55,120.35 71.69,119.09 71.61,118.97 71.44,118.72 70.96,118.02 70.86,117.92 70.77,117.59 70.33,115.99 70.33,115.67 70.38,115.61 70.38,115.39 70.29,115.3 70.29,114.92 70.38,114.83 70.38,114.52 70.19,114.33 70.12,114.33 70.05,114.4 U18.W3
CLK_PCIE_LANP: length 287.9
  TOP w0.114: v1(268.36,86.03) 268.53,86.03 268.59,86.1 268.59,86.42 268.51,86.5 268.16,86.5 267.87,86.78 267.87,87.06 268.06,87.25 268.26,87.25 268.4,87.4 U2.15
  IN3 w0.114: v2(75.97,125.58) 75.8,125.4 75.8,125.25 75.88,125.16 76.77,125.16 78.83,125.7 90.19,125.7 90.73,125.17 92.57,125.17 96.78,124.02 100.12,123.16 106.31,123.16 110.75,118.72 110.75,115.53 114.31,111.98 114.31,92.44 120.69,86.06 122.98,86.06 124.65,86.66 136.58,86.66 142.11,88.48 144.45,88.48 146.68,86.25 146.68,85.52 147,85.19 147.53,85.19 148.35,84.37 154.63,82.49 157.7,82.49 160.89,81.72 163.82,81.72 167.43,79.93 173.35,79.93 178.33,74.95 186.62,53.8 189.82,50.59 191.79,45.9 195.4,42.29 204.42,42.29 218.24,37.41 231.12,37.41 250.74,43.11 250.75,43.11 254.35,45.1 257.94,47.09 262.18,51.32 262.18,53.75 263.46,57.98 263.48,58.03 264.25,58.8 264.25,63.45 265.13,65.59 265.13,65.59 265.94,67.32 265.94,67.44 267.13,70.47 267.13,72.5 267.17,72.64 267.3,73.03 267.72,73.93 267.72,82.42 269.08,84.99 269.08,85.43 268.83,85.69 268.7,85.69 v1(268.36,86.03)
  BOTTOM w0.114: v2(75.97,125.58) 75.78,125.39 75.78,125.1 75.5,124.82 75.33,124.82 75.18,124.67 75.18,124.41 75.28,124.31 R813.2
CLK_PCIE_LANP_R: length 12.3
  BOTTOM w0.114: R813.1 74.99,122.95 73.61,122.58 72.77,121.74 72.77,120.28 71.87,118.97 71.62,118.6 71.13,117.88 71.06,117.81 70.98,117.53 70.54,115.96 70.54,115.76 70.6,115.7 70.6,115.3 70.5,115.21 70.5,115.01 70.6,114.91 70.6,114.43 70.27,114.1 70.13,114.1 70.05,114.02 U18.W4
CLK_PCIE_WLANN: length 151.5
  IN3 w0.114: v2(71.52,125.45) 71.31,125.25 71.31,123.67 68.32,120.68 56.84,120.68 54.21,118.04 54.21,116.17 53.61,115.58 53.61,108.02 52.25,106.66 49.99,106.66 48.42,105.1 48.42,101.07 43.3,95.95 43.3,90.25 39.56,86.5 39.56,78.82 35.13,74.39 35.13,68.32 29.84,63.03 29.84,58.82 30.51,58.15 30.51,30.49 24.84,24.82 23.81,24.82 18.13,19.14 16.86,19.14 13.64,15.92 12.88,15.92 12.29,15.33 12.29,14.94 v1(12.57,14.66)
  BOTTOM w0.114: R585.2 71.4,125.02 71.4,125.34 v2(71.52,125.45) ; CN10.49 10.42,14.68 11.21,15.47 11.58,15.47 12.03,15.47 12.36,15.14 12.36,14.87 v1(12.57,14.66)
CLK_PCIE_WLANN_R: length 9.7
  BOTTOM w0.114: U18.U2 68.75,115.8 68.75,115.83 69.04,116.12 69.04,116.72 69.61,117.29 69.61,118.22 70.35,118.97 70.35,119.8 70.54,119.99 70.54,121.79 71.58,122.83 71.58,123.51 R585.1
CLK_PCIE_WLANP: length 151.5
  IN3 w0.114: v1(11.78,14.66) 12.08,14.97 12.08,15.42 12.79,16.13 13.55,16.13 16.77,19.35 18.04,19.35 23.72,25.04 24.75,25.04 30.3,30.58 30.3,58.06 29.62,58.73 29.62,63.12 34.91,68.41 34.91,74.48 39.34,78.91 39.34,86.59 43.09,90.34 43.09,96.04 48.21,101.16 48.21,105.19 49.9,106.88 52.16,106.88 53.39,108.11 53.39,115.67 53.99,116.26 53.99,118.13 56.75,120.9 68.23,120.9 71.1,123.76 71.1,125.28 v2(70.92,125.45)
  BOTTOM w0.114: v2(70.92,125.45) 71.18,125.19 71.18,124.91 R584.2 ; v1(11.78,14.66) 12.04,14.66 12.15,14.78 12.15,15.05 11.94,15.26 11.67,15.26 11.3,15.26 10.51,14.46 9.81,14.46 9.53,14.18 CN10.47
CLK_PCIE_WLANP_R: length 9.7
  BOTTOM w0.114: U18.U1 68.45,116.15 68.54,116.06 68.67,116.06 68.82,116.21 68.82,116.81 69.39,117.38 69.39,118.31 70.14,119.06 70.14,119.89 70.33,120.08 70.33,121.88 71.36,122.92 71.36,123.68 71.25,123.79 R584.1
CLK_REQ3: length 8.2
  BOTTOM w0.102: U18.BB18 88.43,102.6 88.73,102.3 89.13,102.3 89.32,102.49 90.46,102.49 90.7,102.72 93.28,102.72 93.69,102.32 93.93,102.32 94.36,101.88 95.33,101.88 R528.1
CLK_VGA_N: length 82.7
  IN3 w0.114: v2(73.16,123.86) 73.31,124.01 73.31,125.14 74.51,126.34 90.45,126.34 90.99,125.8 92.83,125.8 97.04,124.66 97.05,124.66 100.69,123.79 106.58,123.79 113.75,116.62 113.79,116.58 119.21,114.05 119.46,113.8 121.71,111.55 121.71,110.25 122.84,109.13 123.47,109.13 124.08,108.52 129.19,95.87 130.54,94.51 132.38,94.51 132.99,93.91 133.12,93.91 v1(133.36,94.14)
  BOTTOM w0.102: U22.AU33 133.75,93.75 v1(133.36,94.14)
  BOTTOM w0.114: R816.2 71.31,121.32 71.41,121.41 71.41,121.69 73.31,123.59 73.31,123.71 v2(73.16,123.86)
CLK_VGA_N_R: length 8.7
  BOTTOM w0.114: U18.U3 68.34,114.59 68.34,114.43 68.42,114.35 68.6,114.35 68.7,114.45 69.2,114.45 69.53,114.78 69.53,114.92 69.57,114.96 69.57,115.24 69.53,115.28 69.53,115.72 69.57,115.76 69.57,116.04 69.53,116.08 69.53,116.72 70.12,117.31 70.12,118.14 70.77,118.78 70.77,119.38 71.46,120.07 71.46,120.38 71.3,120.54 R816.1
CLK_VGA_P: length 82.7
  IN3 w0.114: v2(73.75,123.86) 73.52,124.09 73.52,125.05 74.6,126.12 90.36,126.12 90.9,125.59 92.8,125.59 96.93,124.46 96.99,124.45 97,124.45 100.66,123.58 106.49,123.58 113.66,116.4 119.09,113.87 121.5,111.46 121.5,110.16 122.75,108.91 123.38,108.91 123.9,108.39 129,95.74 130.45,94.3 132.29,94.3 132.9,93.69 133.25,93.69 133.36,93.58 v2(133.36,93.34)
  BOTTOM w0.114: v2(73.75,123.86) 73.52,123.63 73.52,123.5 71.62,121.6 71.62,121.37 71.68,121.32 R817.2 ; U22.AV33 133.36,93.34 v2(133.36,93.34)
CLK_VGA_P_R: length 8.7
  BOTTOM w0.114: U18.U4 68.79,114.24 69.29,114.24 69.74,114.69 69.74,114.83 69.79,114.87 69.79,115.33 69.74,115.37 69.74,115.63 69.79,115.67 69.79,116.13 69.74,116.17 69.74,116.63 70.34,117.23 70.34,118.05 70.98,118.69 70.98,119.29 71.68,119.98 71.68,120.45 71.76,120.54 R817.1
CLKA0: length 37.3
  TOP w0.127: R772.2 131,135.43 131,135.37 130.55,134.91 129.98,134.91 v1(129.96,134.89) 129.96,134.5 129.1,133.65 128.92,133.65 v1(128.75,133.82) 128.42,133.49 128.25,133.49 126.6,131.84 125.74,131.84 124.67,130.77 124.67,122.17 124.93,121.91 126.05,121.91 126.18,121.78 126.18,121.28 126.05,121.15 124.93,121.15 124.67,120.89 124.67,120.06 132.47,112.26 133.3,112.26 133.63,111.92 133.63,111.53 134.02,111.14 134.21,111.14 v1(134.4,110.95)
  BOTTOM w0.127: v1(134.4,110.95) 134.8,110.55 U22.E31 ; v1(128.75,133.82) VRAM1.J12
CLKA0B: length 36.8
  TOP w0.127: R768.2 131.21,134.88 130.84,134.88 130.4,134.45 130.23,134.45 130.12,134.34 129.69,133.91 v1(129.69,133.64) 129.42,133.64 129.22,133.45 129.2,133.42 VRAM1.J11 v1(128.75,133.02) 128.51,133.26 128.34,133.26 128.06,132.97 126.69,131.61 125.83,131.61 124.9,130.67 124.9,122.27 125.02,122.14 126.15,122.14 126.41,121.88 126.41,121.18 126.15,120.92 125.02,120.92 124.9,120.79 124.9,120.15 132.57,112.49 133.39,112.49 133.86,112.01 133.86,111.62 134.12,111.37 134.37,111.37 134.51,111.51 134.51,111.69 v1(134.4,111.8)
  BOTTOM w0.127: v1(128.75,133.02) VRAM1.J11 ; U22.D31 v1(134.4,111.8)
CLKA1: length 33.8
  TOP w0.127: R773.2 150.84,136.24 150.97,136.12 151.27,136.12 151.52,135.87 151.52,135.23 151.98,134.78 v1(152.64,134.78) 152.64,134.12 153.12,133.63 153.36,133.63 v1(153.57,133.84) 153.57,133.69 153.98,133.28 154.34,133.28 155.75,131.87 155.75,127.05 156.35,126.45 156.35,123.86 150.43,117.94 150.43,113.33 149.61,112.51 148.58,112.51 148.18,112.11 148.18,112 148.29,111.89 v1(148.55,111.89)
  BOTTOM w0.127: v1(153.57,133.84) VRAM2.J12 ; U22.D7 148.55,111.85 v1(148.55,111.89)
CLKA1B: length 34.4
  TOP w0.127: R769.2 150.84,135.76 150.97,135.89 151.18,135.89 151.29,135.77 151.29,135.14 151.72,134.71 v1(151.72,133.89) 152.54,133.89 153.03,133.41 153.2,133.41 v1(153.57,133.04) 153.58,133.05 154.24,133.05 155.52,131.77 155.52,126.95 156.12,126.35 156.12,123.95 150.2,118.03 150.2,113.43 149.51,112.74 148.49,112.74 147.95,112.2 147.95,111.91 148.14,111.72 148.14,111.35 147.79,111 v1(147.5,111)
  BOTTOM w0.127: v1(153.57,133.04) VRAM2.J11 ; U22.D9 147.3,111 v1(147.5,111)
CLKB0: length 37.9
  TOP w0.127: v1(150,110.32) 150,110.19 150.08,110.11 150.24,110.11 151.18,111.05 151.18,111.97 151.73,112.53 152.16,112.53 153.16,113.53 155.22,113.53 155.56,113.87 155.56,116.57 159.61,120.61 168.88,120.61 171.41,118.09 171.41,116.66 171,116.25 171,115.86 171.52,115.34 v1(171.52,115.34) 171.52,114.88 171.85,114.54 v1(172.14,114.54) 172.14,114.26 172.46,113.93 173.03,113.93 173.92,113.05 173.92,112.93 R774.2
  BOTTOM w0.127: U22.G4 149.55,109.87 v1(150,110.32) ; VRAM3.J12 171.41,115.45 171.52,115.34 v1(171.52,115.34)
CLKB0B: length 38.5
  TOP w0.127: v1(149.2,109.3) 149.79,109.88 150.34,109.88 151.4,110.95 151.4,111.88 151.83,112.3 152.25,112.3 153.25,113.3 155.31,113.3 155.79,113.78 155.79,116.47 159.71,120.39 168.79,120.39 171.18,118 171.18,116.75 170.73,116.31 v1(170.73,115.34) 172.35,113.72 172.35,113.71 172.94,113.71 173.69,112.95 173.69,112.65 173.59,112.55 R770.2
  BOTTOM w0.127: VRAM3.J11 171.12,114.95 v1(170.73,115.34) ; U22.J4 149.55,108.95 v1(149.2,109.3)
CLKB1: length 39.7
  TOP w0.127: v2(149.15,96.2) 149.34,96.01 149.34,95.67 149.62,95.39 150.4,95.39 151.13,94.67 151.13,93.72 152.71,92.14 152.71,90.5 153.7,89.5 157.77,89.5 158.44,88.83 158.44,88.65 158.26,88.47 158.26,88.1 158.76,87.61 159.13,87.61 159.3,87.79 159.48,87.79 159.84,87.43 159.84,87.25 159.61,87.01 159.61,86.59 160.02,86.18 160.5,86.18 160.71,86.38 160.89,86.38 162.21,85.05 168.64,85.05 169.63,86.04 169.63,86.64 171.05,88.05 171.05,88.32 171.21,88.48 171.21,88.63 171.51,88.93 v1(171.51,88.95) 171.51,89.38 172.51,90.38 172.51,90.72 172.79,90.99 173.75,90.99 174.83,92.08 175.08,92.08 R775.2
  BOTTOM w0.127: U22.AL5 v2(149.15,96.2) ; v1(171.51,88.95) VRAM4.J12
CLKB1B: length 40.2
  TOP w0.127: R771.2 174.99,92.31 174.74,92.31 173.65,91.22 172.69,91.22 172.28,90.81 172.28,90.48 172.07,90.26 v1(171.75,90.26) 171.75,89.95 171.35,89.55 171.11,89.31 171.07,89.31 v1(170.71,88.95) 170.98,88.68 170.98,88.57 170.82,88.41 170.82,88.14 169.4,86.73 169.4,86.14 168.55,85.28 162.31,85.28 160.98,86.61 160.61,86.61 160.41,86.41 160.12,86.41 159.84,86.69 159.84,86.92 160.07,87.15 160.07,87.52 159.58,88.01 159.21,88.01 159.03,87.84 158.85,87.84 158.49,88.2 158.49,88.38 158.67,88.55 158.67,88.92 157.86,89.73 153.8,89.73 152.94,90.59 152.94,92.23 151.36,93.81 151.36,94.76 150.72,95.39 150.5,95.62 149.71,95.62 149.57,95.76 149.57,95.97 149.74,96.15 v2(150,96.15)
  BOTTOM w0.127: v1(170.71,88.95) 170.74,88.95 171.11,89.32 VRAM4.J11 ; v2(150,96.15) 149.8,96.15 149.55,96.39 U22.AL4
CLKREQB: length 14
  BOTTOM w0.114: Q50.2 121.68,85.55 121.92,85.31 R960.1 R707.1 123.41,85.31 123.89,85.8 123.89,86.49 v1(124.71,87.3) 125.22,87.81 125.66,87.81 127.82,89.97 127.82,91.48 128.92,92.57 129.13,92.57 129.33,92.47 129.53,92.47 129.85,92.8 U22.AV40
CLKRUN#: length 242.8
  TOP w0.114: U34.93 235.34,23.01 233.67,21.34 231.74,21.34 230.24,22.84 v1(225.14,22.84)
  IN1 w0.089: v1(109.64,28.3) 110.12,28.77 110.12,32.69 111.92,34.49 111.92,44.09 110.97,45.04 110.97,68.57 110.73,68.81 110.73,84.69 106.59,88.83 106.59,91.62 100.55,97.67 100.55,100.9 99.74,101.7 99.74,102.4 97.94,104.21 97.94,106.09 94.93,109.1 92.98,109.1 v1(92.7,108.82)
  IN4 w0.089: v1(109.64,28.3) 109.64,26.76 112.85,23.55 117.91,23.55 118.33,23.98 123.63,23.98 125.72,21.88 133.17,21.88 133.72,21.33 139.07,21.33 139.66,21.93 147.6,21.93 148.74,23.06 166.43,23.06 167.05,22.45 169.88,22.45 170.7,23.27 172.04,23.27 172.87,22.45 174.95,22.45 181.09,16.31 189.95,16.31 193.68,20.03 193.68,21.32 197.05,24.7 209.98,24.7 210.46,25.18 212.19,25.18 212.52,24.85 219.21,24.85 220.08,25.72 222.26,25.72 v1(225.14,22.84)
  BOTTOM w0.102: U18.BC11 89.6,108.45 90.41,108.45
  BOTTOM w0.114: 90.41,108.45 90.6,108.26 92.14,108.26 v1(92.7,108.82) ; v1(225.14,22.84) 224.61,23.37 220.6,23.37 R1070.1
COMP_OUT1: length 24.7
  IN4 w0.381: v1(122.16,65.34) 117.47,65.34 116.98,65.83 116.98,68 v1(117.71,68.73)
  BOTTOM w0.381: PU30.1 119.61,60.84 119.71,60.75 PR462.1 PR455.1 120.15,58.57 122.94,58.57 123.22,58.85 PQ63.2 123.22,60.2 123.48,60.45 v1(123.48,62.11) PC9299.2 123.48,63.46 123.22,63.72 PQ64.2 123.22,64.96 122.84,65.34 v1(122.16,65.34) ; PU30.6 117.07,68.36 117.44,68.73 v1(117.71,68.73)
CORE_PWM_PROCHOT#: length 451.7
  TOP w0.114: v1(202.29,17.14) 203.13,17.98 211.94,17.98 212.28,17.63 Q42.3 ; Q44.3 43.74,103.03 43.58,103.18 43.58,103.87 R481.2 42.65,104.14 42.5,103.99 v1(41.92,103.99) ; v1(64.69,11.84) 64.36,11.51 55.76,11.51 55.22,12.06 PQ43.3 ; v1(197.36,12.22) 197.36,12.5 191.52,18.34 184.7,18.34 178.9,24.14 159.19,24.14 158.66,23.61 139.47,23.61 137.38,25.7 129.31,25.7 128.61,24.99 121.07,24.99 120.99,25.07 117.92,25.07 117.31,24.47 115.65,24.47 115.04,25.08 115.04,25.89 114.88,26.05 114.88,26.95 114.42,27.4 114.42,28.56 115.3,29.43 115.3,30.33 114.68,30.95 114.68,32.15 v1(115.38,32.85) 115.38,33.49 117.62,35.73 117.62,37.05 117.94,37.37 117.94,45.67 122.74,50.47 122.74,52.24 122.05,52.93 122.05,55.41 120.13,57.33 120.13,61.78 119.33,62.58 119.33,70.51 118.15,71.69 117.3,71.69 110.39,78.6 110.39,88.31 113.67,91.59 113.67,115.59 115.96,117.88 115.96,123.02 114.97,124.01 114.97,130.56 117.57,133.15 120.33,133.15 121.93,134.75 121.93,142.94 120.55,144.32 120.49,144.38 PR266.1
  IN3 w0.127: v1(41.92,103.99) 41.54,103.61 41.54,97.52 40.9,96.88 40.9,92.87 36.73,88.7 36.17,88.7 33.78,86.31 33.78,77.95 32.73,76.9 32.73,74.42 33.67,73.48 33.67,70.27 v1(33.21,69.8)
  IN4 w0.089: v1(115.38,32.85) 111.15,37.08 98.63,37.08 94.2,32.65 65.28,32.65 v1(65.14,32.78) 62.21,35.72 38.8,35.72 36.73,37.79 36.73,45.95 34.68,48 34.68,57.95 33.79,58.84 33.79,60.72 33.31,61.2 33.31,69.71 v1(33.21,69.8)
  BOTTOM w0.114: v1(64.69,11.84) 65.02,12.17 65.43,12.17 65.64,12.37 PR215.1 65.64,12.43 64.86,13.21 64.86,15.34 63.64,16.56 63.64,31.28 v1(65.14,32.78) ; PR311.1 41.79,113.77 42,113.56 42,110.86 42.38,110.47 42.38,108.57 42.1,108.29 42.1,106.36 41.34,105.59 v1(41.34,104.86) 41.34,104.58 v1(41.92,103.99) ; v1(197.36,12.22) 199.81,12.22 202.29,14.7 v1(202.29,17.14)
CSA0B_0: length 33.4
  TOP w0.14: v1(134.36,109.46) 133.87,109.96 132.58,109.96 132.07,110.47 131.73,110.81 131.73,111.23 131.79,111.29 131.79,112.03 124.01,119.81 124.01,131.01 126.73,133.74 127.02,133.74 v1(127.91,134.63)
  BOTTOM w0.14: v1(127.91,134.63) 128.3,135.02 VRAM1.G12 ; v1(134.36,109.46) 134.85,108.98 U22.H31
CSA1B_0: length 31.9
  TOP w0.11: 149.03,111.79 148.9,111.66 148.9,111.18 v1(148.69,110.97)
  TOP w0.14: 149.03,111.79 149.2,111.96 149.98,111.96 151.04,113.03 151.04,114.24 151.4,114.59 151.4,118 156.99,123.59 156.99,130.91 157.32,131.23 157.32,133.1 156.7,133.72 v1(156.7,133.81) 156.7,134.51 156.39,134.82 154.97,134.82 v1(154.38,135.41)
  BOTTOM w0.14: v1(154.38,135.41) 154,135.04 VRAM2.L12 ; U22.E7 148.3,110.55 148.69,110.93 v1(148.69,110.97)
CSB0B_0: length 34.6
  TOP w0.102: 172.33,118.48 172.33,117.56 172.72,117.17 172.72,116.75 172.75,116.73 172.75,115.73 v1(172.36,115.34)
  TOP w0.14: 172.33,118.48 v1(171.94,118.86) 169.53,121.27 158.77,121.27 153.58,116.08 153.58,115.17 152.95,114.54 152.8,114.54 152.05,113.79 152.05,113.78 151.54,113.27 151.54,113.02 150.53,112 150.53,111.35 150.28,111.1 149.98,111.1 v1(149.2,110.32)
  BOTTOM w0.14: v1(172.36,115.34) 172.72,115.7 VRAM3.G12 ; U22.G5 148.75,109.87 v1(149.2,110.32)
CSB1B_0: length 35.2
  TOP w0.14: v1(172.31,88.15) 172.31,87.85 v1(171.35,86.88) 171.35,85.66 170.1,84.41 160.55,84.41 156.25,88.71 153.09,88.71 151.77,90.03 150.39,90.03 148.06,92.36 148.06,95.69 v2(147.55,96.2)
  BOTTOM w0.14: VRAM4.L12 v1(172.31,88.15) ; v2(147.55,96.2) 147.15,96.6 U22.AL8
DB_USB3_0_C1: length 2.6
  BOTTOM w0.114: U209.12 21,19.21 R981.2 R984.1
DB_USB3_0_C2: length 4
  BOTTOM w0.114: R982.2 R983.1 ; R983.1 21.31,24.1 21,23.79 U209.6 ; R983.1 22.02,24.1 v1(22.4,23.72)
DB_USB3_1_C1: length 3.8
  BOTTOM w0.114: R985.2 R988.1 ; R985.2 21.45,12.74 v1(22.15,13.44) ; R985.2 21.01,13.11 U210.12
DB_USB3_1_C2: length 2.6
  BOTTOM w0.114: U210.6 21.01,17.55 R986.2 R987.1
DBGDATA_0: length 9.5
  BOTTOM w0.102: 126.18,109.45 126.14,109.49
  BOTTOM w0.114: U22.L40 129.5,107.65 129.2,107.96 126.71,107.96 126.18,108.49 126.18,109.45 ; R944.1 122.95,110.28 124.09,110.28 R945.2 124.91,110.72 126.14,109.49
DBGDATA_1: length 8.1
  BOTTOM w0.114: U22.L41 126.71,107.65 125.96,108.4 125.96,108.96 125.34,109.58 R946.2 124.08,110.04 122.96,110.04 R947.1
DBGDATA_2: length 15.3
  BOTTOM w0.114: R948.2 117.4,110.18 117.62,110.39 v1(117.74,110.39) 117.85,110.29 118.86,110.29 R949.1 120,109.14 125.13,109.14 125.65,108.62 125.65,108.08 126.66,107.08 127.97,107.08 128.22,107.33 129.18,107.33 129.26,107.41 129.54,107.41 129.85,107.1 U22.M40
DBGDATA_3: length 8.1
  BOTTOM w0.114: R951.1 122.96,108.9 124.07,108.9 R950.2 124.96,108.44 126.56,106.84 128.12,106.84 128.38,107.1 U22.M41
DBGDATA_4: length 15.5
  BOTTOM w0.114: U22.N40 129.5,106.55 129.2,106.86 128.77,106.86 128.5,106.6 126.43,106.6 125.02,108 120,108 R953.1 119.1,108.89 116.68,108.89 116.57,108.79 v1(116.57,108.67) 116.57,108.54 116.68,108.44 R952.2
DBGDATA_5: length 13.1
  BOTTOM w0.114: U22.N41 128.86,106.35 126.33,106.35 124.92,107.76 120.03,107.76 R955.1 118.86,108 117.75,108 117.4,107.65 R954.2
